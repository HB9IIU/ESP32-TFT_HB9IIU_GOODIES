#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x3E, 0x00, 0x40, 0x00, 0x7F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x7E,
  0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x78,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xE1, 0xF0, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x7C, 0x7C, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFD, 0xE0, 0xFE, 0xE1, 0x07, 0xE7, 0x00, 0x3F, 0x30, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x06, 0xFE, 0x00,
  0x33, 0xF0, 0x03, 0x9F, 0x98, 0x1C, 0xFC, 0xF0, 0xEF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC,
  0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x7E, 0x7C, 0x0F, 0x80, 0x7C, 0x7C,
  0x1F, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xFC, 0x7C,
  0x7C, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0xF8, 0x00, 0xF8, 0xF9,
  0xF1, 0xFC, 0xFD, 0xF9, 0xF3, 0xFE, 0x7F, 0xF3, 0xE7, 0xFE, 0x7F, 0xF7,
  0xCF, 0xFF, 0x3F, 0xE7, 0xDF, 0x9F, 0x1F, 0x8F, 0x9F, 0x1F, 0x00, 0x1F,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x3F, 0x00, 0xFC, 0x3E, 0x3E, 0x00, 0xF8, 0x3E, 0x3E, 0x01, 0xF0,
  0x3E, 0x7E, 0x03, 0xF0, 0x3E, 0x7C, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xC0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC1,
  0xF8, 0x7F, 0xF8, 0x7F, 0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF3, 0xF8, 0xFE,
  0x7F, 0x7E, 0x3F, 0x8F, 0xFF, 0xC7, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE,
  0x3F, 0x81, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0x7F, 0x8F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF8, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x10, 0x7C, 0x03, 0x0F, 0x80, 0xF9, 0xF0, 0x1F,
  0xFC, 0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xDF, 0x01, 0xF9, 0xF0, 0x1E,
  0x3E, 0x01, 0x87, 0xE0, 0x10, 0x70, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC7, 0xF1,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x7E, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF3, 0xF8, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7E, 0x07, 0xF7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0x7F, 0x7F,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7C, 0xFC, 0x78, 0xFC,
  0x31, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0x3C, 0x1F, 0xC0, 0x60, 0x7F,
  0x01, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0x0F, 0xF0, 0x30, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x20, 0x07, 0xF8, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0,
  0x1F, 0x1F, 0x80, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x06, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x30, 0x07, 0xF8, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFC, 0x08, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC7, 0x00, 0xFC, 0xFE, 0x07, 0xEF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x87,
  0xF0, 0xFE, 0x7F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF9,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFE,
  0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x7F, 0x3F, 0xC3, 0xF3, 0xF8, 0x3F, 0x3F,
  0x83, 0xF3, 0xF0, 0x3F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7,
  0xF8, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0x7E,
  0x0F, 0xE7, 0xE0, 0x38, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x81, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0x8F, 0xF1, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x1E, 0x0F, 0x81, 0xFF, 0x1F, 0x1F, 0x07, 0xFF, 0x9F, 0x1F, 0x0F, 0xFF,
  0x1F, 0x3E, 0x1F, 0xFF, 0x0F, 0x3E, 0x3F, 0x1F, 0x0F, 0x7C, 0x3E, 0x1F,
  0x1F, 0x7C, 0x7C, 0x1E, 0x1F, 0x7C, 0x7C, 0x3E, 0x1F, 0x78, 0x78, 0x3E,
  0x1F, 0x78, 0xF8, 0x3E, 0x1E, 0x78, 0xF8, 0x7C, 0x3E, 0xF8, 0xF8, 0x7C,
  0x3C, 0xF8, 0xF8, 0xFC, 0x7C, 0xF8, 0xFD, 0xFC, 0xF8, 0x78, 0x7F, 0xFF,
  0xF8, 0x78, 0x7F, 0xFF, 0xF0, 0x7C, 0x3F, 0x1F, 0xC0, 0x7C, 0x04, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x04,
  0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07,
  0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01,
  0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03,
  0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF1,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0xFC, 0x1F, 0xF0, 0x18, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x40, 0x7F, 0xEF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xF1, 0xF0, 0x3F, 0xC0, 0x18, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x7F, 0xF3, 0xFC, 0x3F, 0xF9, 0xFC, 0x1F, 0xFC, 0xFE, 0x0F, 0xFC,
  0x7F, 0x0F, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0xC7,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x07,
  0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0x7C, 0x1F, 0xFE, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0xFD, 0xF0,
  0xFD, 0xF8, 0x1F, 0xBE, 0x1F, 0x7F, 0x03, 0xF7, 0xC7, 0xEF, 0xC0, 0x7E,
  0xF8, 0xF9, 0xF8, 0x1F, 0x9F, 0x1F, 0x3F, 0x03, 0xF3, 0xE7, 0xC7, 0xE0,
  0x7E, 0x7C, 0xF9, 0xFC, 0x0F, 0xCF, 0xBF, 0x3F, 0x03, 0xF9, 0xF7, 0xC7,
  0xE0, 0x7E, 0x3F, 0xF8, 0xFC, 0x0F, 0xC7, 0xFE, 0x3F, 0x81, 0xF8, 0xFF,
  0xC7, 0xF0, 0x3F, 0x1F, 0xF0, 0xFC, 0x0F, 0xE3, 0xFE, 0x1F, 0x81, 0xF8,
  0x7F, 0x83, 0xF0, 0x3F, 0x0F, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0x81,
  0xFC, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x03,
  0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x01, 0xF8,
  0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0xF0, 0x1F, 0x81, 0xFF, 0xE0, 0xFE, 0x07,
  0xFF, 0x83, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x7D, 0xF8, 0x3F, 0x03, 0xF7,
  0xF0, 0xFC, 0x0F, 0xCF, 0xC7, 0xF0, 0x3F, 0x3F, 0x1F, 0x80, 0xFC, 0xFC,
  0x7E, 0x03, 0xF3, 0xF9, 0xF8, 0x1F, 0xC7, 0xE7, 0xE0, 0x7E, 0x1F, 0xBF,
  0x81, 0xF8, 0x7E, 0xFC, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F,
  0x01, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x1F, 0xF8, 0x1F, 0x80,
  0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xC7, 0xF8, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F,
  0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1, 0xFE, 0x07,
  0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE1, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xF8, 0x7F, 0xC1, 0xFE,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8,
  0x07, 0xF1, 0xFE, 0x0F, 0xF8, 0x7F, 0xDF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF3, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1,
  0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFE, 0x03, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x08, 0x01, 0xFC, 0x18, 0x07, 0xF0, 0x7E, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80,
  0x7F, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F,
  0xC3, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F,
  0x7E, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x1F, 0xE0,
  0x7F, 0x3F, 0x03, 0xFC, 0x0F, 0xC7, 0xE0, 0xFF, 0x83, 0xF8, 0xFC, 0x1F,
  0xF0, 0x7F, 0x1F, 0x87, 0xFE, 0x0F, 0xC3, 0xF0, 0xFF, 0xC3, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x0F, 0xC7, 0xDF, 0x1F, 0xC1, 0xF8, 0xFB, 0xE3, 0xF8,
  0x3F, 0x3F, 0x7C, 0x7E, 0x07, 0xE7, 0xCF, 0x9F, 0xC0, 0xFD, 0xF9, 0xF3,
  0xF0, 0x1F, 0xBF, 0x3E, 0x7E, 0x03, 0xF7, 0xC7, 0xDF, 0x80, 0x7F, 0xF8,
  0xFB, 0xF0, 0x0F, 0xBE, 0x1F, 0xFE, 0x01, 0xF7, 0xC3, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x80,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0x7E,
  0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x80, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0x81,
  0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC,
  0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3,
  0xF0, 0x0F, 0xBF, 0x00, 0x3E, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0, 0x7C, 0x1E, 0x01, 0xFC,
  0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0xFC, 0x7F, 0x83, 0xF1, 0xFC,
  0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xBE, 0x01, 0xF8,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x7E, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1,
  0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xF7, 0xFF,
  0x07, 0xDF, 0xF8, 0x3F, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xC3, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x02, 0x0F, 0xE1,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF9, 0xFC, 0x03, 0xFD, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0x87,
  0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0x80, 0x1F, 0xCF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F,
  0xE7, 0xF1, 0xFC, 0x3F, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x7F, 0x07, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x18, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xE2, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xDF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x03, 0xFE, 0xFC, 0x0F,
  0xFD, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x82, 0x00, 0xFE, 0x07, 0x83,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x7E, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xBF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xF8, 0x3F, 0x80, 0xFC, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F,
  0xC0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x07,
  0xC7, 0xF0, 0x7E, 0x03, 0xE7, 0xFC, 0xFF, 0x81, 0xF7, 0xFE, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x8F, 0xF9, 0xFC,
  0x3F, 0x87, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC1, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x07,
  0xF3, 0xF8, 0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xC1,
  0xFC, 0x7E, 0x0F, 0xE0, 0xFE, 0x3F, 0x07, 0xF0, 0x7F, 0x3F, 0x83, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0x1F, 0x8F, 0xE0, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE,
  0x0F, 0xE3, 0xF0, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x83, 0xF0, 0x07, 0xC7,
  0xF0, 0x1F, 0x3F, 0xE0, 0x7D, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x7F,
  0x03, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x01, 0xF7, 0xFC, 0x01, 0xF7, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xBF, 0xE0, 0x3F, 0x9F, 0x80,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x0F, 0xFB, 0xF0,
  0x7F, 0xEF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7E, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7D, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0x88, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xEF, 0x87, 0xF0, 0x41, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x80, 0x7F, 0x38, 0x1F, 0xCF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x88, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F,
  0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x3F, 0xC7, 0xF3,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xC0,
  0xFE, 0x7E, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFC, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0,
  0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xEF,
  0xE0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x7E, 0x0F, 0xE0, 0xFE,
  0x7E, 0x1F, 0xE0, 0xFC, 0x7E, 0x1F, 0xE1, 0xFC, 0x7E, 0x3F, 0xE1, 0xF8,
  0x7E, 0x3F, 0xE1, 0xF8, 0x7E, 0x3F, 0xE3, 0xF8, 0x7E, 0x7F, 0xE3, 0xF0,
  0x7E, 0x7F, 0xE7, 0xF0, 0x7E, 0xFB, 0xE7, 0xE0, 0x7E, 0xFB, 0xE7, 0xE0,
  0x7E, 0xFB, 0xEF, 0xC0, 0x7D, 0xF3, 0xEF, 0xC0, 0x7D, 0xF3, 0xEF, 0x80,
  0x7D, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x07,
  0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xC0, 0x01, 0xF7, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x2F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x17, 0xFC,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0,
  0x7F, 0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 31, 12, 0, -30 },
  { 52, 16, 11, 19, 4, -30 },
  { 74, 26, 30, 25, 0, -30 },
  { 172, 21, 34, 22, 1, -32 },
  { 262, 32, 30, 35, 2, -30 },
  { 382, 27, 30, 28, 0, -30 },
  { 484, 8, 11, 10, 4, -30 },
  { 495, 16, 37, 14, 1, -30 },
  { 569, 16, 38, 14, -3, -31 },
  { 645, 19, 20, 21, 3, -32 },
  { 693, 19, 20, 23, 2, -25 },
  { 741, 10, 11, 12, -2, -5 },
  { 755, 11, 6, 13, 1, -14 },
  { 764, 8, 8, 12, 0, -7 },
  { 772, 23, 30, 18, -2, -30 },
  { 859, 21, 30, 22, 1, -30 },
  { 938, 16, 30, 22, 4, -30 },
  { 998, 22, 30, 22, -1, -30 },
  { 1081, 22, 30, 22, 0, -30 },
  { 1164, 22, 30, 22, 0, -30 },
  { 1247, 22, 30, 22, 0, -30 },
  { 1330, 21, 30, 22, 2, -30 },
  { 1409, 23, 30, 22, 1, -30 },
  { 1496, 21, 30, 22, 1, -30 },
  { 1575, 20, 30, 22, 1, -30 },
  { 1650, 12, 24, 12, 0, -23 },
  { 1686, 14, 29, 12, -2, -23 },
  { 1737, 19, 22, 23, 2, -26 },
  { 1790, 19, 14, 23, 2, -22 },
  { 1824, 20, 22, 23, 2, -26 },
  { 1879, 18, 31, 18, 2, -30 },
  { 1949, 32, 34, 34, 1, -30 },
  { 2085, 25, 30, 25, -3, -30 },
  { 2179, 24, 30, 24, 0, -30 },
  { 2269, 24, 30, 23, 2, -30 },
  { 2359, 25, 30, 26, 0, -30 },
  { 2453, 23, 30, 21, 0, -30 },
  { 2540, 22, 30, 21, 0, -30 },
  { 2623, 25, 30, 27, 2, -30 },
  { 2717, 28, 30, 27, 0, -30 },
  { 2822, 20, 30, 16, -1, -30 },
  { 2897, 21, 39, 13, -7, -30 },
  { 3000, 28, 30, 24, 0, -30 },
  { 3105, 18, 30, 20, 0, -30 },
  { 3173, 35, 30, 35, 0, -30 },
  { 3305, 30, 30, 29, 0, -30 },
  { 3418, 25, 30, 28, 2, -30 },
  { 3512, 24, 30, 24, 0, -30 },
  { 3602, 25, 37, 28, 2, -30 },
  { 3718, 24, 30, 24, 0, -30 },
  { 3808, 22, 30, 21, 0, -30 },
  { 3891, 21, 30, 21, 3, -30 },
  { 3970, 25, 30, 27, 2, -30 },
  { 4064, 23, 30, 24, 4, -30 },
  { 4151, 35, 30, 35, 4, -30 },
  { 4283, 29, 30, 24, -2, -30 },
  { 4392, 22, 30, 23, 4, -30 },
  { 4475, 25, 30, 21, -2, -30 },
  { 4569, 18, 37, 14, -1, -30 },
  { 4653, 11, 30, 18, 4, -30 },
  { 4695, 18, 37, 14, -3, -30 },
  { 4779, 21, 19, 21, 0, -30 },
  { 4829, 18, 4, 17, -4, 3 },
  { 4838, 9, 7, 14, 6, -32 },
  { 4846, 22, 23, 23, 1, -23 },
  { 4910, 22, 32, 23, 0, -32 },
  { 4998, 19, 23, 19, 1, -23 },
  { 5053, 24, 32, 23, 1, -32 },
  { 5149, 20, 23, 22, 1, -23 },
  { 5207, 24, 42, 15, -5, -32 },
  { 5333, 23, 33, 23, 0, -23 },
  { 5428, 22, 32, 24, 0, -32 },
  { 5516, 13, 32, 12, 0, -32 },
  { 5568, 18, 42, 12, -5, -32 },
  { 5663, 25, 32, 23, 0, -32 },
  { 5763, 14, 32, 12, 0, -32 },
  { 5819, 33, 23, 35, 0, -23 },
  { 5914, 22, 23, 24, 0, -23 },
  { 5978, 21, 23, 23, 1, -23 },
  { 6039, 24, 33, 23, -2, -23 },
  { 6138, 22, 33, 23, 1, -23 },
  { 6229, 18, 23, 17, 0, -23 },
  { 6281, 18, 23, 19, 0, -23 },
  { 6333, 15, 28, 16, 2, -28 },
  { 6386, 21, 23, 24, 2, -23 },
  { 6447, 21, 23, 21, 2, -23 },
  { 6508, 32, 23, 31, 2, -23 },
  { 6600, 25, 23, 21, -2, -23 },
  { 6672, 26, 33, 21, -3, -23 },
  { 6780, 20, 23, 18, -1, -23 },
  { 6838, 18, 37, 15, 0, -30 },
  { 6922, 5, 42, 21, 8, -32 },
  { 6949, 17, 37, 15, -2, -30 },
  { 7028, 20, 8, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC42PT7B_H_
