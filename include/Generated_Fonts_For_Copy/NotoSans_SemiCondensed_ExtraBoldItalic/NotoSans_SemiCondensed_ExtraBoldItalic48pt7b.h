#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x7F, 0x1F, 0xDF, 0xC7, 0xF7,
  0xF1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0xBF, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF7, 0x3C, 0x0F, 0xE7, 0x04, 0x0F,
  0xE7, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3B, 0xFC, 0x00, 0x39, 0xFC, 0x80, 0x39, 0xFC, 0xE0, 0x73, 0xFC, 0xF8,
  0x73, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x7E,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x03, 0xF7, 0xF0,
  0x1F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0xFC,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE3,
  0xF0, 0x00, 0xF8, 0x7E, 0x7E, 0x3F, 0x0F, 0x8F, 0xCF, 0xC7, 0xFC, 0xFD,
  0xFC, 0xFC, 0xFF, 0xEF, 0xFF, 0x9F, 0x9F, 0xFE, 0xFF, 0xFB, 0xF3, 0xFF,
  0xF7, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0xC7, 0xE7, 0xE3, 0xF0, 0x70, 0xFC,
  0x7E, 0x3F, 0x00, 0x0F, 0x8F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0xF8, 0x07,
  0xE0, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F,
  0xC7, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xCF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xC3, 0xF8,
  0x1F, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0x00, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xF8,
  0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x04, 0x07, 0xE0, 0x38,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xEF, 0x80, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0x03, 0xFD, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3C, 0x3F, 0x00, 0xE1, 0xFC, 0x02, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x1E, 0x1F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F,
  0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F,
  0x0F, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xF7, 0xF1, 0xFC,
  0xFE, 0x1F, 0x3F, 0xC3, 0x87, 0xF8, 0x20, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x01, 0xE0, 0x7F,
  0x80, 0x60, 0x1F, 0xC0, 0x20, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0x81, 0xFF, 0x01,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x10, 0x00,
  0xFF, 0x8F, 0x00, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xE7, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0E, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x80, 0x0F, 0xF8, 0xF0, 0x3F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x82, 0x00, 0x3F, 0x9F, 0xC0, 0x7F,
  0x7F, 0xF0, 0x7F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x83, 0xF8, 0xFF, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xFB, 0xFC, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F,
  0x83, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8,
  0xFF, 0x1F, 0xE0, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFE, 0x07,
  0xF3, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x9F, 0xE1, 0xFF,
  0x3F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xDF, 0xC1, 0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x08, 0x07,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFE, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x1F, 0x80, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xE0,
  0x7F, 0x10, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x01, 0x80, 0x3E, 0x1F, 0x80, 0xFF, 0xC3, 0xE1, 0xF8, 0x3F,
  0xFE, 0x3F, 0x3F, 0x07, 0xFF, 0xE3, 0xF3, 0xE0, 0xFF, 0xFE, 0x1F, 0x7E,
  0x1F, 0xC7, 0xE1, 0xF7, 0xE1, 0xF8, 0x7C, 0x1F, 0x7C, 0x3F, 0x07, 0xC3,
  0xFF, 0xC3, 0xE0, 0xFC, 0x3F, 0xFC, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xC0,
  0xF8, 0x3E, 0xF8, 0x7C, 0x0F, 0x83, 0xEF, 0x87, 0xC1, 0xF8, 0x7E, 0xF8,
  0xFC, 0x1F, 0x87, 0xCF, 0x8F, 0xC3, 0xF0, 0xFC, 0xF8, 0x7C, 0x3F, 0x1F,
  0x8F, 0x87, 0xFF, 0xFF, 0xF8, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0x87, 0xFE,
  0xFF, 0xE0, 0xFC, 0x3F, 0xC7, 0xF8, 0x0F, 0xC0, 0xF8, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x80,
  0x03, 0xFC, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x07, 0xFC, 0x3F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3C, 0x0F, 0xF8, 0x01, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x0C, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF8, 0xFF, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x07, 0xFC, 0x3F, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0x7F, 0x83, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xE0, 0x38, 0x0F, 0xFC, 0x00, 0x40, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xFC, 0x7F, 0x83, 0xFF,
  0xE3, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0x8F,
  0xF0, 0x7F, 0xFC, 0x7F, 0x83, 0xFF, 0xE3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x43,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x1F,
  0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0x81, 0xFB, 0xF8, 0x0F, 0xEF,
  0x81, 0xFB, 0xF8, 0x0F, 0xEF, 0x83, 0xF7, 0xF0, 0x1F, 0xCF, 0x83, 0xF7,
  0xF0, 0x1F, 0xCF, 0x87, 0xE7, 0xF0, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0, 0x1F,
  0xCF, 0xCF, 0xCF, 0xF0, 0x1F, 0xCF, 0xCF, 0xCF, 0xE0, 0x3F, 0x8F, 0xDF,
  0x8F, 0xE0, 0x3F, 0x8F, 0xDF, 0x8F, 0xE0, 0x3F, 0x8F, 0xFF, 0x0F, 0xE0,
  0x3F, 0x8F, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x1F,
  0xC0, 0x7F, 0x0F, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xF8, 0x07,
  0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF0,
  0x3F, 0x80, 0x7F, 0xFC, 0x0F, 0xE0, 0x3F, 0xBF, 0x83, 0xF8, 0x0F, 0xEF,
  0xE0, 0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x80, 0xFE, 0xFF, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF1, 0xFC, 0x07, 0xF1, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x9F, 0xC0, 0x7F, 0x0F, 0xEF, 0xE0, 0x3F, 0x83, 0xFB, 0xF8,
  0x0F, 0xE0, 0xFE, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0x81, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x0F,
  0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x3F, 0x80, 0x3F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xF8, 0x3C, 0x07, 0xF8, 0x04, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x10, 0x01,
  0xFE, 0x0C, 0x01, 0xFF, 0x07, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x1F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x3F,
  0xC0, 0x3F, 0xDF, 0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xFC, 0x0F, 0xF1, 0xFC,
  0x07, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFF,
  0x83, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xC1, 0xFF, 0xE1, 0xFE,
  0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0xFD, 0xF8, 0x7F, 0x03, 0xF8,
  0x7E, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x3F,
  0x3F, 0xC0, 0x7F, 0x3F, 0x9F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8F, 0xCF, 0xE0,
  0x1F, 0xCF, 0xC7, 0xEF, 0xE0, 0x0F, 0xEF, 0xE3, 0xF7, 0xF0, 0x07, 0xF7,
  0xE1, 0xFB, 0xF8, 0x03, 0xFB, 0xF0, 0xFB, 0xF8, 0x01, 0xFF, 0xF0, 0x7D,
  0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xDF, 0xC0,
  0x3F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x0F, 0xF3, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x01,
  0xF9, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x3F, 0xC7, 0xF8, 0xFE, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x3F, 0x07, 0xFF,
  0x7F, 0x0F, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xF7,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x81,
  0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xF8, 0xFF, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0, 0x1F, 0xC7,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x78, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFD, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x01,
  0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x7F, 0xF8, 0x1F,
  0x9F, 0xF8, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xEF,
  0x87, 0xFC, 0x08, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0x0F, 0xF0,
  0x30, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1E,
  0x1F, 0xC0, 0x1F, 0xE7, 0xF0, 0x1F, 0xFD, 0xFC, 0x0F, 0xFF, 0x7F, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xC3, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x03, 0xFE, 0x7E, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xCF, 0xF0, 0x7F,
  0x3F, 0x81, 0xFD, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x43,
  0xFE, 0x1F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFE, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE3, 0xF0, 0x1F, 0xFD,
  0xFC, 0x0F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xDF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1,
  0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFE, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x08, 0x00, 0xFF, 0x03, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF,
  0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF,
  0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F,
  0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xCF, 0xF8,
  0x3F, 0xC0, 0x7F, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0x07,
  0xEF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xF9, 0xFF, 0x01, 0xFD, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7E, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F,
  0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07,
  0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x1F, 0xE0,
  0xFE, 0x7F, 0xC1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F, 0x01, 0xFE,
  0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF,
  0xF0, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0x9F, 0xE0, 0x07, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xDF, 0xFC, 0x03, 0xFB, 0xFF, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x3F, 0x07,
  0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xF7, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFC, 0x7F,
  0x81, 0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x1F,
  0xDF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x8F, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x83, 0x83, 0xFC, 0x04, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF1, 0x00, 0x3F, 0x8C, 0x03, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC1, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xE1, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83,
  0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F,
  0xE3, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xEF, 0xE0, 0x7F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x03,
  0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F,
  0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x7F, 0x80, 0x3F, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x03,
  0xFB, 0xF8, 0x3F, 0xE0, 0x7F, 0x7F, 0x07, 0xFC, 0x1F, 0xEF, 0xE1, 0xFF,
  0x83, 0xF9, 0xFC, 0x3F, 0xF0, 0xFF, 0x3F, 0x87, 0xFE, 0x1F, 0xC7, 0xF1,
  0xFF, 0xC3, 0xF8, 0xFE, 0x3E, 0xF8, 0xFE, 0x1F, 0xCF, 0xDF, 0x1F, 0xC3,
  0xF9, 0xFB, 0xE7, 0xF0, 0x7F, 0x3E, 0x7C, 0xFE, 0x0F, 0xEF, 0xCF, 0x9F,
  0xC1, 0xFD, 0xF3, 0xF7, 0xF0, 0x3F, 0xFE, 0x7E, 0xFE, 0x07, 0xFF, 0xCF,
  0xDF, 0x80, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x40,
  0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 35, 13, 0, -34 },
  { 67, 18, 12, 21, 5, -34 },
  { 94, 29, 34, 28, 0, -34 },
  { 218, 24, 39, 25, 1, -36 },
  { 335, 36, 35, 40, 3, -35 },
  { 493, 30, 35, 32, 1, -35 },
  { 625, 8, 12, 12, 5, -34 },
  { 637, 18, 43, 16, 1, -35 },
  { 734, 17, 43, 16, -3, -35 },
  { 826, 21, 23, 24, 4, -37 },
  { 887, 22, 24, 26, 2, -29 },
  { 953, 12, 12, 13, -3, -6 },
  { 971, 13, 6, 15, 1, -16 },
  { 981, 9, 9, 13, 0, -8 },
  { 992, 26, 35, 20, -2, -35 },
  { 1106, 24, 35, 25, 1, -35 },
  { 1211, 19, 34, 25, 4, -34 },
  { 1292, 25, 35, 25, -1, -35 },
  { 1402, 25, 35, 25, 0, -35 },
  { 1512, 25, 34, 25, 0, -34 },
  { 1619, 24, 34, 25, 1, -34 },
  { 1721, 24, 35, 25, 2, -35 },
  { 1826, 26, 34, 25, 1, -34 },
  { 1937, 24, 35, 25, 1, -35 },
  { 2042, 23, 35, 25, 1, -35 },
  { 2143, 13, 28, 13, 0, -27 },
  { 2189, 16, 33, 13, -3, -27 },
  { 2255, 22, 25, 26, 2, -30 },
  { 2324, 23, 16, 26, 2, -25 },
  { 2370, 23, 25, 26, 2, -30 },
  { 2442, 19, 36, 21, 3, -35 },
  { 2528, 36, 39, 39, 2, -35 },
  { 2704, 29, 34, 29, -3, -34 },
  { 2828, 27, 34, 28, 1, -34 },
  { 2943, 27, 35, 27, 2, -35 },
  { 3062, 28, 34, 30, 1, -34 },
  { 3181, 25, 34, 24, 1, -34 },
  { 3288, 25, 34, 24, 1, -34 },
  { 3395, 29, 35, 31, 2, -35 },
  { 3522, 31, 34, 31, 1, -34 },
  { 3654, 23, 34, 18, -2, -34 },
  { 3752, 24, 44, 15, -8, -34 },
  { 3884, 31, 34, 28, 1, -34 },
  { 4016, 19, 34, 23, 1, -34 },
  { 4097, 40, 34, 40, 1, -34 },
  { 4267, 34, 34, 34, 1, -34 },
  { 4412, 29, 35, 32, 2, -35 },
  { 4539, 27, 34, 27, 1, -34 },
  { 4654, 29, 43, 32, 2, -35 },
  { 4810, 26, 34, 28, 1, -34 },
  { 4921, 25, 35, 24, 0, -35 },
  { 5031, 23, 34, 24, 4, -34 },
  { 5129, 28, 34, 30, 3, -34 },
  { 5248, 27, 34, 27, 4, -34 },
  { 5363, 41, 34, 40, 4, -34 },
  { 5538, 34, 34, 28, -3, -34 },
  { 5683, 26, 34, 26, 4, -34 },
  { 5794, 28, 34, 24, -2, -34 },
  { 5913, 20, 43, 16, -1, -35 },
  { 6021, 12, 35, 20, 5, -35 },
  { 6074, 20, 43, 16, -3, -35 },
  { 6182, 24, 22, 24, 0, -34 },
  { 6248, 20, 4, 19, -4, 4 },
  { 6258, 10, 8, 16, 7, -37 },
  { 6268, 24, 27, 27, 2, -27 },
  { 6349, 25, 36, 27, 0, -36 },
  { 6462, 21, 27, 22, 2, -27 },
  { 6533, 26, 36, 27, 2, -36 },
  { 6650, 22, 27, 25, 2, -27 },
  { 6725, 27, 49, 17, -5, -37 },
  { 6891, 26, 39, 27, 0, -27 },
  { 7018, 25, 36, 27, 0, -36 },
  { 7131, 15, 37, 14, 0, -37 },
  { 7201, 21, 49, 14, -6, -37 },
  { 7330, 28, 36, 26, 0, -36 },
  { 7456, 16, 36, 14, 0, -36 },
  { 7528, 38, 27, 40, 0, -27 },
  { 7657, 25, 27, 27, 0, -27 },
  { 7742, 23, 27, 26, 2, -27 },
  { 7820, 27, 38, 27, -2, -27 },
  { 7949, 24, 39, 27, 2, -27 },
  { 8066, 21, 27, 19, 0, -27 },
  { 8137, 21, 27, 21, 0, -27 },
  { 8208, 18, 32, 19, 2, -32 },
  { 8280, 25, 26, 27, 2, -26 },
  { 8362, 24, 26, 24, 2, -26 },
  { 8440, 35, 26, 36, 3, -26 },
  { 8554, 30, 26, 24, -3, -26 },
  { 8652, 29, 38, 24, -3, -26 },
  { 8790, 23, 26, 21, -1, -26 },
  { 8865, 20, 42, 17, 0, -34 },
  { 8970, 6, 48, 24, 9, -37 },
  { 9006, 20, 42, 17, -3, -34 },
  { 9111, 23, 8, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC48PT7B_H_
