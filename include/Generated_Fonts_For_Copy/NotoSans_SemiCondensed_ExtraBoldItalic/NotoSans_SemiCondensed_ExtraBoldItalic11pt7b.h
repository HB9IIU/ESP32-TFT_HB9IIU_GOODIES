#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x40, 0xCC, 0xDF, 0xB0, 0x14, 0x69, 0xF9, 0x42, 0x9F,
  0x94, 0x28, 0x19, 0xF7, 0x1C, 0x38, 0xAF, 0x98, 0x20, 0x66, 0xA4, 0xA8,
  0xBE, 0xD5, 0x2D, 0x6F, 0xCE, 0x38, 0x58, 0xB1, 0xC7, 0x7B, 0xB7, 0x3F,
  0xF8, 0x12, 0x64, 0x4C, 0xCC, 0xC4, 0x31, 0x11, 0x13, 0x32, 0x6C, 0x37,
  0xDF, 0xE2, 0x00, 0x63, 0x3F, 0xF6, 0x30, 0x78, 0xFC, 0xF0, 0x04, 0x30,
  0x86, 0x30, 0x86, 0x30, 0x39, 0xF6, 0xD3, 0xCB, 0x6D, 0x9C, 0x37, 0xF3,
  0x26, 0x66, 0x39, 0xF0, 0xC6, 0x31, 0x8F, 0xBE, 0x39, 0xF0, 0xCE, 0x38,
  0x69, 0xBC, 0x0C, 0x63, 0x9E, 0x5B, 0xE1, 0x0C, 0x3C, 0xF6, 0x1E, 0x58,
  0x69, 0xBC, 0x1C, 0xF6, 0x1E, 0xEB, 0x2D, 0x9C, 0x7D, 0xF0, 0x86, 0x30,
  0xC6, 0x38, 0x39, 0xB6, 0xCE, 0x7B, 0x6D, 0x9C, 0x39, 0xE4, 0xD3, 0x78,
  0x6B, 0x38, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x06, 0xC0, 0x04, 0x77, 0x38,
  0x1C, 0x10, 0xFF, 0xF0, 0x3F, 0x86, 0x1C, 0x7E, 0x40, 0xFF, 0x36, 0xC0,
  0x8C, 0x1E, 0x18, 0x9B, 0xEA, 0xBF, 0x5F, 0xAB, 0x78, 0x84, 0x3C, 0x00,
  0x0C, 0x38, 0x78, 0xB3, 0x67, 0xD9, 0xE3, 0x3C, 0xF6, 0xDF, 0x79, 0x3D,
  0xFE, 0x3D, 0xEC, 0x30, 0x82, 0x0D, 0x3C, 0x38, 0x79, 0x9B, 0x36, 0x49,
  0xBF, 0x78, 0x3C, 0xF6, 0x1E, 0x79, 0x0F, 0xBC, 0x3C, 0xF6, 0x1E, 0x79,
  0x0C, 0x30, 0x3D, 0xFC, 0x37, 0xBA, 0x6D, 0xBE, 0x36, 0x4D, 0x9B, 0xF7,
  0xC9, 0xB3, 0x66, 0x79, 0x88, 0xC6, 0x31, 0x9C, 0x0C, 0x21, 0x86, 0x18,
  0x61, 0x0C, 0x33, 0x80, 0x36, 0x59, 0xB3, 0xC7, 0x8B, 0x36, 0x66, 0x31,
  0x18, 0xC6, 0x23, 0xFE, 0x31, 0x99, 0xDC, 0xEE, 0xF5, 0x52, 0xEB, 0x6D,
  0xB6, 0x33, 0x33, 0x72, 0x7A, 0x5E, 0x4E, 0xCE, 0xCC, 0x39, 0xFC, 0xF3,
  0x8E, 0x3D, 0xBC, 0x38, 0xF6, 0x5B, 0x79, 0x0C, 0x30, 0x39, 0xFC, 0xF3,
  0x8E, 0x3D, 0xBC, 0x30, 0x60, 0x38, 0xF6, 0xDB, 0x79, 0x6D, 0xB3, 0x3D,
  0xE6, 0x1C, 0x38, 0x6B, 0xBC, 0xFF, 0xD8, 0xC6, 0x23, 0x18, 0x6F, 0x3C,
  0xF2, 0xDA, 0x6D, 0xBC, 0xCF, 0x2D, 0xB6, 0xF3, 0xCE, 0x38, 0xC9, 0xEC,
  0xF6, 0x5F, 0x6E, 0xA5, 0x73, 0xB9, 0x98, 0x33, 0x16, 0x1C, 0x1C, 0x1C,
  0x3C, 0x6C, 0xE6, 0xCF, 0x6D, 0x1C, 0x61, 0x84, 0x30, 0x7D, 0xF1, 0x8C,
  0x71, 0x8C, 0x3E, 0x36, 0x64, 0x44, 0xCC, 0xAC, 0xD9, 0x24, 0x9B, 0x38,
  0xC4, 0x23, 0x18, 0xC4, 0x27, 0x00, 0x11, 0x8E, 0xDC, 0x80, 0xF8, 0xC0,
  0x3D, 0xB4, 0xB2, 0xD9, 0xE0, 0x31, 0x87, 0x9B, 0x4D, 0x3D, 0xBC, 0x3B,
  0x51, 0x8D, 0x38, 0x06, 0x18, 0xF3, 0x64, 0x99, 0x36, 0x3C, 0x39, 0xB7,
  0xBC, 0xC9, 0xE0, 0x1C, 0x43, 0x9C, 0x30, 0xC2, 0x18, 0x63, 0x8C, 0x00,
  0x3D, 0xB4, 0xB2, 0xD9, 0xE1, 0xBC, 0x60, 0x31, 0x87, 0xDB, 0x6D, 0x2D,
  0xB6, 0x30, 0x66, 0x64, 0xCC, 0x18, 0x0C, 0x63, 0x11, 0x8C, 0x66, 0x20,
  0x30, 0xC5, 0xB3, 0xC7, 0x0E, 0x36, 0x6C, 0x36, 0x66, 0x64, 0xCC, 0x7B,
  0xB6, 0xDB, 0x69, 0x2D, 0xB6, 0xD8, 0x7D, 0xB6, 0xD2, 0xDB, 0x60, 0x39,
  0xB4, 0xF2, 0xD9, 0xC0, 0x3C, 0x6C, 0x99, 0x36, 0xCF, 0x18, 0x20, 0xC0,
  0x3D, 0xB4, 0xB2, 0xD9, 0xE1, 0x84, 0x30, 0x7B, 0x98, 0x8C, 0x60, 0x7A,
  0x58, 0x6B, 0x78, 0x23, 0xF8, 0xC4, 0x29, 0x80, 0x6D, 0xB4, 0xD2, 0xD9,
  0xE0, 0x9D, 0xAD, 0x4E, 0x60, 0x9B, 0xBE, 0xBE, 0xF4, 0xDC, 0xD8, 0x36,
  0x78, 0x61, 0xC2, 0x9D, 0x80, 0x26, 0x58, 0xB1, 0x43, 0x86, 0x0C, 0x70,
  0xC0, 0x78, 0x8C, 0xCC, 0x78, 0x19, 0x88, 0x4E, 0x61, 0x08, 0x63, 0x00,
  0xFF, 0xE0, 0x31, 0x84, 0x61, 0x9C, 0x8C, 0xE6, 0x00, 0x66, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 8, 3, 0, -8 },
  { 5, 4, 3, 5, 1, -8 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 6, 9, 6, 0, -8 },
  { 21, 8, 8, 9, 1, -8 },
  { 29, 7, 8, 7, 0, -8 },
  { 36, 2, 3, 3, 1, -8 },
  { 37, 4, 10, 4, 0, -8 },
  { 42, 4, 10, 4, -1, -8 },
  { 47, 5, 5, 6, 1, -8 },
  { 51, 5, 6, 6, 1, -7 },
  { 55, 3, 2, 3, -1, -1 },
  { 56, 3, 2, 3, 0, -4 },
  { 57, 2, 2, 3, 0, -2 },
  { 58, 6, 8, 5, -1, -8 },
  { 64, 6, 8, 6, 0, -8 },
  { 70, 4, 8, 6, 1, -8 },
  { 74, 6, 8, 6, 0, -8 },
  { 80, 6, 8, 6, 0, -8 },
  { 86, 6, 8, 6, 0, -8 },
  { 92, 6, 8, 6, 0, -8 },
  { 98, 6, 8, 6, 0, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 6, 8, 6, 0, -8 },
  { 116, 6, 8, 6, 0, -8 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 4, 7, 3, -1, -6 },
  { 129, 6, 6, 6, 0, -7 },
  { 134, 6, 4, 6, 0, -6 },
  { 137, 5, 6, 6, 1, -7 },
  { 141, 4, 8, 5, 1, -8 },
  { 145, 9, 9, 9, 0, -8 },
  { 156, 7, 8, 7, -1, -8 },
  { 163, 6, 8, 6, 0, -8 },
  { 169, 6, 8, 6, 1, -8 },
  { 175, 7, 8, 7, 0, -8 },
  { 182, 6, 8, 5, 0, -8 },
  { 188, 6, 8, 5, 0, -8 },
  { 194, 6, 8, 7, 1, -8 },
  { 200, 7, 8, 7, 0, -8 },
  { 207, 5, 8, 4, 0, -8 },
  { 212, 6, 10, 4, -2, -8 },
  { 220, 7, 8, 6, 0, -8 },
  { 227, 5, 8, 5, 0, -8 },
  { 232, 9, 8, 9, 0, -8 },
  { 241, 8, 8, 8, 0, -8 },
  { 249, 6, 8, 7, 1, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 10, 7, 1, -8 },
  { 269, 6, 8, 6, 0, -8 },
  { 275, 6, 8, 5, 0, -8 },
  { 281, 5, 8, 5, 1, -8 },
  { 286, 6, 8, 7, 1, -8 },
  { 292, 6, 8, 6, 1, -8 },
  { 298, 9, 8, 9, 1, -8 },
  { 307, 8, 8, 6, -1, -8 },
  { 315, 6, 8, 6, 1, -8 },
  { 321, 6, 8, 5, 0, -8 },
  { 327, 4, 10, 4, 0, -8 },
  { 332, 3, 8, 5, 1, -8 },
  { 335, 5, 10, 4, -1, -8 },
  { 342, 5, 5, 6, 0, -8 },
  { 346, 5, 1, 4, -1, 1 },
  { 347, 2, 1, 4, 2, -8 },
  { 348, 6, 6, 6, 0, -6 },
  { 353, 6, 8, 6, 0, -8 },
  { 359, 5, 6, 5, 0, -6 },
  { 363, 7, 8, 6, 0, -8 },
  { 370, 6, 6, 6, 0, -6 },
  { 375, 6, 11, 4, -1, -8 },
  { 384, 6, 9, 6, 0, -6 },
  { 391, 6, 8, 6, 0, -8 },
  { 397, 4, 8, 3, 0, -8 },
  { 401, 5, 11, 3, -1, -8 },
  { 408, 7, 8, 6, 0, -8 },
  { 415, 4, 8, 3, 0, -8 },
  { 419, 9, 6, 9, 0, -6 },
  { 426, 6, 6, 6, 0, -6 },
  { 431, 6, 6, 6, 0, -6 },
  { 436, 7, 9, 6, -1, -6 },
  { 444, 6, 9, 6, 0, -6 },
  { 451, 5, 6, 4, 0, -6 },
  { 455, 5, 6, 5, 0, -6 },
  { 459, 5, 7, 4, 0, -7 },
  { 464, 6, 6, 6, 0, -6 },
  { 469, 5, 6, 5, 1, -6 },
  { 473, 8, 6, 8, 1, -6 },
  { 479, 7, 6, 6, -1, -6 },
  { 485, 7, 9, 5, -1, -6 },
  { 493, 5, 6, 5, 0, -6 },
  { 497, 5, 10, 4, 0, -8 },
  { 504, 1, 11, 5, 2, -8 },
  { 506, 5, 10, 4, -1, -8 },
  { 513, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC11PT7B_H_
