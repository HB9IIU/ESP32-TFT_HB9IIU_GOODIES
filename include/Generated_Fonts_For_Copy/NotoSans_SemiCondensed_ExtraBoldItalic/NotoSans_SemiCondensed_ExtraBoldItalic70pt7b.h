#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0xE7, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE7,
  0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFE, 0x0F,
  0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF,
  0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xDF, 0x0F, 0x80, 0x3F, 0xF9, 0xF0, 0x30, 0x03, 0xFF,
  0x1E, 0x00, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x03, 0xFF, 0x1E, 0x00, 0x00,
  0x3F, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0xBE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF7, 0xFF, 0x00,
  0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x01, 0xE3, 0xFF, 0x04, 0x00, 0x1E, 0x3F,
  0xF0, 0x60, 0x03, 0xE3, 0xFF, 0x07, 0x80, 0x3E, 0x7F, 0xF0, 0x7F, 0x03,
  0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x07, 0xC0, 0x7F, 0x83,
  0xFE, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFF, 0x0F, 0xFF, 0x87, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xF0,
  0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x00,
  0x00, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xFB, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0x7F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFB, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x1C,
  0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0xE3, 0xF8, 0x00, 0x3F, 0xFB, 0xF8, 0x03, 0x7F, 0xFF, 0xF1, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xE0, 0x7F, 0xC0, 0x01, 0xE0, 0x7F, 0xE0, 0x00, 0xC0, 0x7F, 0x80, 0x00,
  0x40, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0xE1,
  0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xF0,
  0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x1F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xDF,
  0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0x87, 0xFF,
  0x3F, 0xF8, 0x3F, 0xC3, 0xFF, 0x01, 0xF8, 0x7F, 0xF0, 0x1F, 0x07, 0xFF,
  0x00, 0xC0, 0x7F, 0xF0, 0x08, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x1F,
  0x00, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x01, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x10,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x08,
  0x00, 0x00, 0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x80, 0x00, 0x3F, 0xFE, 0x0E, 0x00, 0x07,
  0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xFF, 0x00,
  0x7F, 0xEF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0x9F, 0xF8,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0x83, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x20, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0xFE, 0x1C, 0x00, 0x7F, 0xF0, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0x07, 0xF8,
  0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0xE3, 0xFE, 0x07,
  0xF1, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFC, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xFB, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0xFF,
  0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF9, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x8F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x03, 0x80, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00,
  0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x02, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x7F,
  0xFC, 0x00, 0x1C, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0xF0, 0x00, 0x04,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0x8F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFD, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xBF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00,
  0x7F, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F,
  0xC0, 0x7F, 0xDF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7, 0xFF, 0x00,
  0x3F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x9F,
  0xF0, 0x7F, 0xCF, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFF, 0x80,
  0x1F, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xC7, 0xFC,
  0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFC, 0x7F, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFF, 0x80,
  0x0F, 0xFC, 0x3F, 0xCF, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xF7, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFD, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0xCF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x7F, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xE3, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0xE0, 0x01, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x40, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x03, 0xFF, 0xC0,
  0x7C, 0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x07,
  0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xDF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFB,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x0F, 0xFB, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x7F, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xCF, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x1F, 0xF9, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3,
  0xFE, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC3, 0xFE, 0x7F, 0xE0,
  0x00, 0xFF, 0xDF, 0xF0, 0x7F, 0xDF, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x0F,
  0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF7, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xF3, 0xFF, 0x00,
  0xFF, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80,
  0x3F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0x80, 0x1F,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE1, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFF, 0xBF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0xFF,
  0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xE0, 0x3F,
  0xFE, 0x00, 0x80, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x18,
  0x0F, 0xFF, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0x03, 0xFF, 0x80, 0x03, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x70, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1D, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xC0,
  0x07, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1D, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00,
  0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x00, 0x3F, 0xF7,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x00, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xE3,
  0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xFE, 0x00,
  0x7F, 0xDF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x7F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x3F,
  0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xCF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE1, 0xFF,
  0xC0, 0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xFF, 0xC0, 0x01,
  0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xFD, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF, 0xF8, 0x00, 0xFF,
  0xEF, 0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0x3F, 0xFF,
  0x1F, 0xF0, 0x07, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0xBF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xFD, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xBF, 0xF8, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x83, 0xF0, 0x0F, 0xFE, 0x01, 0xE0, 0x3F,
  0xFC, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x1F, 0xFE,
  0x1E, 0x00, 0x3F, 0xFC, 0x3F, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x20, 0x3F, 0xFE, 0x78, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xF9, 0xFF, 0x00, 0x1F, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xDF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFD, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xDF, 0xE3,
  0xFF, 0x80, 0x7F, 0xC7, 0xF9, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0x9F,
  0xE3, 0xFF, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF,
  0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0xFF, 0xC0, 0x07, 0xFD,
  0xFE, 0x1F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xE1, 0xFE, 0xFF, 0xC0, 0x07,
  0xFD, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x8F, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x8F, 0xFF, 0x80, 0x00, 0xCF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xB0, 0x00, 0x3F, 0xFF, 0x90, 0x00,
  0x07, 0xFF, 0x08, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 22, 51, 20, 0, -50 },
  { 142, 27, 18, 31, 7, -50 },
  { 203, 42, 50, 42, 1, -50 },
  { 466, 36, 57, 36, 1, -53 },
  { 723, 53, 52, 59, 4, -51 },
  { 1068, 45, 52, 46, 1, -51 },
  { 1361, 13, 18, 17, 7, -50 },
  { 1391, 26, 62, 23, 2, -51 },
  { 1593, 26, 62, 23, -5, -51 },
  { 1795, 32, 33, 35, 5, -54 },
  { 1927, 33, 34, 38, 3, -42 },
  { 2068, 18, 18, 19, -4, -9 },
  { 2109, 20, 10, 22, 1, -24 },
  { 2134, 13, 12, 19, 0, -11 },
  { 2154, 38, 52, 30, -3, -51 },
  { 2401, 34, 52, 36, 2, -51 },
  { 2622, 28, 50, 37, 6, -50 },
  { 2797, 38, 51, 36, -2, -51 },
  { 3040, 36, 52, 36, 0, -51 },
  { 3274, 37, 50, 37, -1, -50 },
  { 3506, 36, 51, 36, 1, -50 },
  { 3736, 35, 52, 36, 3, -51 },
  { 3964, 38, 50, 36, 2, -50 },
  { 4202, 36, 52, 36, 1, -51 },
  { 4436, 34, 52, 36, 2, -51 },
  { 4657, 19, 40, 20, 0, -39 },
  { 4752, 23, 48, 20, -4, -39 },
  { 4890, 33, 36, 38, 3, -43 },
  { 5039, 33, 23, 38, 3, -36 },
  { 5134, 33, 36, 38, 3, -43 },
  { 5283, 29, 52, 30, 4, -51 },
  { 5472, 53, 56, 56, 2, -50 },
  { 5843, 41, 50, 42, -4, -50 },
  { 6100, 39, 50, 40, 1, -50 },
  { 6344, 39, 52, 39, 3, -51 },
  { 6598, 41, 50, 44, 1, -50 },
  { 6855, 37, 50, 35, 1, -50 },
  { 7087, 36, 50, 35, 1, -50 },
  { 7312, 42, 52, 45, 3, -51 },
  { 7585, 46, 50, 45, 1, -50 },
  { 7873, 33, 50, 27, -2, -50 },
  { 8080, 35, 65, 22, -11, -50 },
  { 8365, 46, 50, 41, 1, -50 },
  { 8653, 28, 50, 33, 1, -50 },
  { 8828, 58, 50, 58, 1, -50 },
  { 9191, 49, 50, 49, 1, -50 },
  { 9498, 42, 52, 47, 3, -51 },
  { 9771, 39, 50, 39, 1, -50 },
  { 10015, 42, 63, 47, 3, -51 },
  { 10346, 38, 50, 40, 1, -50 },
  { 10584, 36, 52, 35, 0, -51 },
  { 10818, 33, 50, 35, 6, -50 },
  { 11025, 42, 51, 44, 4, -50 },
  { 11293, 39, 50, 39, 6, -50 },
  { 11537, 59, 50, 59, 6, -50 },
  { 11906, 49, 50, 40, -4, -50 },
  { 12213, 38, 50, 38, 6, -50 },
  { 12451, 42, 50, 34, -3, -50 },
  { 12714, 30, 62, 23, -2, -51 },
  { 12947, 17, 52, 30, 7, -51 },
  { 13058, 30, 62, 23, -5, -51 },
  { 13291, 35, 32, 36, 0, -50 },
  { 13431, 30, 7, 28, -7, 5 },
  { 13458, 15, 12, 23, 10, -54 },
  { 13481, 36, 40, 39, 2, -39 },
  { 13661, 36, 54, 39, 0, -53 },
  { 13904, 31, 40, 32, 2, -39 },
  { 14059, 40, 54, 39, 2, -53 },
  { 14329, 33, 40, 36, 2, -39 },
  { 14494, 39, 71, 25, -7, -54 },
  { 14841, 38, 56, 39, 0, -39 },
  { 15107, 37, 53, 39, 0, -53 },
  { 15353, 22, 54, 20, 0, -54 },
  { 15502, 31, 71, 20, -9, -54 },
  { 15778, 41, 53, 38, 0, -53 },
  { 16050, 23, 53, 20, 0, -53 },
  { 16203, 56, 39, 58, 0, -39 },
  { 16476, 37, 39, 39, 0, -39 },
  { 16657, 34, 40, 38, 2, -39 },
  { 16827, 39, 56, 39, -3, -39 },
  { 17100, 36, 56, 39, 2, -39 },
  { 17352, 31, 39, 28, 0, -39 },
  { 17504, 31, 40, 31, 0, -39 },
  { 17659, 26, 47, 27, 3, -46 },
  { 17812, 36, 39, 39, 3, -38 },
  { 17988, 34, 38, 34, 4, -38 },
  { 18150, 52, 38, 52, 4, -38 },
  { 18397, 43, 38, 35, -4, -38 },
  { 18602, 43, 55, 35, -5, -38 },
  { 18898, 34, 38, 30, -2, -38 },
  { 19060, 29, 61, 25, 0, -50 },
  { 19282, 8, 69, 35, 13, -53 },
  { 19351, 29, 61, 25, -4, -50 },
  { 19573, 33, 13, 38, 3, -31 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC70PT7B_H_
