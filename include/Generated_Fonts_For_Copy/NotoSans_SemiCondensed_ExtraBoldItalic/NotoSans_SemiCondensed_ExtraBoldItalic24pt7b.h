#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x40, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xDC, 0xE7, 0x39, 0xDE, 0xE7,
  0x39, 0xC0, 0x03, 0x9C, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x07,
  0xFF, 0xCF, 0xFF, 0x07, 0x30, 0x0C, 0xE0, 0x39, 0xC3, 0xFF, 0xE7, 0xFF,
  0xC1, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x19, 0xC0, 0x73, 0x80, 0x00, 0xC0,
  0x0E, 0x03, 0xFE, 0x3F, 0xE1, 0xFF, 0x1E, 0x80, 0xF4, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x6E, 0x23, 0x71, 0xFF, 0x9F, 0xF8,
  0x7F, 0x80, 0x60, 0x03, 0x00, 0x1F, 0x07, 0x8F, 0xC1, 0x87, 0x70, 0xE1,
  0xDC, 0x70, 0x77, 0x18, 0x39, 0xCE, 0x0E, 0x77, 0x13, 0xB9, 0x9F, 0x7E,
  0xEF, 0xDF, 0x77, 0x70, 0x39, 0xDC, 0x0E, 0x77, 0x07, 0x39, 0xC3, 0x8E,
  0x70, 0xE3, 0xB8, 0x70, 0x7E, 0x38, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xC1,
  0x1F, 0x8E, 0x3F, 0xDE, 0x7B, 0xDC, 0xF1, 0xFC, 0xF1, 0xF8, 0xF8, 0xF0,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x3C, 0x7B, 0x9C, 0xEE, 0x70, 0x07, 0x87,
  0x07, 0x87, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x00, 0x07, 0x03,
  0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x87, 0x80, 0x07,
  0x01, 0xC1, 0x38, 0x7F, 0x1F, 0xFE, 0x3F, 0xCF, 0x8B, 0xF8, 0xF7, 0x04,
  0x70, 0x08, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3D, 0xE7, 0x9C, 0xF3, 0x80,
  0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xC3, 0xFC,
  0xFF, 0x9E, 0xF7, 0x8E, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF1, 0xEE, 0x3D, 0xEF, 0x3F, 0xE7, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE1,
  0xF9, 0xFE, 0xFF, 0x9D, 0xC4, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFE,
  0x18, 0xF0, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x09, 0xFF, 0x8F, 0xFC, 0xFF, 0xE0, 0x0F,
  0xE1, 0xFF, 0x1F, 0xF0, 0x8F, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0xFC, 0x0F,
  0x81, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE8, 0x3E, 0xFF, 0xCF, 0xF8, 0xFF,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xEE, 0x0F, 0xE1,
  0xDE, 0x39, 0xE7, 0x1C, 0x71, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x61, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x1F, 0xE3,
  0xE0, 0x38, 0x07, 0x80, 0x77, 0xCF, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF3, 0xCF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xF9, 0xFF,
  0x9F, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x38, 0xF1, 0xC7, 0x0E, 0x78, 0x7F,
  0x81, 0xF8, 0x1F, 0xC1, 0xFF, 0x1E, 0x78, 0xE1, 0xCF, 0x0E, 0x78, 0xF1,
  0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF9, 0xFF, 0xBC, 0xF7, 0x9F,
  0xE3, 0xFC, 0x7F, 0x9F, 0x7F, 0xEF, 0xFC, 0xF7, 0x01, 0xE0, 0x38, 0x1F,
  0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0x7C, 0xF0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xE3, 0xC7, 0x8F, 0x00, 0x0E, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x20, 0x1C,
  0x0F, 0x87, 0xF3, 0xF1, 0xF8, 0x3C, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x78, 0x3F,
  0x3F, 0x9F, 0xC3, 0xE0, 0x60, 0x08, 0x00, 0x3F, 0x9F, 0xF7, 0xFC, 0x8F,
  0x03, 0xC0, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x07, 0x83, 0xE0, 0x70, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xF0, 0x78,
  0x70, 0x0E, 0x38, 0x71, 0xDC, 0x7F, 0x77, 0x3F, 0x9F, 0x9C, 0xE7, 0xE7,
  0x39, 0xFB, 0x8E, 0x7E, 0xE3, 0x1B, 0x39, 0xCE, 0xEF, 0xFF, 0x39, 0xEF,
  0x8E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x30, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73,
  0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F, 0xFD, 0xE0,
  0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xCF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3,
  0xC7, 0x1E, 0x1E, 0x78, 0xF1, 0xE7, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0x84, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE1,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xF3, 0xE1, 0xE3, 0xC3, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x7E, 0x1F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xFF, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0xF1, 0xFF, 0xCF, 0x82, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x7E,
  0xF1, 0xFB, 0xC7, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xE3, 0xC7, 0xFF,
  0x0F, 0xFC, 0x1F, 0xE0, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3C, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x0F, 0x1F, 0x0E, 0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xE0, 0x79,
  0xE0, 0x79, 0xE0, 0x79, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF8, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0x81, 0xF0,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xEE,
  0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x3F, 0x9D, 0xC3, 0xBB, 0xDC, 0x3B, 0xBB,
  0xC7, 0xBB, 0xBC, 0x7B, 0xF3, 0xC7, 0xBF, 0x38, 0x73, 0xE3, 0x87, 0x1E,
  0x78, 0xF1, 0xC7, 0x80, 0x0F, 0x03, 0x87, 0xC3, 0xC7, 0xE1, 0xE3, 0xF0,
  0xE1, 0xFC, 0x70, 0xFE, 0x38, 0xF7, 0x3C, 0x7B, 0x9E, 0x3D, 0xEE, 0x1C,
  0xF7, 0x0E, 0x3B, 0x8F, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xE1, 0xC1, 0xF0,
  0xE0, 0xF8, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1,
  0xE3, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0xF7, 0x83, 0xEF, 0x07, 0x9F, 0x1F, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F,
  0x80, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x9F, 0x1E, 0x3C, 0x78, 0xF3,
  0xC7, 0xCF, 0x3E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9F, 0x1E, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x3C, 0xF1, 0xE3, 0x8F, 0x3C, 0xF1, 0xE7, 0xFF,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0xCE,
  0x1E, 0xF0, 0xF8, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7C, 0x43, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x61, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x1E, 0x78,
  0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x1F, 0x3E, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCF,
  0x3F, 0x3C, 0xF3, 0xF3, 0xCF, 0x77, 0x78, 0xF7, 0x77, 0x8F, 0xF7, 0x70,
  0xEE, 0x7F, 0x0E, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x87, 0x8F, 0x03, 0xC7,
  0x80, 0xE7, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xE7, 0x81,
  0xF3, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x00, 0xF0, 0xFF, 0x87, 0x9C, 0x78,
  0xF3, 0xC7, 0xBC, 0x3D, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x47,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xC3, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0xE7, 0x39, 0xCE, 0x79,
  0xCE, 0x73, 0x9C, 0xE7, 0x9C, 0xE7, 0x38, 0x07, 0xC3, 0xF0, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x87, 0xC1, 0xF0, 0xFC, 0x00, 0x01, 0x80,
  0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xEE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7,
  0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xF8, 0xE3, 0xC0, 0x1F, 0x73, 0xFF,
  0x7F, 0xF7, 0x9E, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C,
  0xFF, 0xCF, 0xFC, 0x7B, 0x80, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0xF0, 0x7F, 0xC7, 0xFE, 0x3C, 0x71, 0xE3, 0xCE, 0x1C, 0x71,
  0xE7, 0x8F, 0x3C, 0x79, 0xE7, 0x8F, 0xFC, 0xFF, 0xC7, 0x3C, 0x00, 0x1F,
  0xCF, 0xF7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x4F,
  0xF1, 0xFC, 0x3F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF,
  0x1E, 0x78, 0xE3, 0xCF, 0x1F, 0xF8, 0xFD, 0xC3, 0xDC, 0x00, 0x0F, 0xC7,
  0xFD, 0xF7, 0xBC, 0x7F, 0x1F, 0xFF, 0xBF, 0xE7, 0xF0, 0xF0, 0x1E, 0x13,
  0xFE, 0x3F, 0xC3, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x01,
  0xC0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0xBE, 0x03, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xB8,
  0xFF, 0xCF, 0xFE, 0x79, 0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x79,
  0xE3, 0xCF, 0x1F, 0xF8, 0xFF, 0xC3, 0xDE, 0x00, 0xE0, 0x0F, 0x18, 0xF8,
  0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0xF8, 0x7F, 0xC7, 0xFF, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x71,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x3C, 0xF1, 0xE7, 0x8F, 0x00, 0x0F,
  0x1F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x78, 0x70, 0xF0, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x0B, 0xC1, 0xF8, 0x3E,
  0x07, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x79,
  0xF1, 0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x07, 0xBC, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0xC0, 0x0F, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0x70, 0xF0, 0xF0, 0x1D, 0xF3, 0xC3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9E,
  0x3C, 0xF3, 0xC7, 0x9E, 0x79, 0xE3, 0xCE, 0x3C, 0x7B, 0xC7, 0x8E, 0x78,
  0xF3, 0xCF, 0x1C, 0x79, 0xC7, 0x8F, 0x78, 0xF1, 0xEF, 0x1E, 0x78, 0x1D,
  0xF0, 0xFF, 0x8F, 0xFE, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0xE3, 0xCF, 0x1E,
  0x78, 0xF3, 0xC7, 0x1C, 0x79, 0xE3, 0xCF, 0x1E, 0x00, 0x1F, 0xC7, 0xFD,
  0xFF, 0xBC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7B, 0xFF,
  0x3F, 0xC3, 0xF0, 0x0E, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x8E, 0x1E, 0x3C,
  0x70, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xFF, 0x1F, 0xF8,
  0x7B, 0xC1, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x1F, 0x73, 0xFF, 0x7F, 0xF7, 0x9E, 0x71, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xCF, 0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x1D, 0xE3, 0xF8, 0xFF, 0x1F, 0xA3,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x00,
  0x1F, 0xE7, 0xF8, 0xF7, 0x1C, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0x90, 0xF3, 0xFE, 0x7F, 0x8F, 0xE0, 0x0E, 0x0E, 0x07, 0x0F, 0xFF, 0xFF,
  0xF9, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0xF3, 0xF8, 0xFC,
  0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E,
  0xF3, 0xCF, 0x3C, 0xFF, 0xCF, 0xDC, 0x79, 0xC0, 0xF0, 0xFF, 0x1E, 0xF1,
  0xE7, 0x3C, 0x73, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x00, 0xF1, 0xE3, 0xFC, 0xF8, 0xEF, 0x3E, 0x79, 0xCF,
  0x9E, 0x77, 0xEF, 0x1D, 0xFB, 0xC7, 0x6E, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC,
  0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x00, 0x1E, 0x3C,
  0x79, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x78, 0xF1, 0xF0, 0x1E, 0x1E, 0x3C,
  0x78, 0x38, 0xF0, 0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0x70,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x5F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x1F, 0xF1, 0xFF,
  0x1F, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x7F, 0xC7, 0xFC, 0xFF, 0x80, 0x03, 0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x3C, 0x3F, 0x0F, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78,
  0x38, 0x1C, 0x0F, 0x03, 0xC1, 0xE3, 0xF1, 0xE0, 0xE0, 0xF0, 0x78, 0x38,
  0x3C, 0x3E, 0x1E, 0x0E, 0x00, 0x10, 0x3F, 0xC7, 0xFF, 0xE7, 0xF8, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 17, 7, 0, -17 },
  { 18, 10, 6, 11, 2, -17 },
  { 26, 15, 17, 14, 0, -17 },
  { 58, 13, 19, 13, 0, -18 },
  { 89, 18, 17, 20, 1, -17 },
  { 128, 16, 17, 16, 0, -17 },
  { 162, 5, 6, 6, 2, -17 },
  { 166, 9, 21, 8, 1, -17 },
  { 190, 9, 22, 8, -2, -18 },
  { 215, 11, 11, 12, 2, -18 },
  { 231, 11, 11, 13, 1, -14 },
  { 247, 6, 6, 7, -1, -3 },
  { 252, 7, 3, 8, 0, -8 },
  { 255, 4, 4, 7, 0, -4 },
  { 257, 13, 17, 10, -1, -17 },
  { 285, 11, 17, 13, 1, -17 },
  { 309, 10, 17, 13, 2, -17 },
  { 331, 13, 17, 13, -1, -17 },
  { 359, 12, 17, 13, 0, -17 },
  { 385, 12, 17, 13, 0, -17 },
  { 411, 13, 17, 13, 0, -17 },
  { 439, 12, 17, 13, 1, -17 },
  { 465, 13, 17, 13, 1, -17 },
  { 493, 13, 17, 13, 0, -17 },
  { 521, 11, 17, 13, 1, -17 },
  { 545, 7, 13, 7, 0, -13 },
  { 557, 8, 16, 7, -1, -13 },
  { 573, 11, 13, 13, 1, -15 },
  { 591, 11, 7, 13, 1, -12 },
  { 601, 11, 13, 13, 1, -15 },
  { 619, 10, 17, 10, 1, -17 },
  { 641, 18, 19, 19, 1, -17 },
  { 684, 14, 17, 14, -1, -17 },
  { 714, 14, 17, 14, 0, -17 },
  { 744, 14, 17, 13, 1, -17 },
  { 774, 15, 17, 15, 0, -17 },
  { 806, 13, 17, 12, 0, -17 },
  { 834, 13, 17, 12, 0, -17 },
  { 862, 14, 17, 15, 1, -17 },
  { 892, 16, 17, 16, 0, -17 },
  { 926, 12, 17, 9, -1, -17 },
  { 952, 12, 22, 8, -4, -17 },
  { 985, 16, 17, 14, 0, -17 },
  { 1019, 10, 17, 11, 0, -17 },
  { 1041, 20, 17, 20, 0, -17 },
  { 1084, 17, 17, 17, 0, -17 },
  { 1121, 15, 17, 16, 1, -17 },
  { 1153, 14, 17, 14, 0, -17 },
  { 1183, 15, 21, 16, 1, -17 },
  { 1223, 13, 17, 14, 0, -17 },
  { 1251, 13, 17, 12, 0, -17 },
  { 1279, 12, 17, 12, 2, -17 },
  { 1305, 15, 17, 15, 1, -17 },
  { 1337, 14, 17, 13, 2, -17 },
  { 1367, 20, 17, 20, 2, -17 },
  { 1410, 17, 17, 14, -1, -17 },
  { 1447, 13, 17, 13, 2, -17 },
  { 1475, 14, 17, 12, -1, -17 },
  { 1505, 10, 21, 8, -1, -17 },
  { 1532, 5, 17, 10, 3, -17 },
  { 1543, 10, 21, 8, -2, -17 },
  { 1570, 12, 11, 12, 0, -17 },
  { 1587, 10, 2, 10, -2, 2 },
  { 1590, 6, 3, 8, 3, -18 },
  { 1593, 12, 13, 13, 1, -13 },
  { 1613, 13, 18, 13, 0, -18 },
  { 1643, 10, 13, 11, 1, -13 },
  { 1660, 13, 18, 13, 1, -18 },
  { 1690, 11, 13, 13, 1, -13 },
  { 1708, 14, 24, 9, -3, -18 },
  { 1750, 13, 19, 13, 0, -13 },
  { 1781, 13, 18, 13, 0, -18 },
  { 1811, 8, 18, 7, 0, -18 },
  { 1829, 11, 24, 7, -3, -18 },
  { 1862, 14, 18, 13, 0, -18 },
  { 1894, 8, 18, 7, 0, -18 },
  { 1912, 19, 13, 20, 0, -13 },
  { 1943, 13, 13, 13, 0, -13 },
  { 1965, 11, 13, 13, 1, -13 },
  { 1983, 14, 19, 13, -1, -13 },
  { 2017, 12, 19, 13, 1, -13 },
  { 2046, 11, 13, 9, 0, -13 },
  { 2064, 11, 13, 11, 0, -13 },
  { 2082, 9, 16, 9, 1, -16 },
  { 2100, 12, 13, 13, 1, -13 },
  { 2120, 12, 13, 12, 1, -13 },
  { 2140, 18, 13, 18, 1, -13 },
  { 2170, 14, 13, 12, -1, -13 },
  { 2193, 15, 19, 12, -2, -13 },
  { 2229, 12, 13, 10, -1, -13 },
  { 2249, 10, 21, 8, 0, -17 },
  { 2276, 3, 23, 12, 4, -18 },
  { 2285, 9, 21, 8, -1, -17 },
  { 2309, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC24PT7B_H_
