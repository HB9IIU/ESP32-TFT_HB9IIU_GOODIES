#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x18,
  0x00, 0x7F, 0x9F, 0xEF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xE1,
  0xF8, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE2, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xF9, 0xC3, 0x01, 0xFC, 0xE0, 0x00, 0xFE, 0x70,
  0x00, 0x7F, 0x38, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x39, 0xFC, 0x00, 0x1C, 0xFE, 0x20, 0x0E, 0x7F, 0x1C, 0x07, 0x3F, 0x8F,
  0xC7, 0x7F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x01, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0x80, 0x3F, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0x9F, 0x80, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xC0, 0x0F, 0xC7, 0xE0,
  0x7E, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x3E, 0x00, 0x3F,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE1, 0xF0,
  0x00, 0x7E, 0x3F, 0x1F, 0x81, 0x03, 0xF1, 0xF9, 0xF8, 0xFF, 0x1F, 0x9F,
  0x9F, 0x8F, 0xFC, 0xFF, 0xFC, 0xFC, 0xFF, 0xF7, 0xFF, 0xCF, 0xCF, 0xFF,
  0x9F, 0xFE, 0xFC, 0xFF, 0xFC, 0xFF, 0xE7, 0xE7, 0xE3, 0xF3, 0xFC, 0x7E,
  0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x0F,
  0xC0, 0xFC, 0x7E, 0x00, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC1,
  0xFE, 0x0F, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFD, 0xFE, 0x7F, 0x8F, 0xF3, 0xFE, 0xFF, 0x3F, 0xE3, 0xFF, 0xFC,
  0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0x83,
  0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x7F, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F,
  0xBF, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xC1, 0xF8, 0x07, 0x87,
  0xE0, 0x1F, 0x9F, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0xC3,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x07, 0xF9, 0xF8, 0x0F, 0xC7,
  0xE0, 0x0E, 0x1F, 0xC0, 0x18, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x7F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE,
  0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF8,
  0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xBF,
  0x83, 0xF3, 0xF8, 0x3C, 0x7F, 0x81, 0x87, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xCF, 0xFC,
  0x07, 0xC0, 0xFF, 0x00, 0xC0, 0x3F, 0xC0, 0x20, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x07, 0x83, 0xFE, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x98, 0x00, 0xFF, 0x8F, 0x00,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x07,
  0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x81,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x10,
  0x01, 0xFF, 0x0F, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFC, 0x02, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFC, 0xFF, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xF7, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F,
  0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0xE3, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x83, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF,
  0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0x7F, 0x87, 0xFE, 0xFF,
  0x9F, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0x7F, 0x87, 0xFC, 0xFE, 0x03, 0xF3, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x10, 0x1F, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x1F, 0x80, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3E,
  0x0F, 0xF1, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x03, 0xFC, 0x1F,
  0x87, 0xE0, 0x7F, 0xFC, 0x7C, 0x3F, 0x07, 0xFF, 0xE3, 0xE3, 0xF0, 0x7F,
  0xFE, 0x1F, 0x9F, 0x07, 0xFF, 0xF0, 0xFD, 0xF8, 0x7F, 0x0F, 0x87, 0xEF,
  0xC3, 0xF0, 0xFC, 0x3F, 0x7C, 0x3F, 0x07, 0xE1, 0xF7, 0xE1, 0xF0, 0x3E,
  0x0F, 0xBF, 0x1F, 0x83, 0xF0, 0x7D, 0xF0, 0xFC, 0x1F, 0x83, 0xEF, 0x87,
  0xE0, 0xFC, 0x3F, 0x7C, 0x3E, 0x07, 0xC1, 0xF3, 0xE1, 0xF0, 0x7E, 0x1F,
  0x9F, 0x0F, 0x83, 0xF0, 0xF8, 0xF8, 0x7E, 0x3F, 0x8F, 0xC7, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3E, 0x1F, 0xFF, 0xFF, 0xC1, 0xF8, 0x7F, 0xEF, 0xFC, 0x0F,
  0xC1, 0xFC, 0x7F, 0xC0, 0x7E, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x40, 0x01, 0xFE,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0,
  0xF8, 0x0F, 0xFC, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x18, 0x07, 0xFF, 0x1F, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFE, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x07, 0xFE, 0x00, 0x60, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC1, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0x1F, 0xE0, 0xFF, 0xF8, 0xFF,
  0x07, 0xFF, 0xCF, 0xF8, 0x3F, 0xFE, 0x7F, 0xC1, 0xFF, 0xE3, 0xFE, 0x10,
  0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x43, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0,
  0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80,
  0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xF3, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0xFD,
  0xFC, 0x0F, 0xEF, 0xC1, 0xFF, 0xFC, 0x0F, 0xEF, 0xC1, 0xFB, 0xF8, 0x0F,
  0xEF, 0xC3, 0xFB, 0xF8, 0x1F, 0xEF, 0xC3, 0xF3, 0xF8, 0x1F, 0xCF, 0xC7,
  0xF7, 0xF8, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0,
  0x1F, 0xCF, 0xCF, 0xC7, 0xF0, 0x3F, 0xCF, 0xCF, 0xC7, 0xF0, 0x3F, 0x8F,
  0xDF, 0x8F, 0xF0, 0x3F, 0x8F, 0xDF, 0x8F, 0xE0, 0x3F, 0x8F, 0xFF, 0x0F,
  0xE0, 0x3F, 0x8F, 0xFF, 0x0F, 0xE0, 0x7F, 0x8F, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xFC,
  0x1F, 0xC0, 0x7F, 0x0F, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x07, 0xF0,
  0x3F, 0xF8, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x01,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFE,
  0x07, 0xF0, 0x1F, 0xBF, 0x81, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF, 0x03, 0xFB,
  0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x0F, 0xE0, 0x3F, 0x9F, 0xC3, 0xF8, 0x1F,
  0xE7, 0xF0, 0xFE, 0x07, 0xF1, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0x9F, 0xC0,
  0x7F, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xF0, 0xFF, 0x7F,
  0x03, 0xF8, 0x1F, 0xDF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0x80, 0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0xFF,
  0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0,
  0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01,
  0xFE, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF,
  0xCF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x9F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF1, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE3, 0xE0, 0x1F, 0xE0, 0x18, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x04, 0x00, 0x7F, 0x81, 0xC0, 0x3F,
  0xE0, 0x7F, 0x3F, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xC7, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF0, 0x07, 0xFB, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xFC, 0x07,
  0xF8, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0xC0, 0xFF, 0x0F,
  0xF0, 0x7F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFF, 0xC3, 0xFC, 0x0F, 0xE1, 0xFF, 0xF0,
  0xFF, 0x03, 0xF8, 0x7E, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xBF, 0x1F, 0xE0,
  0x3F, 0x8F, 0xEF, 0xC7, 0xF0, 0x0F, 0xE3, 0xF3, 0xF3, 0xFC, 0x03, 0xF9,
  0xFC, 0xFC, 0xFF, 0x00, 0xFE, 0x7E, 0x3F, 0x3F, 0x80, 0x3F, 0xBF, 0x8F,
  0xDF, 0xE0, 0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0xFD, 0xFC,
  0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF,
  0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF,
  0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xF0, 0x1F, 0xF3, 0xF8,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F, 0x83,
  0xFE, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0,
  0x7F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0x01, 0xF9, 0xFF,
  0x80, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xC3, 0x87,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0x0F, 0xF8, 0x38,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x03, 0xF1, 0xFE, 0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0xF7, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE3,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFB, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0xCF, 0xF8, 0x7F, 0x9F, 0xE0, 0xFF, 0x7F, 0x81, 0xFC, 0xFF,
  0x07, 0xF9, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x06, 0x1F, 0xF9, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x1F,
  0xF9, 0xFC, 0x07, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE1, 0xFF, 0x03, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xCF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x06, 0x00, 0xFF, 0x80, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xEF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x7E,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xF0,
  0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0xFE, 0x07, 0xF0, 0x07, 0xE7, 0xFE, 0x1F, 0xF0, 0x1F, 0xDF, 0xFC,
  0x7F, 0xF0, 0x3F, 0xFF, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xFC, 0x7F, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x0F, 0xE1, 0xFE, 0x07,
  0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC3, 0xF8, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xF1, 0xFE, 0x00, 0xFC, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F,
  0xE0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F,
  0xCF, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xCF, 0xF8, 0x01, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE1,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFC,
  0x01, 0xFD, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x81, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xFC,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x8F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF7, 0xF0, 0x07,
  0xF3, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7F,
  0x81, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xC4, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0xF8, 0x7F,
  0x81, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF9, 0x00, 0x3F, 0xCE,
  0x03, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC1, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F,
  0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF1, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xF7, 0xE0, 0x7F, 0xF3, 0xF0,
  0x1F, 0xF9, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0x7E, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F,
  0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFE, 0xFE, 0x07, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0xC1, 0xFE, 0xFE, 0x0F,
  0xFC, 0x1F, 0xCF, 0xE1, 0xFF, 0xC3, 0xFC, 0xFE, 0x1F, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFF, 0xC7, 0xF8, 0xFE, 0x3F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0xC7,
  0xF0, 0xFE, 0x3E, 0xFC, 0xFE, 0x0F, 0xE7, 0xEF, 0xCF, 0xE0, 0xFE, 0x7C,
  0xFD, 0xFE, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0xFE, 0xFC, 0xFD, 0xFC, 0x0F,
  0xEF, 0x8F, 0xBF, 0x80, 0xFF, 0xF8, 0xFB, 0xF8, 0x0F, 0xFF, 0x8F, 0xBF,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFE, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 36, 14, 0, -35 },
  { 73, 19, 13, 22, 5, -35 },
  { 104, 30, 35, 29, 0, -35 },
  { 236, 25, 40, 26, 1, -37 },
  { 361, 37, 35, 41, 3, -35 },
  { 523, 31, 35, 32, 1, -35 },
  { 659, 9, 13, 12, 5, -35 },
  { 674, 19, 43, 16, 1, -35 },
  { 777, 19, 44, 16, -4, -36 },
  { 882, 22, 24, 25, 4, -38 },
  { 948, 23, 24, 27, 2, -29 },
  { 1017, 13, 12, 14, -3, -6 },
  { 1037, 14, 6, 15, 1, -16 },
  { 1048, 9, 9, 14, 0, -8 },
  { 1059, 26, 35, 21, -2, -35 },
  { 1173, 24, 36, 26, 1, -36 },
  { 1281, 20, 35, 26, 4, -35 },
  { 1369, 26, 35, 26, -1, -35 },
  { 1483, 25, 35, 26, 0, -35 },
  { 1593, 25, 35, 26, 0, -35 },
  { 1703, 25, 35, 26, 1, -35 },
  { 1813, 25, 36, 26, 2, -36 },
  { 1926, 27, 35, 26, 1, -35 },
  { 2045, 25, 36, 26, 1, -36 },
  { 2158, 23, 36, 26, 2, -36 },
  { 2262, 13, 28, 14, 0, -27 },
  { 2308, 16, 33, 14, -3, -27 },
  { 2374, 23, 25, 27, 2, -30 },
  { 2446, 23, 16, 27, 2, -25 },
  { 2492, 23, 25, 27, 2, -30 },
  { 2564, 20, 36, 21, 3, -35 },
  { 2654, 37, 39, 39, 2, -35 },
  { 2835, 29, 35, 29, -3, -35 },
  { 2962, 27, 35, 28, 1, -35 },
  { 3081, 28, 36, 27, 2, -36 },
  { 3207, 29, 35, 31, 1, -35 },
  { 3334, 25, 35, 24, 1, -35 },
  { 3444, 25, 35, 24, 1, -35 },
  { 3554, 29, 36, 31, 2, -36 },
  { 3685, 32, 35, 32, 1, -35 },
  { 3825, 24, 35, 19, -2, -35 },
  { 3930, 24, 46, 16, -8, -35 },
  { 4068, 32, 35, 29, 1, -35 },
  { 4208, 19, 35, 23, 1, -35 },
  { 4292, 40, 35, 41, 1, -35 },
  { 4467, 34, 35, 34, 1, -35 },
  { 4616, 30, 36, 33, 2, -36 },
  { 4751, 27, 35, 28, 1, -35 },
  { 4870, 30, 44, 33, 2, -36 },
  { 5035, 27, 35, 28, 1, -35 },
  { 5154, 26, 35, 24, 0, -35 },
  { 5268, 24, 35, 24, 4, -35 },
  { 5373, 29, 35, 31, 3, -35 },
  { 5500, 28, 35, 27, 4, -35 },
  { 5623, 42, 35, 41, 4, -35 },
  { 5807, 35, 35, 28, -3, -35 },
  { 5961, 27, 35, 26, 4, -35 },
  { 6080, 29, 35, 24, -2, -35 },
  { 6207, 20, 43, 16, -1, -35 },
  { 6315, 12, 35, 21, 5, -35 },
  { 6368, 20, 43, 16, -3, -35 },
  { 6476, 24, 23, 25, 0, -35 },
  { 6545, 21, 4, 19, -5, 4 },
  { 6556, 11, 8, 16, 7, -38 },
  { 6567, 25, 27, 27, 2, -27 },
  { 6652, 26, 37, 27, 0, -37 },
  { 6773, 21, 27, 22, 2, -27 },
  { 6844, 27, 37, 27, 2, -37 },
  { 6969, 23, 27, 26, 2, -27 },
  { 7047, 28, 49, 17, -5, -37 },
  { 7219, 27, 39, 27, 0, -27 },
  { 7351, 26, 37, 27, 0, -37 },
  { 7472, 16, 38, 14, 0, -38 },
  { 7548, 22, 50, 14, -6, -38 },
  { 7686, 29, 37, 26, 0, -37 },
  { 7821, 16, 37, 14, 0, -37 },
  { 7895, 39, 27, 41, 0, -27 },
  { 8027, 26, 27, 27, 0, -27 },
  { 8115, 23, 27, 27, 2, -27 },
  { 8193, 28, 39, 27, -2, -27 },
  { 8330, 25, 39, 27, 2, -27 },
  { 8452, 22, 27, 19, 0, -27 },
  { 8527, 21, 27, 22, 0, -27 },
  { 8598, 18, 32, 19, 2, -32 },
  { 8670, 25, 27, 27, 2, -27 },
  { 8755, 24, 27, 24, 3, -27 },
  { 8836, 36, 27, 37, 3, -27 },
  { 8958, 30, 27, 25, -3, -27 },
  { 9060, 30, 39, 24, -3, -27 },
  { 9207, 23, 27, 21, -1, -27 },
  { 9285, 21, 43, 17, 0, -35 },
  { 9398, 6, 48, 24, 9, -37 },
  { 9434, 20, 43, 17, -3, -35 },
  { 9542, 23, 9, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC49PT7B_H_
