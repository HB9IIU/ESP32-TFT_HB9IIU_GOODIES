#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x79, 0xEF, 0x79, 0xEF,
  0x39, 0xE7, 0x38, 0xE7, 0x3C, 0xE0, 0x01, 0xCE, 0x03, 0x8C, 0x03, 0x9C,
  0x03, 0x9C, 0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1C, 0xE0,
  0x39, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0x00, 0x80, 0x0C, 0x01,
  0xF8, 0x3F, 0xF3, 0xFF, 0x1E, 0xB8, 0xEC, 0x0F, 0x60, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF2, 0x17, 0x9D, 0xBC, 0xFF, 0xE7,
  0xFE, 0x1F, 0xC0, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x01, 0xC1, 0xF8,
  0x38, 0x3F, 0x87, 0x87, 0xB8, 0x70, 0x73, 0x8E, 0x07, 0x39, 0xE0, 0xF3,
  0x9C, 0x0F, 0x7B, 0x80, 0xF7, 0x7B, 0xE7, 0xF7, 0x7F, 0x7E, 0xEF, 0x73,
  0xDE, 0xE7, 0x01, 0xCE, 0x70, 0x39, 0xE7, 0x07, 0x9C, 0xF0, 0x71, 0xCE,
  0x0E, 0x1F, 0xE1, 0xE0, 0xFC, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x1F,
  0xE0, 0x07, 0xE0, 0x0F, 0xE3, 0xCF, 0xF3, 0xCF, 0xFD, 0xE7, 0x9F, 0xE7,
  0xCF, 0xF3, 0xE3, 0xF1, 0xF1, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xEF,
  0xC0, 0x7B, 0xDE, 0xE7, 0x3B, 0xC0, 0x03, 0x83, 0x83, 0xC3, 0xC1, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x0F,
  0x00, 0x07, 0x80, 0x70, 0x47, 0x06, 0x70, 0xFE, 0x7F, 0xFF, 0x1F, 0xF1,
  0xF3, 0x3F, 0x07, 0xB8, 0x33, 0xC1, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x3D, 0xE7, 0x9E, 0xF3, 0x80, 0x7F, 0x7E, 0x7E, 0xFE,
  0x7F, 0xFF, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xF3, 0xFF, 0x3C, 0xF7, 0xCF, 0x78, 0xF7,
  0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF,
  0x7C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x3F, 0x0F, 0xE7,
  0xFD, 0xF7, 0x9D, 0xE1, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1F,
  0xE1, 0xFF, 0xC3, 0xFF, 0x0E, 0x3C, 0x10, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0x87, 0xFE,
  0x3F, 0xF0, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C, 0x03,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xD8, 0x7E, 0xFF, 0xE7, 0xFE,
  0x1F, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x03, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0x9E, 0x1C, 0x78, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xBF, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x38, 0xF8, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xF8,
  0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x78, 0x77,
  0xE7, 0xFF, 0x3E, 0x7D, 0xF1, 0xEF, 0x1F, 0x78, 0xF3, 0xC7, 0x9F, 0x7C,
  0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x9F, 0xFE,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xDF, 0x1E, 0x3C,
  0x78, 0xE1, 0xE7, 0x87, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x0F, 0x7C,
  0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x3E, 0x3C, 0x7F, 0xF1, 0xFF, 0x81, 0xF8,
  0x00, 0x07, 0x81, 0xFE, 0x3F, 0xF3, 0xFF, 0x78, 0xF7, 0x8F, 0x78, 0xFF,
  0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xEE, 0x19, 0xE0, 0x1E, 0x03, 0xC8,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE7, 0xCF, 0x9E, 0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0,
  0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xC7, 0xE0, 0xF8, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x3F, 0x0F, 0xE7, 0xF8, 0xFC,
  0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x87, 0xF9, 0xFF, 0x9F, 0xF2, 0x1E, 0x03,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x1F, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0xF0, 0x1C, 0x1C, 0x00, 0xE3, 0x87, 0xCE, 0x79, 0xFE,
  0x67, 0x3F, 0xE7, 0x73, 0x9C, 0x6E, 0x71, 0xC6, 0xE7, 0x1C, 0xEE, 0x71,
  0xCE, 0xE7, 0x38, 0xCE, 0x77, 0x9C, 0xE7, 0xFF, 0x8E, 0x3D, 0xF0, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xDE, 0x03, 0xDE, 0x07, 0x9E, 0x07, 0x8E, 0x07, 0x8E, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F,
  0xF8, 0x0F, 0x0F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE3,
  0xC3, 0xC7, 0x8F, 0x8F, 0x3E, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xE3,
  0xC3, 0xC7, 0xCF, 0x8F, 0x9E, 0x1E, 0x3C, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3,
  0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xF0, 0x87,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x70, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E,
  0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x04, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0xFE, 0xF8, 0xFC, 0xF9, 0xFC, 0xF9, 0xFC,
  0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78, 0x7E, 0x78, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF1, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x7F, 0x87, 0xFC,
  0x3F, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0x80, 0x70, 0x00, 0x0F, 0x07, 0x87, 0x87, 0xC3,
  0xC7, 0xC1, 0xE7, 0xC1, 0xF3, 0xC0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDF, 0x03, 0xE7,
  0x81, 0xE3, 0xC0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x3C, 0x3E, 0x1F, 0x00,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xFF, 0x7F, 0xEF,
  0xFB, 0xFF, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0x71,
  0xDC, 0x1D, 0xCF, 0xF0, 0xF7, 0x3B, 0xC3, 0xDC, 0xEF, 0x0F, 0x77, 0x3C,
  0x39, 0xDC, 0xE1, 0xE7, 0xE7, 0x87, 0x9F, 0x9E, 0x1E, 0x7E, 0x78, 0x79,
  0xF1, 0xE1, 0xC7, 0xCF, 0x0F, 0x1E, 0x3C, 0x00, 0x0F, 0x81, 0xE1, 0xF0,
  0x38, 0x3F, 0x0F, 0x07, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF8,
  0xE0, 0xEF, 0x3C, 0x1D, 0xE7, 0x87, 0x9C, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B,
  0x83, 0xCF, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7E,
  0x0E, 0x07, 0xC3, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C,
  0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E,
  0x7C, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x1F,
  0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0x7D, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x7C, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF8, 0xF0, 0xF3, 0xE1, 0xF0, 0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0x87,
  0xFE, 0x1E, 0x10, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x88, 0x1E, 0x3C, 0xF8, 0xFF, 0xE3,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78,
  0x78, 0xF8, 0x78, 0xF8, 0xF8, 0x7D, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xC0, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x8E, 0x1E,
  0x1C, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x87, 0xBC, 0x3E, 0x1E,
  0xF0, 0xF8, 0xFB, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0xFE, 0x78, 0xF3,
  0xB9, 0xE3, 0xCE, 0xEF, 0x0F, 0x7B, 0xBC, 0x3D, 0xCE, 0xF0, 0xFF, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x1F,
  0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F, 0x87,
  0xC3, 0xE0, 0x78, 0x00, 0xF8, 0x3D, 0xE1, 0xF7, 0x8F, 0x9E, 0x3C, 0x79,
  0xF1, 0xE7, 0x83, 0xBC, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0xE3, 0x8F,
  0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3,
  0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x84, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3B, 0x83, 0x8E, 0x3C, 0x71,
  0xC3, 0x9E, 0x1D, 0xE0, 0x70, 0xFF, 0xFF, 0xF8, 0xF7, 0x9E, 0x70, 0x02,
  0x00, 0xF9, 0xCF, 0xFE, 0x7F, 0xF7, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE, 0x1E,
  0xF0, 0xF7, 0x8F, 0x3C, 0x79, 0xF7, 0xCF, 0xFE, 0x7F, 0xF1, 0xF7, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x79, 0x01, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0xF9, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C, 0x78, 0xE1,
  0xE7, 0x87, 0x9E, 0x3E, 0x7D, 0xF1, 0xFF, 0xCF, 0xFE, 0x3D, 0xF0, 0x01,
  0x01, 0xFC, 0xFF, 0x9F, 0xE7, 0xC4, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x19, 0xE1, 0xF7, 0x8F, 0xFE, 0x3F, 0xF9,
  0xF3, 0xC7, 0x8F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78,
  0xF3, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0x70, 0x01, 0x00, 0xFE, 0x1F, 0xF3,
  0xFF, 0x78, 0xF7, 0x8F, 0xF3, 0xFF, 0xFE, 0xFF, 0x8F, 0x00, 0xF0, 0x0F,
  0x04, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xA0, 0x1E, 0x00, 0x3C, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x3F, 0x71, 0xFF,
  0xC7, 0xFF, 0x3E, 0x78, 0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE3,
  0xC7, 0x8F, 0x1F, 0x7C, 0x7F, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x78, 0x01,
  0xE2, 0x0F, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x81, 0xFF, 0x87, 0xFE, 0x1F, 0xFC,
  0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0x9E, 0x3E,
  0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0x3C, 0x7C, 0x07, 0x0F, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x87, 0xE0,
  0xFC, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8, 0x79, 0xE0, 0xF7, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xE3, 0xE3, 0xC7, 0x87, 0xC0, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8,
  0xF0, 0x00, 0x20, 0x40, 0xEF, 0xCF, 0x87, 0x7E, 0xFC, 0x3F, 0xFF, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF3, 0xC3, 0xC7, 0x9E, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x7C,
  0x78, 0xF3, 0xC7, 0xC7, 0x80, 0x00, 0x20, 0x77, 0xE1, 0xDF, 0x87, 0xFF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x8F,
  0x9E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x1F, 0x00, 0x01, 0x00, 0xFE, 0x3F,
  0xE3, 0xFF, 0x7C, 0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xEF, 0x3E, 0xFF, 0xC7, 0xFC, 0x3F, 0x00, 0x00, 0x20, 0x1D, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE1, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1C, 0x3C,
  0x78, 0x78, 0xF1, 0xF1, 0xF7, 0xC3, 0xFF, 0x8F, 0x7E, 0x1E, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x02,
  0x00, 0xFD, 0xCF, 0xFE, 0x7F, 0xF7, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE, 0x1E,
  0xF0, 0xF7, 0x8F, 0x3C, 0x79, 0xF7, 0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x23,
  0x9C, 0x77, 0x8F, 0xF3, 0xFC, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0x02, 0x03, 0xFC, 0xFF, 0x9F,
  0xF3, 0xC4, 0x78, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x43, 0xEF,
  0xFD, 0xFF, 0x3F, 0xC0, 0x0E, 0x03, 0x81, 0xE1, 0xFF, 0xFF, 0xBF, 0xE3,
  0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x4F, 0xE3, 0xF8,
  0x7E, 0x00, 0x3C, 0x79, 0xE3, 0xDF, 0x1E, 0xF0, 0xF7, 0x8F, 0x3C, 0x79,
  0xE3, 0xDE, 0x1E, 0xF1, 0xF7, 0x8F, 0x3C, 0xF9, 0xFF, 0xCF, 0xFE, 0x3E,
  0xF0, 0xF0, 0x7B, 0x87, 0x9C, 0x3C, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1E, 0x00,
  0xE1, 0xE3, 0xFC, 0x7C, 0x7B, 0x8F, 0x8F, 0x73, 0xF3, 0xCE, 0x7E, 0x79,
  0xCF, 0xDE, 0x3B, 0xBB, 0xC7, 0x77, 0x70, 0xFC, 0xFE, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x00, 0x1E, 0x3F,
  0x1F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7C, 0xF0, 0x78, 0xF0,
  0xF8, 0xF8, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0xFF, 0xC7, 0xFC, 0x7F, 0xE0, 0x00, 0x20, 0x7C, 0x1F, 0x83, 0xE0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08,
  0x03, 0xC1, 0xF0, 0x7E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0x7C, 0x0F, 0x0F, 0xC7, 0xE1, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0,
  0xF8, 0x3E, 0x0E, 0x00, 0x7E, 0x1F, 0xFF, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 11, 7, 11, 2, -19 },
  { 30, 16, 19, 15, 0, -19 },
  { 68, 13, 22, 14, 1, -20 },
  { 104, 20, 19, 22, 1, -19 },
  { 152, 17, 19, 17, 0, -19 },
  { 193, 5, 7, 6, 2, -19 },
  { 198, 9, 23, 8, 1, -19 },
  { 224, 10, 23, 9, -2, -19 },
  { 253, 12, 12, 13, 2, -20 },
  { 271, 12, 13, 14, 1, -16 },
  { 291, 6, 6, 7, -1, -3 },
  { 296, 8, 4, 8, 0, -9 },
  { 300, 5, 4, 7, 0, -4 },
  { 303, 14, 19, 11, -1, -19 },
  { 337, 12, 19, 14, 1, -19 },
  { 366, 11, 19, 14, 2, -19 },
  { 393, 14, 19, 14, -1, -19 },
  { 427, 13, 19, 14, 0, -19 },
  { 458, 14, 19, 14, 0, -19 },
  { 492, 14, 19, 14, 0, -19 },
  { 526, 13, 19, 14, 1, -19 },
  { 557, 14, 19, 14, 1, -19 },
  { 591, 14, 19, 14, 0, -19 },
  { 625, 12, 19, 14, 1, -19 },
  { 654, 7, 14, 7, 0, -14 },
  { 667, 8, 17, 7, -1, -14 },
  { 684, 12, 13, 14, 1, -16 },
  { 704, 12, 8, 14, 1, -13 },
  { 716, 12, 13, 14, 1, -16 },
  { 736, 11, 19, 11, 1, -19 },
  { 763, 20, 21, 21, 1, -19 },
  { 816, 16, 19, 15, -2, -19 },
  { 854, 15, 19, 15, 0, -19 },
  { 890, 15, 19, 15, 1, -19 },
  { 926, 16, 19, 16, 0, -19 },
  { 964, 14, 19, 13, 0, -19 },
  { 998, 14, 19, 13, 0, -19 },
  { 1032, 16, 19, 17, 1, -19 },
  { 1070, 17, 19, 17, 0, -19 },
  { 1111, 13, 19, 10, -1, -19 },
  { 1142, 13, 25, 8, -4, -19 },
  { 1183, 17, 19, 15, 0, -19 },
  { 1224, 11, 19, 12, 0, -19 },
  { 1251, 22, 19, 22, 0, -19 },
  { 1304, 19, 19, 18, 0, -19 },
  { 1350, 16, 19, 17, 1, -19 },
  { 1388, 15, 19, 15, 0, -19 },
  { 1424, 16, 23, 17, 1, -19 },
  { 1470, 15, 19, 15, 0, -19 },
  { 1506, 14, 19, 13, 0, -19 },
  { 1540, 13, 19, 13, 2, -19 },
  { 1571, 16, 19, 17, 1, -19 },
  { 1609, 15, 19, 15, 2, -19 },
  { 1645, 22, 19, 22, 2, -19 },
  { 1698, 19, 19, 15, -2, -19 },
  { 1744, 14, 19, 14, 2, -19 },
  { 1778, 15, 19, 13, -1, -19 },
  { 1814, 11, 23, 8, -1, -19 },
  { 1846, 6, 19, 11, 3, -19 },
  { 1861, 11, 23, 8, -2, -19 },
  { 1893, 13, 12, 13, 0, -19 },
  { 1913, 11, 2, 10, -2, 2 },
  { 1916, 5, 4, 9, 4, -20 },
  { 1919, 13, 15, 14, 1, -15 },
  { 1944, 14, 20, 14, 0, -20 },
  { 1979, 11, 15, 12, 1, -15 },
  { 2000, 14, 20, 14, 1, -20 },
  { 2035, 12, 15, 14, 1, -15 },
  { 2058, 15, 26, 9, -3, -20 },
  { 2107, 14, 21, 14, 0, -15 },
  { 2144, 14, 20, 15, 0, -20 },
  { 2179, 8, 20, 7, 0, -20 },
  { 2199, 11, 26, 7, -3, -20 },
  { 2235, 15, 20, 14, 0, -20 },
  { 2273, 8, 20, 7, 0, -20 },
  { 2293, 21, 15, 22, 0, -15 },
  { 2333, 14, 15, 15, 0, -15 },
  { 2360, 12, 15, 14, 1, -15 },
  { 2383, 15, 21, 14, -1, -15 },
  { 2423, 13, 21, 14, 1, -15 },
  { 2458, 11, 15, 10, 0, -15 },
  { 2479, 11, 15, 12, 0, -15 },
  { 2500, 10, 17, 10, 1, -17 },
  { 2522, 13, 14, 15, 1, -14 },
  { 2545, 13, 14, 13, 1, -14 },
  { 2568, 19, 14, 19, 2, -14 },
  { 2602, 16, 14, 13, -1, -14 },
  { 2630, 16, 20, 13, -2, -14 },
  { 2670, 13, 14, 11, -1, -14 },
  { 2693, 11, 23, 9, 0, -19 },
  { 2725, 3, 26, 13, 5, -20 },
  { 2735, 10, 23, 9, -1, -19 },
  { 2764, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC26PT7B_H_
