#ifndef _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07,
  0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF1,
  0xEF, 0x3C, 0xF3, 0xCE, 0x3C, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x07, 0x9E, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0xF3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x1E, 0x78, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x1F,
  0x62, 0x3C, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0x7D, 0x06, 0xFB, 0x8F, 0xE7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F,
  0x80, 0xF8, 0x7F, 0x81, 0xE1, 0xFF, 0x07, 0x83, 0xDE, 0x1E, 0x0F, 0x3C,
  0x3C, 0x1E, 0x78, 0xF0, 0x3C, 0xF3, 0xC0, 0x79, 0xE7, 0x80, 0xE3, 0x9E,
  0x31, 0xCF, 0x79, 0xFB, 0xFE, 0xF7, 0xFF, 0xFB, 0xDF, 0xF7, 0xEF, 0x3D,
  0xE0, 0x1E, 0xF3, 0xC0, 0x79, 0xE7, 0x81, 0xE3, 0xCF, 0x03, 0xC7, 0x1E,
  0x0F, 0x0E, 0x78, 0x3C, 0x1C, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0x7F, 0x87,
  0x80, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7C,
  0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0x9F, 0x00, 0x7B, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF1, 0xF1, 0xFF, 0x1F, 0x3F, 0xFB, 0xE7,
  0xCF, 0xBE, 0x7C, 0xFF, 0xCF, 0x87, 0xFC, 0xF8, 0x3F, 0x8F, 0xC3, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0xFE, 0x7D, 0xE7,
  0x9E, 0xF3, 0xCF, 0x3C, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x00, 0x01, 0x00, 0x0F,
  0x80, 0x3C, 0x08, 0xF0, 0x7B, 0xC1, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFC, 0x7F, 0x03, 0xFE, 0x1F, 0x78, 0x38, 0xF0, 0x23, 0xC0, 0x08, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78,
  0xF8, 0x7F, 0xBF, 0xDF, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xF3, 0xF3, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF3, 0xF3, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x3F, 0x0F, 0xE1, 0xFE, 0x7F, 0xEF, 0xFE, 0xFB, 0xE7, 0x3C,
  0x47, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x01, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0x71, 0xF8, 0x30, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x04, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xC0, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x07, 0xBC, 0x0F, 0x7C,
  0x1E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x78, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0xC0, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x40,
  0x7D, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFC, 0xFC, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xF9, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x8F, 0x8F, 0xBE, 0x1F, 0xFC, 0x1F, 0xE0, 0x3F, 0x81,
  0xFF, 0x87, 0xFF, 0x9F, 0x9F, 0x3E, 0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xF1,
  0xF3, 0xF7, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F,
  0x7C, 0x7E, 0xF8, 0xFD, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0x0F, 0xC7, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x03,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0x07, 0xF8,
  0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0x40, 0x00, 0x1F,
  0xE7, 0xFF, 0x7F, 0xF7, 0xFF, 0x20, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0xF0, 0x01, 0xE3, 0xC0,
  0x03, 0xCF, 0x0F, 0xF3, 0x9C, 0x3F, 0xE7, 0x78, 0xF3, 0x8E, 0xE3, 0xC7,
  0x1D, 0xC7, 0x1E, 0x3F, 0x9E, 0x3C, 0x7F, 0x3C, 0x71, 0xFE, 0x70, 0xE3,
  0xFC, 0xE3, 0xC7, 0x79, 0xEF, 0x9E, 0xF3, 0xFF, 0xF9, 0xE3, 0xE7, 0xE1,
  0xC3, 0x87, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x08, 0x07, 0xE1, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D,
  0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x3D, 0xF8, 0x07,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x8F,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x3F, 0x87, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF8, 0x3E, 0x7F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0x83, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x83, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C,
  0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x3F, 0x8F, 0x8F, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x08, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x87, 0xF9, 0xF1, 0xFE, 0x3E, 0x3F,
  0xC7, 0xC7, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0xC3, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x80, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0xDF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0x80, 0x00,
  0x07, 0xC1, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0xF8,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xBE,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7C, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x7F, 0xF8, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF1, 0xEF, 0x07, 0xBC, 0x7B, 0xC1, 0xEF, 0x3D, 0xF0, 0x7B, 0xCF,
  0x7C, 0x3E, 0xF7, 0x9F, 0x0F, 0xBD, 0xE7, 0x83, 0xCF, 0x73, 0xE0, 0xF3,
  0xFC, 0xF8, 0x3C, 0xFF, 0x3E, 0x1F, 0x3F, 0x8F, 0x07, 0xCF, 0xE3, 0xC1,
  0xE3, 0xF1, 0xF0, 0x78, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x07, 0xE0,
  0x3C, 0x1F, 0x81, 0xF0, 0xFE, 0x07, 0xC3, 0xFC, 0x1F, 0x0F, 0xF0, 0x78,
  0x3F, 0xC1, 0xE0, 0xFF, 0x0F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0xF0, 0x79,
  0xE3, 0xC1, 0xE7, 0xDF, 0x07, 0x9F, 0x7C, 0x3E, 0x7D, 0xF0, 0xF8, 0xF7,
  0x83, 0xE3, 0xFE, 0x0F, 0x0F, 0xF8, 0x3C, 0x1F, 0xE1, 0xF0, 0x7F, 0x87,
  0xC1, 0xFC, 0x1E, 0x07, 0xF0, 0x78, 0x0F, 0xC3, 0xE0, 0x3F, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E,
  0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7F, 0xF8, 0x0F, 0xBF, 0x03, 0xF3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F,
  0x87, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0,
  0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0,
  0x7D, 0xF8, 0x0F, 0xBF, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0xC7,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x9F, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xF7, 0xC0, 0xF8, 0x03, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x86, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x80, 0xF8, 0xE1, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF8, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83,
  0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E,
  0x7C, 0x1F, 0x3C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x83, 0xEF, 0x07, 0xE0, 0xFB, 0xC1,
  0xF8, 0x7C, 0xF0, 0x7E, 0x1F, 0x3C, 0x3F, 0x87, 0xCF, 0x0F, 0xE3, 0xE3,
  0xC7, 0xF8, 0xF8, 0xF1, 0xFE, 0x7C, 0x3C, 0xFF, 0x9F, 0x0F, 0x3D, 0xE7,
  0x83, 0xCF, 0x7B, 0xE0, 0xF7, 0x9E, 0xF8, 0x3D, 0xE7, 0xBC, 0x0F, 0xF9,
  0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F,
  0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC,
  0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00,
  0x7E, 0x7E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x83, 0xF0,
  0x3F, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7E, 0x78, 0x7C, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7D, 0xF0, 0x7D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0xF0, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xEE, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x38, 0xF0, 0x79, 0xE0,
  0xF7, 0x81, 0xFE, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xF8,
  0xF1, 0xF1, 0xE0, 0x07, 0xCF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xF3,
  0xE0, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7E, 0x11, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x23,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0xBE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFD, 0xE0, 0x7C, 0xE0, 0x07, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF9, 0xF3, 0xE3, 0xEF, 0x87, 0x9F, 0x1F, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x81, 0x1F, 0xDE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0x90, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x03, 0xE7, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x8F, 0xC7, 0xC7, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x10, 0x1F, 0x0F, 0x7F, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x7E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0x03, 0x81, 0xF0, 0x7C, 0x3F, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x38, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x3F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xF3,
  0xE0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0x0F, 0x7E, 0x3E, 0x0F, 0x7F, 0x3F, 0x87, 0xBF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x7C, 0x3C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F,
  0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xE1, 0xF1,
  0xF1, 0xF0, 0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x7C, 0x00, 0x0F, 0x7E,
  0x1E, 0xFF, 0x1E, 0xFF, 0x1F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x07, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xF7, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x07, 0xC7, 0x87, 0xC7, 0xC3, 0xE3, 0xF3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFB, 0xF8, 0x7D, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x7C, 0x7F, 0xE1, 0xEF,
  0x87, 0xFE, 0x1F, 0xF0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0x8F, 0xDC, 0x3E, 0x10, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x81, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x1F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0x80, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0x78, 0x3E,
  0x78, 0xF0, 0x3F, 0xE0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E,
  0x3E, 0x7C, 0x7D, 0xF0, 0xFB, 0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF0, 0xFC, 0x3F,
  0xE1, 0xF8, 0xFB, 0xC3, 0xF1, 0xF7, 0x8F, 0xE7, 0xCF, 0x1F, 0xCF, 0x9E,
  0x7F, 0x9E, 0x3C, 0xFF, 0x7C, 0x79, 0xDE, 0xF0, 0xF7, 0xBF, 0xE1, 0xEE,
  0x77, 0x83, 0xFC, 0xEF, 0x07, 0xF9, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x0F, 0xC7,
  0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF0,
  0xFC, 0x3F, 0x00, 0x0F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xBE,
  0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0xFE, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x00,
  0x18, 0x02, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 22, 9, 0, -22 },
  { 29, 12, 8, 14, 3, -22 },
  { 41, 19, 22, 18, 0, -22 },
  { 94, 15, 26, 16, 1, -24 },
  { 143, 23, 22, 26, 2, -22 },
  { 207, 20, 22, 20, 0, -22 },
  { 262, 6, 8, 8, 3, -22 },
  { 268, 11, 27, 10, 1, -22 },
  { 306, 11, 28, 10, -2, -23 },
  { 345, 14, 15, 16, 2, -24 },
  { 372, 15, 15, 17, 1, -18 },
  { 401, 8, 8, 9, -2, -4 },
  { 409, 9, 4, 10, 0, -10 },
  { 414, 6, 5, 9, 0, -5 },
  { 418, 16, 22, 13, -1, -22 },
  { 462, 15, 22, 16, 1, -22 },
  { 504, 12, 22, 16, 3, -22 },
  { 537, 17, 22, 16, -1, -22 },
  { 584, 16, 22, 16, 0, -22 },
  { 628, 16, 22, 16, 0, -22 },
  { 672, 16, 22, 16, 0, -22 },
  { 716, 16, 22, 16, 1, -22 },
  { 760, 17, 22, 16, 1, -22 },
  { 807, 15, 22, 16, 1, -22 },
  { 849, 15, 22, 16, 1, -22 },
  { 891, 9, 17, 9, 0, -17 },
  { 911, 11, 21, 9, -2, -17 },
  { 940, 15, 16, 17, 1, -19 },
  { 970, 15, 10, 17, 1, -16 },
  { 989, 15, 16, 17, 1, -19 },
  { 1019, 12, 22, 13, 2, -22 },
  { 1052, 23, 25, 25, 1, -22 },
  { 1124, 19, 22, 18, -2, -22 },
  { 1177, 18, 22, 18, 0, -22 },
  { 1227, 18, 22, 17, 1, -22 },
  { 1277, 19, 22, 19, 0, -22 },
  { 1330, 17, 22, 15, 0, -22 },
  { 1377, 17, 22, 15, 0, -22 },
  { 1424, 19, 22, 20, 1, -22 },
  { 1477, 21, 22, 20, 0, -22 },
  { 1535, 15, 22, 12, -1, -22 },
  { 1577, 15, 29, 10, -5, -22 },
  { 1632, 21, 22, 18, 0, -22 },
  { 1690, 13, 22, 15, 0, -22 },
  { 1726, 26, 22, 26, 0, -22 },
  { 1798, 22, 22, 22, 0, -22 },
  { 1859, 19, 22, 21, 1, -22 },
  { 1912, 18, 22, 17, 0, -22 },
  { 1962, 19, 27, 21, 1, -22 },
  { 2027, 17, 22, 18, 0, -22 },
  { 2074, 16, 22, 15, 0, -22 },
  { 2118, 15, 22, 15, 2, -22 },
  { 2160, 18, 22, 20, 2, -22 },
  { 2210, 17, 22, 17, 3, -22 },
  { 2257, 26, 22, 26, 3, -22 },
  { 2329, 22, 22, 18, -2, -22 },
  { 2390, 16, 22, 17, 3, -22 },
  { 2434, 18, 22, 15, -1, -22 },
  { 2484, 13, 27, 10, -1, -22 },
  { 2528, 8, 22, 13, 3, -22 },
  { 2550, 13, 27, 10, -2, -22 },
  { 2594, 15, 14, 16, 0, -22 },
  { 2621, 13, 3, 12, -3, 2 },
  { 2626, 7, 5, 10, 4, -24 },
  { 2631, 16, 17, 17, 1, -17 },
  { 2665, 16, 24, 17, 0, -24 },
  { 2713, 14, 17, 14, 1, -17 },
  { 2743, 17, 24, 17, 1, -24 },
  { 2794, 15, 17, 16, 1, -17 },
  { 2826, 17, 31, 11, -3, -24 },
  { 2892, 17, 24, 17, 0, -17 },
  { 2943, 16, 24, 17, 0, -24 },
  { 2991, 10, 24, 9, 0, -24 },
  { 3021, 14, 31, 9, -4, -24 },
  { 3076, 18, 24, 17, 0, -24 },
  { 3130, 10, 24, 9, 0, -24 },
  { 3160, 25, 17, 26, 0, -17 },
  { 3214, 16, 17, 17, 0, -17 },
  { 3248, 15, 17, 17, 1, -17 },
  { 3280, 17, 24, 17, -1, -17 },
  { 3331, 16, 24, 17, 1, -17 },
  { 3379, 14, 17, 12, 0, -17 },
  { 3409, 14, 17, 14, 0, -17 },
  { 3439, 12, 21, 12, 1, -21 },
  { 3471, 16, 17, 17, 1, -17 },
  { 3505, 15, 17, 15, 2, -17 },
  { 3537, 23, 17, 23, 2, -17 },
  { 3586, 19, 17, 16, -2, -17 },
  { 3627, 19, 24, 15, -2, -17 },
  { 3684, 15, 17, 13, -1, -17 },
  { 3716, 13, 27, 11, 0, -22 },
  { 3760, 3, 31, 15, 6, -24 },
  { 3772, 13, 27, 11, -2, -22 },
  { 3816, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRABOLDITALIC31PT7B_H_
