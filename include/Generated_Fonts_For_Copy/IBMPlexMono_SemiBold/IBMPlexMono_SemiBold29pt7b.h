#ifndef _IBMPLEXMONO_SEMIBOLD29PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x71, 0x8C, 0x40, 0x00, 0x0F, 0xFF,
  0xFE, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0x80, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0,
  0x38, 0xE1, 0xFC, 0x7E, 0xFE, 0x7F, 0x7F, 0x3F, 0x83, 0x9C, 0x03, 0x8E,
  0x1F, 0xC7, 0xEF, 0xE3, 0xF7, 0xF3, 0xF8, 0x39, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x7F, 0x81, 0xFF, 0xC7, 0xFF, 0xDE, 0x67, 0x38, 0xC4, 0x71,
  0x80, 0xF3, 0x01, 0xF6, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x80, 0xCF, 0x01, 0x8E, 0x03, 0x1D, 0x86, 0x7F, 0xCC, 0xF7, 0xFF, 0xC7,
  0xFF, 0x03, 0xF8, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1E, 0x03, 0xBF,
  0x81, 0x9F, 0xE1, 0xDC, 0x70, 0xCE, 0x18, 0xE7, 0x0C, 0x63, 0x8E, 0x70,
  0xFF, 0x30, 0x7F, 0x38, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xEF, 0xE0, 0xE7,
  0xF8, 0xE7, 0x1C, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xE3, 0xB8, 0x3F, 0xDC,
  0x1F, 0xDC, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0x8F,
  0x03, 0xC2, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0x8F,
  0x87, 0xCF, 0xE3, 0xEF, 0x79, 0xC7, 0x1E, 0xC3, 0x87, 0xE3, 0xC3, 0xF0,
  0xE0, 0xF8, 0x78, 0x7C, 0x3F, 0xEF, 0x0F, 0xF3, 0xC1, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0xF8, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x3C, 0x3E, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x06, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC,
  0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF3, 0xC3, 0xC7, 0x83, 0x07, 0x82,
  0x08, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x3E, 0x79, 0xF3, 0xC7, 0x8F, 0x1C, 0x78,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7,
  0x81, 0xCE, 0x03, 0xFC, 0x07, 0xF9, 0xCF, 0xF3, 0x9F, 0xE7, 0xBF, 0xCE,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x7C, 0x3C,
  0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7D, 0xE0, 0xF9, 0xE0, 0x71, 0xE0, 0x71, 0xE0, 0x21, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xC6, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0,
  0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC3, 0xE3, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC8, 0x07, 0xB8, 0x1F, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0,
  0x7F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0x78,
  0x07, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x78, 0x78,
  0x70, 0x78, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0xF8, 0x77, 0xF8, 0xEF,
  0xF9, 0xF0, 0xF8, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC8, 0x07, 0x98, 0x0F,
  0xF8, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0xF8, 0x7B,
  0xF8, 0xEF, 0xFB, 0xF0, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07,
  0xBC, 0x0F, 0x7C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x7B, 0x81, 0xEE, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xEE, 0x03, 0xDE, 0x07, 0x1E, 0x1E,
  0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0x78, 0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x1E, 0xF8, 0x7D, 0xFF, 0xF9, 0xFE, 0xE0, 0xFB, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFD, 0xE0, 0x3C,
  0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xE7, 0xCF, 0x1E,
  0x3C, 0x71, 0xE3, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x03, 0xE0, 0x1C, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xF1,
  0xFF, 0x07, 0x90, 0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0xE0, 0x7E, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0x01,
  0xCE, 0x01, 0xDC, 0x7B, 0xB1, 0xFF, 0xE3, 0xFF, 0xCF, 0x1F, 0x9C, 0x3F,
  0x38, 0x7E, 0x70, 0xFC, 0xE1, 0xF8, 0xFF, 0xB1, 0xFF, 0x71, 0xEE, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0x70, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x03, 0x83,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x70, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x01, 0xFE, 0x00, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFF, 0xBC, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1,
  0xE7, 0x81, 0xEF, 0x03, 0x9E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x07, 0xBC, 0x0F, 0x3C,
  0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x3C, 0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0,
  0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF,
  0x03, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x01, 0xFE, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x7C, 0x3E, 0x7F, 0xFC,
  0x7F, 0x78, 0x7C, 0xF0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0x03,
  0xFC, 0x1E, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xF0, 0x3F, 0xE0,
  0x7B, 0xC1, 0xE7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0xF0, 0x7B, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x9E, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x7C, 0xF0, 0x79, 0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xF0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCD, 0xFF, 0xFB, 0xFB, 0xF7, 0xF7,
  0xCF, 0xE7, 0x9F, 0xCE, 0x3F, 0x9C, 0x7F, 0x18, 0xFE, 0x21, 0xFC, 0x43,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x70, 0xF8, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8, 0xFD, 0xC7, 0xE7,
  0x3F, 0x39, 0xF9, 0xEF, 0xC7, 0x7E, 0x3B, 0xF1, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE1, 0xE7, 0x81, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0xBC,
  0x0F, 0x7C, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xE1, 0xE7, 0x81, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07,
  0xBC, 0x0F, 0x7C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF,
  0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF,
  0xEF, 0xFF, 0x3F, 0xF0, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xFB,
  0xE1, 0xE7, 0x80, 0x8F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xD0, 0x07, 0xB0, 0x0F,
  0xF8, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xBC, 0x1E, 0xF8, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0xF8,
  0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70,
  0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0xF3, 0x80, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE3, 0xCF, 0xE3, 0xCE, 0xE3, 0xCE, 0xE7, 0xCE,
  0xE7, 0xCE, 0xE6, 0xEE, 0xE6, 0xEE, 0xE6, 0xEE, 0xFE, 0x6E, 0x7E, 0x6E,
  0x7E, 0x6E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x3E, 0x78, 0x0F,
  0x9E, 0x07, 0x8F, 0x07, 0x83, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7B, 0xC0, 0x38, 0xF0, 0x3C, 0x78, 0x3C, 0x1E, 0x1E, 0x0F,
  0x9E, 0x03, 0xDF, 0x01, 0xF0, 0xF8, 0x07, 0xBC, 0x07, 0x8F, 0x03, 0xC7,
  0x83, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x07, 0x78,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03, 0x8E, 0x0F, 0x1E, 0x1C, 0x1C,
  0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x7F, 0x00, 0x72, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x21, 0x8F, 0x1C, 0x78, 0xE1, 0x40, 0x1F, 0x81,
  0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0x20, 0x78, 0x01, 0xE1, 0xFF, 0x9F, 0xFE,
  0xFF, 0xFB, 0xC1, 0xEE, 0x07, 0xBC, 0x3E, 0xFF, 0xFD, 0xFC, 0xF3, 0xE3,
  0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x3E, 0x3D, 0xFC, 0xFF, 0xFB, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xEF, 0xFF, 0xBD, 0xFC,
  0xF3, 0xE0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x33, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0x1E, 0x1F, 0x7F,
  0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0xF1, 0xCF, 0xF7, 0x7F, 0xDD, 0xF0, 0xF7, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x78, 0x1D, 0xF0,
  0xF7, 0xFD, 0xCF, 0xF7, 0x0F, 0x1C, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x3E,
  0x1E, 0xF0, 0x3B, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x3E, 0x0C, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x7F, 0x03, 0xFF, 0x0F, 0xFE, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0xF1, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x0C, 0x00,
  0x18, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFB, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0x1F, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xCF, 0x9E, 0xFE, 0xFF, 0xFF, 0xC3, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0x80, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFF, 0xEF, 0xFB, 0xFC, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0x78, 0x7C, 0xF1, 0xF1, 0xE3, 0xC3,
  0xCF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF0, 0x78, 0xF0, 0xF1,
  0xF1, 0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xE0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7, 0x3D, 0xDE, 0x7F,
  0xFF, 0xFF, 0x9E, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3,
  0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3,
  0x80, 0xF3, 0xE7, 0xBF, 0xBF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x81, 0xEE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x7B, 0xE1,
  0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF,
  0xBE, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x1E, 0xFF, 0xFB, 0xDF, 0xCF, 0x3E, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x1C, 0xFF, 0x77,
  0xFD, 0xDF, 0x0F, 0x78, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x81, 0xDF, 0x0F, 0x7F, 0xDC, 0xFF, 0x70, 0xF1, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xFF, 0x1F, 0xFD,
  0xFF, 0xF7, 0xC3, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x0F, 0xC1, 0xFF, 0x9F, 0xFE, 0xF0, 0x6F, 0x02, 0x7C, 0x01, 0xFE, 0x07,
  0xFE, 0x1F, 0xF8, 0x03, 0xD0, 0x0F, 0xE0, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xF1, 0xF7, 0xFB, 0xBF, 0x9C, 0x78,
  0xE0, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87,
  0x0F, 0x0E, 0x0E, 0x3C, 0x1E, 0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0x7F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF1, 0xE3, 0xB8, 0xF1, 0xDC, 0x78,
  0xEE, 0x7C, 0x77, 0x3E, 0x33, 0x9B, 0x39, 0xCD, 0xDC, 0xE6, 0xEE, 0x73,
  0x37, 0x1F, 0x9B, 0x8F, 0xCD, 0xC7, 0xC6, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0xF8, 0x1E, 0xF8, 0x78, 0xF1, 0xE0, 0xF3, 0xC0, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xE3,
  0xC3, 0xC7, 0xCF, 0x07, 0xBC, 0x07, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0x78,
  0x1E, 0x78, 0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E,
  0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x8F, 0xF0, 0xF8, 0x0F, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0x03, 0xF0, 0xFF,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x1E, 0x0E, 0x7E, 0x1D, 0xFE, 0x3B,
  0x9E, 0xF6, 0x1F, 0xDC, 0x3F, 0xB8, 0x1C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 9, 17, 4, -21 },
  { 25, 17, 20, 17, 0, -20 },
  { 68, 15, 26, 17, 1, -23 },
  { 117, 17, 20, 17, 0, -20 },
  { 160, 17, 20, 17, 0, -20 },
  { 203, 3, 9, 17, 7, -21 },
  { 207, 10, 26, 17, 5, -22 },
  { 240, 10, 26, 17, 2, -22 },
  { 273, 15, 15, 17, 1, -16 },
  { 302, 14, 15, 17, 2, -16 },
  { 329, 7, 9, 17, 5, -5 },
  { 337, 9, 3, 17, 4, -10 },
  { 341, 5, 5, 17, 6, -5 },
  { 345, 13, 26, 17, 2, -22 },
  { 388, 15, 20, 17, 1, -20 },
  { 426, 16, 20, 17, 1, -20 },
  { 466, 15, 20, 17, 1, -20 },
  { 504, 15, 20, 17, 1, -20 },
  { 542, 16, 20, 17, 1, -20 },
  { 582, 15, 20, 17, 1, -20 },
  { 620, 15, 20, 17, 1, -20 },
  { 658, 14, 20, 17, 2, -20 },
  { 693, 15, 20, 17, 1, -20 },
  { 731, 15, 20, 17, 1, -20 },
  { 769, 5, 15, 17, 6, -15 },
  { 779, 7, 19, 17, 5, -15 },
  { 796, 13, 17, 17, 2, -17 },
  { 824, 14, 10, 17, 2, -14 },
  { 842, 13, 17, 17, 2, -17 },
  { 870, 13, 20, 17, 2, -20 },
  { 903, 15, 23, 17, 1, -20 },
  { 947, 17, 20, 17, 0, -20 },
  { 990, 14, 20, 17, 2, -20 },
  { 1025, 15, 20, 17, 1, -20 },
  { 1063, 14, 20, 17, 2, -20 },
  { 1098, 13, 20, 17, 2, -20 },
  { 1131, 14, 20, 17, 2, -20 },
  { 1166, 15, 20, 17, 1, -20 },
  { 1204, 13, 20, 17, 2, -20 },
  { 1237, 13, 20, 17, 2, -20 },
  { 1270, 14, 20, 17, 1, -20 },
  { 1305, 15, 20, 17, 2, -20 },
  { 1343, 13, 20, 17, 3, -20 },
  { 1376, 15, 20, 17, 1, -20 },
  { 1414, 13, 20, 17, 2, -20 },
  { 1447, 15, 20, 17, 1, -20 },
  { 1485, 14, 20, 17, 2, -20 },
  { 1520, 15, 25, 17, 1, -20 },
  { 1567, 14, 20, 17, 2, -20 },
  { 1602, 15, 20, 17, 1, -20 },
  { 1640, 16, 20, 17, 1, -20 },
  { 1680, 14, 20, 17, 2, -20 },
  { 1715, 17, 20, 17, 0, -20 },
  { 1758, 16, 20, 17, 1, -20 },
  { 1798, 17, 20, 17, 0, -20 },
  { 1841, 17, 20, 17, 0, -20 },
  { 1884, 15, 20, 17, 1, -20 },
  { 1922, 9, 26, 17, 6, -22 },
  { 1952, 13, 26, 17, 2, -22 },
  { 1995, 9, 26, 17, 3, -22 },
  { 2025, 15, 13, 17, 1, -20 },
  { 2050, 14, 3, 17, 2, 2 },
  { 2056, 6, 7, 17, 5, -24 },
  { 2062, 14, 15, 17, 2, -15 },
  { 2089, 14, 21, 17, 2, -21 },
  { 2126, 14, 15, 17, 2, -15 },
  { 2153, 14, 21, 17, 1, -21 },
  { 2190, 14, 15, 17, 2, -15 },
  { 2217, 14, 21, 17, 2, -21 },
  { 2254, 15, 24, 17, 2, -18 },
  { 2299, 13, 21, 17, 2, -21 },
  { 2334, 13, 22, 17, 3, -22 },
  { 2370, 10, 28, 17, 3, -22 },
  { 2405, 15, 21, 17, 2, -21 },
  { 2445, 13, 21, 17, 2, -21 },
  { 2480, 15, 15, 17, 1, -15 },
  { 2509, 13, 15, 17, 2, -15 },
  { 2534, 15, 15, 17, 1, -15 },
  { 2563, 14, 21, 17, 2, -15 },
  { 2600, 14, 21, 17, 1, -15 },
  { 2637, 14, 15, 17, 2, -15 },
  { 2664, 13, 15, 17, 2, -15 },
  { 2689, 14, 20, 17, 1, -20 },
  { 2724, 13, 15, 17, 2, -15 },
  { 2749, 15, 15, 17, 1, -15 },
  { 2778, 17, 15, 17, 0, -15 },
  { 2810, 15, 15, 17, 1, -15 },
  { 2839, 16, 21, 17, 1, -15 },
  { 2881, 13, 15, 17, 2, -15 },
  { 2906, 12, 26, 17, 3, -22 },
  { 2945, 3, 26, 17, 7, -22 },
  { 2955, 12, 26, 17, 3, -22 },
  { 2994, 15, 7, 17, 1, -12 },
};

const GFXfont IBMPlexMono_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_SEMIBOLD29PT7B_H_
