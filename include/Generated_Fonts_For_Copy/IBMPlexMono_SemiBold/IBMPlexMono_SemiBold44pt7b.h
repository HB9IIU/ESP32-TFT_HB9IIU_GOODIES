#ifndef _IBMPLEXMONO_SEMIBOLD44PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x0F, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x0F, 0xFE, 0x1F, 0xF3, 0xFF,
  0x8F, 0xFC, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xC0, 0x7C, 0x3C, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9, 0xFC, 0xE7, 0xE3, 0xF1, 0xC3,
  0x87, 0xC3, 0x82, 0x0F, 0x87, 0x00, 0x1F, 0x0E, 0x00, 0x3F, 0x1C, 0x00,
  0x7F, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1C, 0xFE, 0x00,
  0x38, 0xFE, 0x00, 0x70, 0xFC, 0x00, 0xE1, 0xF9, 0x01, 0xC3, 0xF3, 0x03,
  0x87, 0xEF, 0x87, 0x0F, 0xBF, 0xCE, 0x7F, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07,
  0xC7, 0xFC, 0x01, 0xE3, 0xFF, 0x80, 0xF9, 0xFF, 0xE0, 0x3C, 0x7C, 0x7C,
  0x1F, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x3C, 0x7C, 0x1E, 0x0F, 0x1E, 0x07, 0x83, 0xCF, 0x81, 0xF1, 0xF3, 0xC0,
  0x7F, 0xF9, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1E, 0x7F, 0xF8, 0x0F,
  0x9E, 0x1E, 0x03, 0xC7, 0x87, 0xC1, 0xF3, 0xC0, 0xF0, 0x78, 0xF0, 0x3C,
  0x3E, 0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xC7, 0xC3, 0xC0, 0xF1, 0xE0, 0x78,
  0x7C, 0xF8, 0x1E, 0x1E, 0x3C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xC7, 0x80,
  0x1F, 0xE2, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F, 0x1F, 0x7C,
  0x3F, 0x9F, 0x3F, 0x1E, 0x1F, 0x8F, 0xCF, 0x0F, 0x83, 0xE7, 0x87, 0xC0,
  0xFF, 0x83, 0xE0, 0x7F, 0xC1, 0xF0, 0x1F, 0xE0, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xC1, 0xDF, 0x87, 0xFF, 0xE7, 0xE1,
  0xFF, 0xE1, 0xF8, 0x7F, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x38,
  0x3E, 0x0E, 0x7E, 0x3E, 0x7E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0x00, 0xF0, 0x03, 0x00, 0x40, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7,
  0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x1E, 0x1F,
  0xFC, 0x3E, 0x3F, 0xF8, 0xFC, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0x80,
  0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xC1, 0xF8, 0x01,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0x20, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x87, 0x80, 0x3F, 0x06, 0x00, 0x7E, 0x08, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x84, 0x00, 0x3F, 0x3C, 0x00, 0xFE, 0xFC, 0x01, 0xFF,
  0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x03,
  0xE3, 0xF0, 0x03, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F,
  0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x78, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE1, 0xF8,
  0x03, 0xCF, 0xFC, 0x07, 0xBF, 0xFE, 0x1F, 0x7F, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0x03, 0xFC, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x0C, 0x00, 0x7E, 0x3C,
  0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xFE, 0x0F,
  0xDF, 0xFE, 0x1F, 0x7F, 0xFE, 0x7E, 0xFF, 0xFC, 0xFF, 0x83, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x03,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0,
  0x7F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x01,
  0xF9, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1,
  0xFC, 0x0F, 0xE3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xF9, 0xFC,
  0x0F, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0xBF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xEF, 0x83, 0xFF, 0x7E, 0x03,
  0xF1, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F, 0x1F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xE0, 0xFE, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x18, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0x03, 0xE3, 0xC0,
  0x07, 0x9F, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x78, 0xFF, 0x83, 0xFB,
  0xFE, 0x1F, 0xEF, 0xF8, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0x0F, 0x03, 0xFC,
  0x3C, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C,
  0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x87, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xBD, 0xE1, 0xFE, 0xF7, 0x83, 0xF3, 0xDE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80,
  0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xE3, 0xF0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x01, 0x87, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x06, 0x1F, 0x80, 0x1F, 0x7E, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xCF, 0xFF, 0xDF, 0x1F,
  0xFF, 0x7C, 0x7F, 0xF9, 0xF0, 0xFF, 0xC7, 0xC0, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB,
  0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF1,
  0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0xFC,
  0x07, 0xF9, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFB, 0xC7, 0xFF, 0xEF, 0x3D, 0xFF, 0xBE, 0xF7,
  0xFE, 0x7B, 0xDF, 0xF9, 0xFE, 0x7F, 0xE7, 0xF9, 0xFF, 0x8F, 0xE7, 0xFE,
  0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF1, 0xFF, 0x87, 0x87, 0xFE, 0x0E,
  0x1F, 0xF8, 0x30, 0x7F, 0xE0, 0xC1, 0xFF, 0x81, 0x07, 0xFE, 0x08, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xBC, 0x0F, 0xFB, 0xE0, 0xFF,
  0xBE, 0x0F, 0xF9, 0xF0, 0xFF, 0x9F, 0x0F, 0xF9, 0xF0, 0xFF, 0x8F, 0x8F,
  0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0x7C, 0xFF, 0x87, 0xCF, 0xF8, 0x3C,
  0xFF, 0x83, 0xEF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x01, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C, 0x03,
  0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE,
  0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x03, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xF0,
  0xFC, 0x0F, 0x87, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFE, 0x1F, 0x03, 0xF0,
  0xF8, 0x1F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF9, 0xF0, 0x0F, 0xCF, 0x80,
  0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFE, 0x07, 0xE7,
  0xE0, 0x07, 0x1F, 0x80, 0x08, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC8, 0x00,
  0x3F, 0x30, 0x00, 0xFD, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xC1, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x03,
  0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x7C, 0x3E, 0xF8, 0x7E,
  0x1F, 0x7C, 0x3F, 0x0F, 0xBE, 0x1F, 0xC7, 0xCF, 0x0F, 0xE3, 0xE7, 0x87,
  0xF1, 0xF3, 0xE7, 0xF8, 0xF9, 0xF3, 0xDC, 0x7C, 0xF9, 0xEE, 0x3E, 0x7C,
  0xF7, 0x9F, 0x3E, 0x73, 0xCF, 0x1F, 0x39, 0xE7, 0x8F, 0xBC, 0xF3, 0xC7,
  0xDE, 0x79, 0xE3, 0xEF, 0x1C, 0xF1, 0xF7, 0x8F, 0x78, 0xFB, 0x87, 0xBC,
  0x7D, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0x38, 0x00, 0x1C, 0x08, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08,
  0x1E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xE0,
  0x7E, 0x03, 0x80, 0x7E, 0x02, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0xF7, 0xFF, 0xDF, 0xE7,
  0xFF, 0x9F, 0xC7, 0xFE, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xC1, 0xF9, 0xFF, 0x8F, 0xDF, 0xFE, 0x7E, 0xFF, 0xF3, 0xFC, 0x1F, 0xDF,
  0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0x7F, 0x83, 0xFB, 0xF7, 0xFF, 0x9F, 0xBF, 0xFC, 0xFC, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xF8, 0x7F, 0x3F, 0x00, 0xF1, 0xF8, 0x06, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x06, 0x1F, 0x80, 0x7C, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x3E, 0x1F, 0xF1,
  0xF1, 0xFF, 0xCF, 0x9F, 0xFF, 0x7D, 0xFE, 0x1B, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0xC3, 0x7C,
  0xFF, 0xFB, 0xE3, 0xFF, 0x9F, 0x0F, 0xF8, 0xF8, 0x1F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83,
  0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFD,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x83, 0xF0, 0x07, 0x0F, 0xE0, 0x7E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xCF, 0xF8, 0xFC, 0xFF, 0xCF, 0xDF, 0xFE,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F,
  0x80, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xDF, 0x80, 0x7F, 0x1F, 0x80,
  0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE0, 0xF1, 0xE7, 0xE3, 0xF3, 0xDF, 0xEF, 0xF7, 0xBF, 0xFF,
  0xEF, 0x8F, 0xC7, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8, 0x3E, 0x1F,
  0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFF,
  0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8, 0x3E, 0x1F, 0xF0,
  0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x07,
  0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0x80, 0xFC, 0x3F, 0x0F, 0xCF,
  0xF8, 0xFC, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0x07, 0xE7, 0xE0,
  0x0F, 0x9F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xE0,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x80,
  0xFC, 0x3F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFB, 0xFF, 0xCF, 0xF0,
  0x7F, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFD, 0xFE, 0x0F, 0xEF, 0xDF, 0xFE, 0x7E, 0xFF, 0xF3, 0xF3, 0xFF,
  0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0xF8, 0x7F, 0xC7, 0xC7, 0xFF, 0x3E, 0x7F, 0xFD, 0xF7, 0xF8,
  0x6F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFF, 0x0D, 0xF3, 0xFF, 0xEF, 0x8F, 0xFE, 0x7C, 0x3F, 0xE3,
  0xE0, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x03,
  0xF7, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF3, 0xF8, 0x1F, 0x1F, 0x00, 0x30, 0xF8, 0x01, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0xC0, 0x07, 0xCF, 0x00, 0x7E, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF,
  0x1F, 0xF3, 0xF0, 0x7C, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F,
  0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xF0, 0x3E, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x1F, 0x83, 0xDF, 0x0F, 0xC1,
  0xEF, 0x87, 0xF0, 0xF7, 0xC3, 0xF8, 0x7B, 0xE1, 0xFC, 0x3C, 0xF0, 0xEE,
  0x3E, 0x78, 0xF7, 0x1F, 0x3C, 0x73, 0x8F, 0x9E, 0x39, 0xE7, 0x8F, 0x1C,
  0xF3, 0xC7, 0xCE, 0x79, 0xE3, 0xE7, 0x1C, 0xF1, 0xF7, 0x8E, 0x78, 0x7B,
  0xC7, 0x3C, 0x3D, 0xC3, 0xDE, 0x1E, 0xE1, 0xFF, 0x0F, 0x70, 0xFF, 0x07,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x38, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0,
  0xF3, 0xFF, 0xC1, 0xE7, 0xCF, 0xC7, 0xCF, 0x0F, 0x8F, 0x3E, 0x0F, 0xFE,
  0x78, 0x1F, 0xF8, 0xF0, 0x1F, 0xE0, 0xE0, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_SemiBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 31, 26, 9, -31 },
  { 32, 14, 14, 26, 6, -33 },
  { 57, 26, 31, 26, 0, -31 },
  { 158, 23, 40, 26, 2, -36 },
  { 273, 26, 32, 26, 0, -31 },
  { 377, 25, 32, 26, 1, -31 },
  { 477, 5, 14, 26, 11, -33 },
  { 486, 15, 39, 26, 8, -33 },
  { 560, 14, 39, 26, 4, -33 },
  { 629, 24, 22, 26, 1, -24 },
  { 695, 21, 20, 26, 3, -23 },
  { 748, 10, 14, 26, 8, -7 },
  { 766, 14, 5, 26, 6, -16 },
  { 775, 8, 8, 26, 9, -8 },
  { 783, 20, 39, 26, 3, -33 },
  { 881, 23, 32, 26, 2, -31 },
  { 973, 23, 31, 26, 2, -31 },
  { 1063, 22, 31, 26, 2, -31 },
  { 1149, 23, 32, 26, 1, -31 },
  { 1241, 24, 31, 26, 1, -31 },
  { 1334, 23, 32, 26, 2, -31 },
  { 1426, 23, 32, 26, 2, -31 },
  { 1518, 22, 31, 26, 2, -31 },
  { 1604, 23, 32, 26, 2, -31 },
  { 1696, 22, 31, 26, 2, -31 },
  { 1782, 8, 24, 26, 9, -24 },
  { 1806, 10, 31, 26, 8, -24 },
  { 1845, 19, 26, 26, 4, -26 },
  { 1907, 21, 13, 26, 3, -20 },
  { 1942, 19, 26, 26, 4, -26 },
  { 2004, 20, 31, 26, 3, -31 },
  { 2082, 22, 36, 26, 2, -31 },
  { 2181, 25, 31, 26, 1, -31 },
  { 2278, 20, 31, 26, 4, -31 },
  { 2356, 22, 32, 26, 2, -31 },
  { 2444, 22, 31, 26, 3, -31 },
  { 2530, 19, 31, 26, 4, -31 },
  { 2604, 20, 31, 26, 4, -31 },
  { 2682, 22, 32, 26, 2, -31 },
  { 2770, 20, 31, 26, 3, -31 },
  { 2848, 20, 31, 26, 3, -31 },
  { 2926, 20, 32, 26, 2, -31 },
  { 3006, 23, 31, 26, 3, -31 },
  { 3096, 20, 31, 26, 4, -31 },
  { 3174, 22, 31, 26, 2, -31 },
  { 3260, 20, 31, 26, 3, -31 },
  { 3338, 23, 32, 26, 2, -31 },
  { 3430, 20, 31, 26, 4, -31 },
  { 3508, 23, 39, 26, 2, -31 },
  { 3621, 21, 31, 26, 4, -31 },
  { 3703, 22, 32, 26, 2, -31 },
  { 3791, 24, 31, 26, 1, -31 },
  { 3884, 21, 32, 26, 3, -31 },
  { 3968, 25, 31, 26, 1, -31 },
  { 4065, 25, 31, 26, 1, -31 },
  { 4162, 25, 31, 26, 1, -31 },
  { 4259, 26, 31, 26, 0, -31 },
  { 4360, 22, 31, 26, 2, -31 },
  { 4446, 13, 39, 26, 9, -33 },
  { 4510, 20, 39, 26, 3, -33 },
  { 4608, 14, 39, 26, 4, -33 },
  { 4677, 24, 20, 26, 1, -31 },
  { 4737, 21, 5, 26, 3, 3 },
  { 4751, 9, 10, 26, 7, -35 },
  { 4763, 23, 24, 26, 2, -23 },
  { 4832, 21, 34, 26, 3, -33 },
  { 4922, 21, 24, 26, 3, -23 },
  { 4985, 21, 34, 26, 2, -33 },
  { 5075, 22, 24, 26, 2, -23 },
  { 5141, 21, 33, 26, 3, -33 },
  { 5228, 23, 35, 26, 2, -26 },
  { 5329, 20, 33, 26, 3, -33 },
  { 5412, 20, 34, 26, 4, -34 },
  { 5497, 16, 43, 26, 4, -34 },
  { 5583, 23, 33, 26, 3, -33 },
  { 5678, 20, 33, 26, 3, -33 },
  { 5761, 23, 23, 26, 2, -23 },
  { 5828, 20, 23, 26, 3, -23 },
  { 5886, 22, 24, 26, 2, -23 },
  { 5952, 21, 32, 26, 3, -23 },
  { 6036, 21, 32, 26, 2, -23 },
  { 6120, 22, 23, 26, 3, -23 },
  { 6184, 21, 24, 26, 2, -23 },
  { 6247, 21, 31, 26, 2, -31 },
  { 6329, 20, 24, 26, 3, -23 },
  { 6389, 23, 23, 26, 2, -23 },
  { 6456, 25, 23, 26, 1, -23 },
  { 6528, 24, 23, 26, 1, -23 },
  { 6597, 24, 32, 26, 1, -23 },
  { 6693, 20, 23, 26, 3, -23 },
  { 6751, 18, 39, 26, 4, -33 },
  { 6839, 5, 39, 26, 11, -33 },
  { 6864, 18, 39, 26, 4, -33 },
  { 6952, 23, 10, 26, 2, -19 },
};

const GFXfont IBMPlexMono_SemiBold44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_SEMIBOLD44PT7B_H_
