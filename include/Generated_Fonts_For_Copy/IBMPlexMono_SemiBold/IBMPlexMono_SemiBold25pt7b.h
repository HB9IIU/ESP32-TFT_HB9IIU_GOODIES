#ifndef _IBMPLEXMONO_SEMIBOLD25PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x21, 0x00, 0x07, 0x7F, 0xFF, 0x70,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x07, 0x38, 0x0E,
  0x60, 0x1C, 0xC0, 0x33, 0x87, 0xE7, 0xEF, 0xCF, 0xDF, 0x9F, 0x87, 0x30,
  0x0C, 0x60, 0x19, 0xC3, 0xF3, 0xF7, 0xE7, 0xEF, 0xCF, 0xC3, 0x98, 0x06,
  0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x83,
  0xFF, 0x3F, 0xFD, 0xCD, 0xDE, 0x64, 0x73, 0x03, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x81, 0xBC, 0x0C, 0xEC, 0x67, 0xF3, 0x7F, 0xFF, 0x9F, 0xF8,
  0x3F, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3C, 0x0E, 0xFC, 0x39, 0x9C,
  0x67, 0x19, 0xCE, 0x33, 0x1C, 0xEE, 0x1F, 0xD8, 0x3F, 0x40, 0x3C, 0x78,
  0x01, 0xF8, 0x3F, 0x30, 0xEC, 0x71, 0x98, 0xE7, 0x31, 0xCC, 0x73, 0x38,
  0x7E, 0xE0, 0x78, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x81, 0xC7, 0x03, 0x88,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x1E, 0x3F, 0x3C, 0xFF, 0x79, 0xCE, 0xC7,
  0x8F, 0x8E, 0x1F, 0x0E, 0x1E, 0x1F, 0xFE, 0x1F, 0xDE, 0x1F, 0x1E, 0xFF,
  0xFF, 0xFF, 0x0F, 0x1C, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0F,
  0xF0, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x8E, 0x2F, 0x77, 0xFF, 0xFC, 0xFF, 0x81, 0xF0, 0x1F,
  0xC0, 0xEE, 0x0E, 0x38, 0xE0, 0xE1, 0x04, 0x00, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0xF7, 0x9E, 0x71, 0xC7, 0x38, 0xFF, 0xFF, 0xF8, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x9C, 0xFC, 0xE7, 0xE7,
  0x3F, 0x39, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xBC, 0x79, 0xFF, 0xC7, 0xFC,
  0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xF7, 0x0F, 0x38, 0x71, 0xC0,
  0x8E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC1, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE1,
  0xEE, 0x07, 0x10, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x81,
  0xFF, 0x1F, 0xFD, 0xE1, 0xE2, 0x07, 0x00, 0x38, 0x03, 0xC1, 0xFC, 0x0F,
  0x80, 0x7F, 0x00, 0x3C, 0x00, 0xF6, 0x07, 0xF8, 0x79, 0xFF, 0xCF, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0D, 0xC0, 0xEE, 0x0E, 0x70,
  0x63, 0x87, 0x1C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0,
  0x07, 0x00, 0x3B, 0xE1, 0xFF, 0x8F, 0xFE, 0x78, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF2, 0x07, 0xF8, 0x79, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3D, 0xE1, 0xDF, 0x8F, 0xFE, 0xF8,
  0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xBC, 0x79, 0xFF, 0xC7, 0xFC,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEE, 0x07, 0x70, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xC7, 0xFC, 0x1F, 0xC3, 0xFF, 0xBC, 0x1F,
  0xE0, 0xFE, 0x07, 0xF8, 0x3D, 0xFF, 0xCF, 0xFC, 0x1F, 0xC0, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8,
  0xFB, 0xFF, 0x8F, 0xDC, 0x3D, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xF0,
  0x3E, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xB8, 0x39,
  0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x79, 0xE7, 0x1C, 0x73,
  0x80, 0x00, 0x20, 0x1C, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x07, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x1C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x03, 0xE1,
  0xF8, 0x7C, 0x3E, 0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x0F, 0xFB, 0xFF,
  0xF8, 0xFE, 0x0E, 0x01, 0xC0, 0x70, 0xFC, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x0F, 0x81, 0xFF, 0x0F,
  0xFC, 0xF0, 0xE7, 0x03, 0x71, 0xDF, 0x9F, 0xFC, 0xC7, 0xE6, 0x3F, 0x71,
  0xFB, 0x8F, 0xCC, 0x7E, 0x63, 0xF3, 0xFD, 0x8E, 0xEE, 0x00, 0x78, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77,
  0x00, 0xEE, 0x01, 0xDC, 0x07, 0x3C, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0x07, 0x9C, 0x0F, 0x38, 0x0E, 0xF0,
  0x1E, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF,
  0xFC, 0xFF, 0x8F, 0xFE, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xEF,
  0xFE, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8,
  0x13, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x47, 0x07,
  0xBC, 0x38, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE,
  0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xEE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xFE,
  0x7F, 0xE7, 0x8F, 0x70, 0x7F, 0x06, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x03, 0xF0, 0x77, 0x87, 0x7F, 0xF3, 0xFB, 0x1F, 0x30, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF2, 0x0F, 0xF0, 0xF7, 0x1E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0xE0, 0x7F, 0x07, 0xB8, 0x79, 0xC7, 0x8E, 0x38, 0x73, 0x83, 0xBC,
  0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3D, 0xE1, 0xC7, 0x8E, 0x1C, 0x70, 0xF3,
  0x83, 0x9C, 0x1E, 0xE0, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F,
  0xF1, 0xFF, 0xDF, 0xF6, 0xDF, 0xBE, 0xFD, 0xF7, 0xE7, 0x3F, 0x39, 0xF8,
  0x8F, 0xC4, 0x7E, 0x23, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0xF0,
  0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xB8, 0xF7, 0x1E, 0x73, 0xCE, 0x79,
  0xCF, 0x1D, 0xE3, 0xBC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xE0, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xBC, 0x79, 0xFF, 0xC7,
  0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFE, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xEF, 0xFE, 0xFF, 0x8E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF,
  0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0xFF, 0x07, 0xBC, 0x79, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x38, 0x01, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0xFF, 0x8F, 0xFE, 0xFF, 0xEE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xEF, 0xFC, 0xFF, 0x8E, 0x38, 0xE3,
  0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC,
  0xF0, 0xF7, 0x02, 0x38, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0x80,
  0x1E, 0x00, 0xF6, 0x07, 0xF8, 0x3B, 0xFF, 0xCF, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xFF, 0xFB,
  0xFE, 0x3F, 0x80, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83,
  0x87, 0x07, 0x0F, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x7B, 0xC0,
  0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0xE0,
  0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x67, 0x38, 0xCE, 0x71, 0x9C, 0xF7,
  0x3B, 0xEE, 0x76, 0xDC, 0xED, 0xB9, 0xDB, 0x73, 0xB6, 0xE7, 0xEF, 0xCF,
  0x8F, 0x9F, 0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x1C, 0x70, 0x78, 0xF1,
  0xE0, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xCF, 0x07, 0x8F, 0x0E, 0x0E, 0x3C,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x39, 0xE0, 0xF1, 0xC1, 0xC3, 0xC7,
  0x83, 0x8E, 0x07, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x3B,
  0x81, 0xDC, 0x1C, 0x70, 0xE3, 0x8E, 0x0E, 0x70, 0x77, 0x01, 0xD8, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x23, 0x3C, 0xE3, 0x88, 0x1F, 0x81, 0xFF,
  0x1F, 0xF8, 0xE1, 0xE2, 0x0F, 0x00, 0x78, 0x7F, 0xCF, 0xFE, 0x70, 0xF7,
  0x87, 0x9F, 0xDE, 0xFE, 0xF3, 0xE3, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x1E, 0xFF, 0xEE, 0xFC, 0xE7, 0x80,
  0x1F, 0x07, 0xF9, 0xFF, 0xF8, 0x7E, 0x09, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x5E, 0x1D, 0xFF, 0x9F, 0xE1, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x1E, 0x73, 0xF7, 0x7F, 0xFF, 0x8F, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x8F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xE7, 0x07, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x03, 0xC1, 0x1F, 0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x1F, 0x83, 0xFE, 0x3F, 0xF9,
  0xC3, 0xCE, 0x0E, 0x70, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F, 0x07, 0x00, 0x3F,
  0xF1, 0xFF, 0xE3, 0xFF, 0x60, 0x3F, 0x01, 0xFF, 0xFE, 0xFF, 0xE3, 0xFC,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0x7E,
  0xFF, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0x80, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x83, 0xC1,
  0xE0, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFD, 0xFC,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xDC,
  0x3C, 0xE3, 0xC7, 0x3C, 0x3B, 0xC1, 0xFC, 0x0F, 0xF0, 0x7B, 0xC3, 0x8E,
  0x1C, 0x78, 0xE1, 0xE7, 0x07, 0xB8, 0x3E, 0xFE, 0x1F, 0xC3, 0xF8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xEC, 0x77,
  0xF7, 0xFF, 0xBF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7,
  0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0x80, 0xE7, 0x9D, 0xFB, 0xFF,
  0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0E, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0x9F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00,
  0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFF, 0x1E, 0xFF, 0xEE, 0xFC, 0xE7, 0x8E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xFF, 0x8F, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x8F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0x7F, 0xCF, 0xFD, 0xF1, 0xF0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7, 0x86, 0x70, 0x07, 0xF8, 0x3F,
  0xE1, 0xFF, 0x00, 0x72, 0x07, 0xFF, 0xF7, 0xFE, 0x1F, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x3F, 0xFF, 0xBF, 0x73, 0xCE, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0xE0,
  0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x00, 0xE3, 0x8E, 0xC7, 0x19, 0x8E, 0x33, 0x16, 0x66,
  0x6C, 0xCE, 0xD9, 0x9D, 0xB7, 0x3B, 0x6E, 0x76, 0xDC, 0x68, 0xF0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x80, 0xF0, 0x7B, 0xC7, 0x8E, 0x38, 0x3B, 0x81,
  0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0xC1, 0xEF, 0x0E, 0x38, 0xE1,
  0xEF, 0x07, 0x80, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C,
  0x70, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x07, 0x1F, 0xE3, 0xE0, 0x7F, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xE3, 0xFC, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0xFC, 0x0F, 0x8F, 0xF1,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x7F, 0x8F, 0xF1,
  0xFC, 0x00, 0x3C, 0x1B, 0xF1, 0xDF, 0xCE, 0xCE, 0x6E, 0x7F, 0x71, 0xFB,
  0x07, 0x80,
};

const GFXglyph IBMPlexMono_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 17, 15, 5, -17 },
  { 12, 9, 8, 15, 3, -19 },
  { 21, 15, 17, 15, 0, -17 },
  { 53, 13, 23, 15, 1, -20 },
  { 91, 15, 17, 15, 0, -17 },
  { 123, 15, 17, 15, 0, -17 },
  { 155, 3, 8, 15, 6, -19 },
  { 158, 8, 22, 15, 5, -19 },
  { 180, 8, 22, 15, 2, -19 },
  { 202, 13, 13, 15, 1, -14 },
  { 224, 11, 13, 15, 2, -14 },
  { 242, 6, 8, 15, 4, -4 },
  { 248, 7, 3, 15, 4, -9 },
  { 251, 5, 5, 15, 5, -5 },
  { 255, 11, 22, 15, 2, -19 },
  { 286, 13, 17, 15, 1, -17 },
  { 314, 13, 17, 15, 1, -17 },
  { 342, 13, 17, 15, 1, -17 },
  { 370, 13, 17, 15, 1, -17 },
  { 398, 13, 17, 15, 1, -17 },
  { 426, 13, 17, 15, 1, -17 },
  { 454, 13, 17, 15, 1, -17 },
  { 482, 13, 17, 15, 1, -17 },
  { 510, 13, 17, 15, 1, -17 },
  { 538, 13, 17, 15, 1, -17 },
  { 566, 5, 14, 15, 5, -14 },
  { 575, 6, 18, 15, 4, -14 },
  { 589, 11, 15, 15, 2, -15 },
  { 610, 11, 9, 15, 2, -12 },
  { 623, 11, 15, 15, 2, -15 },
  { 644, 11, 17, 15, 2, -17 },
  { 668, 13, 20, 15, 1, -17 },
  { 701, 15, 17, 15, 0, -17 },
  { 733, 12, 17, 15, 2, -17 },
  { 759, 13, 17, 15, 1, -17 },
  { 787, 12, 17, 15, 2, -17 },
  { 813, 11, 17, 15, 2, -17 },
  { 837, 11, 17, 15, 2, -17 },
  { 861, 12, 17, 15, 1, -17 },
  { 887, 11, 17, 15, 2, -17 },
  { 911, 11, 17, 15, 2, -17 },
  { 935, 12, 17, 15, 1, -17 },
  { 961, 13, 17, 15, 2, -17 },
  { 989, 12, 17, 15, 2, -17 },
  { 1015, 13, 17, 15, 1, -17 },
  { 1043, 11, 17, 15, 2, -17 },
  { 1067, 13, 17, 15, 1, -17 },
  { 1095, 12, 17, 15, 2, -17 },
  { 1121, 13, 22, 15, 1, -17 },
  { 1157, 12, 17, 15, 2, -17 },
  { 1183, 13, 17, 15, 1, -17 },
  { 1211, 13, 17, 15, 1, -17 },
  { 1239, 11, 17, 15, 2, -17 },
  { 1263, 15, 17, 15, 0, -17 },
  { 1295, 15, 17, 15, 0, -17 },
  { 1327, 15, 17, 15, 0, -17 },
  { 1359, 15, 17, 15, 0, -17 },
  { 1391, 13, 17, 15, 1, -17 },
  { 1419, 8, 22, 15, 5, -19 },
  { 1441, 11, 22, 15, 2, -19 },
  { 1472, 8, 22, 15, 2, -19 },
  { 1494, 13, 11, 15, 1, -17 },
  { 1512, 13, 3, 15, 1, 2 },
  { 1517, 5, 6, 15, 4, -20 },
  { 1521, 13, 13, 15, 1, -13 },
  { 1543, 12, 19, 15, 2, -19 },
  { 1572, 11, 13, 15, 2, -13 },
  { 1590, 12, 19, 15, 1, -19 },
  { 1619, 13, 13, 15, 1, -13 },
  { 1641, 12, 19, 15, 2, -19 },
  { 1670, 13, 21, 15, 1, -16 },
  { 1705, 11, 19, 15, 2, -19 },
  { 1732, 12, 19, 15, 2, -19 },
  { 1761, 9, 24, 15, 2, -19 },
  { 1788, 13, 19, 15, 2, -19 },
  { 1819, 11, 19, 15, 2, -19 },
  { 1846, 13, 13, 15, 1, -13 },
  { 1868, 11, 13, 15, 2, -13 },
  { 1886, 13, 13, 15, 1, -13 },
  { 1908, 12, 18, 15, 2, -13 },
  { 1935, 12, 18, 15, 1, -13 },
  { 1962, 12, 13, 15, 2, -13 },
  { 1982, 12, 13, 15, 1, -13 },
  { 2002, 12, 17, 15, 1, -17 },
  { 2028, 11, 13, 15, 2, -13 },
  { 2046, 13, 13, 15, 1, -13 },
  { 2068, 15, 13, 15, 0, -13 },
  { 2093, 13, 13, 15, 1, -13 },
  { 2115, 13, 18, 15, 1, -13 },
  { 2145, 11, 13, 15, 2, -13 },
  { 2163, 11, 22, 15, 2, -19 },
  { 2194, 3, 22, 15, 6, -19 },
  { 2203, 11, 22, 15, 2, -19 },
  { 2234, 13, 7, 15, 1, -11 },
};

const GFXfont IBMPlexMono_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_SEMIBOLD25PT7B_H_
