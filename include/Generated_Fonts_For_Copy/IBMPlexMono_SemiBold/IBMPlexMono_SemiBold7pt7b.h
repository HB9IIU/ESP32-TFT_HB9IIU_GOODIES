#ifndef _IBMPLEXMONO_SEMIBOLD7PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0xC0, 0xF0, 0x76, 0xFF, 0xA0, 0x27, 0xC6, 0x5F, 0x20, 0xDE,
  0x47, 0xB0, 0x68, 0x5A, 0xD0, 0xC0, 0x72, 0x48, 0xC0, 0x95, 0x60, 0x4F,
  0x6B, 0x4F, 0x44, 0x60, 0xC0, 0xC0, 0x69, 0x49, 0x00, 0x69, 0xB9, 0x60,
  0x6A, 0x22, 0x70, 0x69, 0x24, 0xF0, 0x69, 0x61, 0xF0, 0x26, 0xAF, 0x20,
  0x78, 0x71, 0xF0, 0x24, 0xF9, 0x70, 0xF9, 0x22, 0x40, 0x69, 0x69, 0x70,
  0x69, 0xF2, 0x60, 0x73, 0x71, 0x80, 0x73, 0x10, 0xFF, 0x8D, 0x40, 0x69,
  0x20, 0x60, 0x6B, 0xDD, 0xA6, 0x66, 0x67, 0x90, 0xD7, 0x5E, 0x6B, 0x88,
  0x70, 0xD6, 0xDC, 0xF3, 0xCE, 0xF3, 0xC8, 0x6B, 0xB9, 0x70, 0x99, 0xF9,
  0x90, 0xE9, 0x2E, 0x71, 0x11, 0xE0, 0xBB, 0x6A, 0x92, 0x4E, 0xDF, 0xBD,
  0x90, 0xDD, 0xDB, 0xB0, 0x69, 0x99, 0x60, 0xD7, 0xC8, 0x69, 0x99, 0x63,
  0xD7, 0xEA, 0x78, 0x61, 0xF0, 0xF2, 0x22, 0x20, 0x99, 0x99, 0x70, 0x99,
  0x66, 0x60, 0x9B, 0xFF, 0xF0, 0x96, 0x26, 0x90, 0x96, 0x62, 0x20, 0xF2,
  0x24, 0xF0, 0xF2, 0x49, 0xC0, 0x92, 0x24, 0xC0, 0xD5, 0x70, 0x66, 0x90,
  0xF0, 0xB0, 0x69, 0x7F, 0x8A, 0xD9, 0xF0, 0x6B, 0x87, 0x15, 0xB9, 0x70,
  0x69, 0xE7, 0x3F, 0x22, 0x70, 0x79, 0x66, 0xF0, 0x9A, 0xDA, 0x59, 0x2E,
  0x75, 0x70, 0x97, 0x6A, 0xE2, 0x22, 0xF0, 0xDF, 0xDD, 0xD6, 0xD0, 0x69,
  0x96, 0xAD, 0x9F, 0x80, 0x5B, 0x97, 0x10, 0xBA, 0x70, 0x69, 0x7F, 0x4F,
  0x44, 0x70, 0x99, 0x97, 0x95, 0x66, 0xBB, 0xFF, 0x96, 0x6D, 0x95, 0x66,
  0x40, 0x72, 0x4F, 0xEB, 0x28, 0xC0, 0xFC, 0xD1, 0x55, 0x80, 0x5A,
};

const GFXglyph IBMPlexMono_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 3, 6, 4, 1, -5 },
  { 21, 2, 6, 4, 1, -5 },
  { 23, 4, 4, 4, 0, -4 },
  { 25, 4, 4, 4, 0, -4 },
  { 27, 2, 2, 4, 1, -1 },
  { 28, 2, 1, 4, 1, -3 },
  { 29, 2, 1, 4, 1, -1 },
  { 30, 3, 6, 4, 1, -5 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 5, 4, 1, -4 },
  { 66, 3, 4, 4, 1, -4 },
  { 68, 4, 2, 4, 0, -3 },
  { 69, 3, 4, 4, 1, -4 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 6, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 3, 5, 4, 1, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 3, 5, 4, 1, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 3, 5, 4, 1, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 3, 5, 4, 1, -5 },
  { 117, 4, 6, 4, 0, -5 },
  { 120, 3, 5, 4, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 3, 6, 4, 1, -5 },
  { 149, 3, 6, 4, 1, -5 },
  { 152, 2, 6, 4, 1, -5 },
  { 154, 4, 3, 4, 0, -5 },
  { 156, 4, 1, 4, 0, 0 },
  { 157, 2, 2, 4, 1, -6 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 4, 5, 4, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 4, 5, 4, 0, -5 },
  { 173, 4, 5, 4, 0, -4 },
  { 176, 3, 5, 4, 1, -5 },
  { 178, 3, 5, 4, 1, -5 },
  { 180, 2, 6, 4, 1, -5 },
  { 182, 3, 5, 4, 1, -5 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 4, 4, 1, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 4, 5, 4, 0, -4 },
  { 196, 4, 5, 4, 0, -4 },
  { 199, 3, 4, 4, 1, -4 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 5, 4, 0, -5 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 4, 5, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 3, 6, 4, 1, -5 },
  { 222, 1, 6, 4, 2, -5 },
  { 223, 3, 6, 4, 1, -5 },
  { 226, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_SEMIBOLD7PT7B_H_
