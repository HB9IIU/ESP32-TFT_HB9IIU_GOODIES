#ifndef _IBMPLEXMONO_SEMIBOLD12PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8F, 0xBB, 0xBB, 0x34, 0x69, 0xB9, 0x42, 0x9D, 0xDA, 0x2C,
  0x10, 0x79, 0x5A, 0x87, 0x83, 0x85, 0xAB, 0xFC, 0x20, 0x63, 0x2A, 0x73,
  0x00, 0xE7, 0x56, 0xE7, 0x38, 0x91, 0x01, 0x07, 0x7B, 0xB3, 0x3B, 0xF0,
  0x36, 0x4C, 0xCC, 0xCC, 0x46, 0x30, 0xC6, 0x23, 0x11, 0x13, 0x26, 0xC0,
  0x10, 0x23, 0xF8, 0xC2, 0x8C, 0x80, 0x21, 0x3E, 0x42, 0x00, 0x6B, 0x60,
  0xE0, 0x7C, 0x08, 0xC4, 0x23, 0x10, 0x8C, 0x46, 0x20, 0x38, 0x89, 0x1E,
  0x3D, 0x6A, 0xD1, 0x1C, 0x38, 0xF3, 0x60, 0xC1, 0x83, 0x06, 0x3F, 0xF2,
  0x20, 0x86, 0x11, 0x8C, 0x3F, 0x7C, 0x88, 0x11, 0xC0, 0x40, 0xD1, 0x7C,
  0x1C, 0x38, 0xB3, 0x64, 0xDF, 0xC3, 0x06, 0xFA, 0x08, 0x2E, 0xCC, 0x38,
  0xBE, 0x39, 0x8C, 0x2E, 0xCE, 0x38, 0x9E, 0xFE, 0x29, 0x86, 0x30, 0xC2,
  0x18, 0x7C, 0x89, 0x11, 0xC4, 0x58, 0xD1, 0x9E, 0x38, 0x8B, 0x1A, 0x37,
  0xC1, 0x86, 0x38, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xB6, 0x09, 0xD9, 0x06,
  0x1C, 0x20, 0xF8, 0x3E, 0x87, 0x0E, 0x13, 0xF2, 0x00, 0x74, 0x42, 0x72,
  0x01, 0x8C, 0x72, 0x2B, 0xEB, 0xAE, 0xBB, 0xE0, 0x70, 0x38, 0x70, 0xA3,
  0x66, 0xCF, 0x91, 0xE3, 0xFB, 0x2C, 0xBC, 0xCB, 0x3C, 0xBE, 0x7B, 0x38,
  0x20, 0x82, 0x0C, 0xDE, 0xF2, 0x28, 0xE3, 0x8E, 0x38, 0xBC, 0xFE, 0x31,
  0xFC, 0x63, 0x1F, 0xFE, 0x31, 0xFC, 0x63, 0x18, 0x3D, 0x94, 0x10, 0xCD,
  0x16, 0x4F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F,
  0x78, 0xC6, 0x31, 0x8E, 0x7E, 0x8E, 0x6B, 0x28, 0xF3, 0x69, 0xA3, 0xC6,
  0x31, 0x8C, 0x63, 0x1F, 0xCF, 0x7F, 0xEF, 0xAE, 0xB8, 0xE3, 0xCE, 0x7B,
  0x5A, 0xDE, 0x73, 0x38, 0xC9, 0x1E, 0x3C, 0x68, 0xD9, 0x1C, 0xFB, 0x3C,
  0xF3, 0xFB, 0x0C, 0x30, 0x38, 0xC9, 0x1E, 0x3C, 0x68, 0xD9, 0x1E, 0x10,
  0x38, 0xFB, 0x2C, 0xF3, 0xFB, 0x4D, 0xB3, 0x3C, 0x8D, 0x03, 0xC0, 0xC0,
  0xD1, 0x7E, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x8C, 0x63, 0x18,
  0xC7, 0x2F, 0xC6, 0x8D, 0x93, 0x66, 0xC5, 0x0E, 0x1C, 0xC3, 0x87, 0x4E,
  0xF6, 0xED, 0xDB, 0xB6, 0xC6, 0xD8, 0xA1, 0xC3, 0x85, 0x9B, 0x63, 0xC6,
  0xC9, 0xB1, 0x43, 0x82, 0x04, 0x08, 0xF8, 0x61, 0x0C, 0x61, 0x0C, 0x3F,
  0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x86, 0x10, 0xC2, 0x10, 0xC2, 0x10,
  0xC2, 0xF1, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x50, 0xB2, 0x2C, 0x60,
  0xF8, 0xB4, 0xF2, 0x60, 0xBE, 0x8B, 0xF0, 0x82, 0x08, 0x2E, 0xCA, 0x38,
  0xF2, 0xB8, 0x7E, 0x61, 0x0C, 0xBC, 0x08, 0x43, 0xD9, 0xC6, 0x31, 0xF8,
  0x72, 0x2F, 0xE0, 0xC9, 0xE0, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0xF8,
  0x0D, 0xE8, 0xA2, 0x72, 0x07, 0xA3, 0xF8, 0x84, 0x21, 0x7C, 0xC6, 0x31,
  0x88, 0x30, 0xC0, 0x3C, 0x30, 0xC3, 0x0C, 0xFC, 0x13, 0x0F, 0x11, 0x11,
  0x11, 0xF0, 0x82, 0x08, 0x27, 0xB3, 0x8F, 0x26, 0x8C, 0xE1, 0x08, 0x42,
  0x10, 0x84, 0xF8, 0xFD, 0xAF, 0x5E, 0xBD, 0x7A, 0xC0, 0xBE, 0x63, 0x18,
  0xC4, 0x72, 0x28, 0xE3, 0x89, 0xC0, 0xBB, 0x28, 0xE3, 0xCA, 0xE8, 0x20,
  0xEC, 0xE3, 0x18, 0xFC, 0x21, 0xED, 0xC6, 0x18, 0x63, 0xE0, 0x7E, 0x7C,
  0x78, 0xFC, 0x30, 0xCF, 0xCC, 0x30, 0xC3, 0x07, 0x8C, 0x63, 0x1C, 0xFC,
  0xC6, 0xC9, 0xB1, 0x43, 0x87, 0x00, 0xD3, 0xB7, 0xAB, 0x76, 0xCD, 0x80,
  0x66, 0x58, 0xE1, 0xC2, 0xD8, 0xC0, 0xC6, 0xC9, 0xB1, 0x43, 0x82, 0x04,
  0x30, 0xF8, 0xCC, 0xCC, 0x7C, 0x39, 0x08, 0x61, 0x70, 0xC6, 0x21, 0x0E,
  0xFF, 0xE0, 0xE1, 0x8C, 0x46, 0x0D, 0x84, 0x31, 0xB8, 0x72, 0xAB, 0x30,
};

const GFXglyph IBMPlexMono_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 3, -8 },
  { 3, 4, 4, 7, 2, -9 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 7, 10, 7, 0, -9 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 7, 8, 7, 0, -8 },
  { 35, 1, 4, 7, 3, -9 },
  { 36, 4, 11, 7, 2, -9 },
  { 42, 4, 11, 7, 1, -9 },
  { 48, 7, 6, 7, 0, -7 },
  { 54, 5, 5, 7, 1, -6 },
  { 58, 3, 4, 7, 2, -2 },
  { 60, 3, 1, 7, 2, -4 },
  { 61, 3, 2, 7, 2, -2 },
  { 62, 5, 11, 7, 1, -9 },
  { 69, 7, 8, 7, 0, -8 },
  { 76, 7, 8, 7, 0, -8 },
  { 83, 6, 8, 7, 1, -8 },
  { 89, 7, 8, 7, 0, -8 },
  { 96, 7, 8, 7, 0, -8 },
  { 103, 6, 8, 7, 1, -8 },
  { 109, 6, 8, 7, 1, -8 },
  { 115, 6, 8, 7, 1, -8 },
  { 121, 7, 8, 7, 0, -8 },
  { 128, 7, 8, 7, 0, -8 },
  { 135, 3, 6, 7, 2, -6 },
  { 138, 3, 8, 7, 2, -6 },
  { 141, 5, 7, 7, 1, -7 },
  { 146, 5, 3, 7, 1, -5 },
  { 148, 5, 7, 7, 1, -7 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 6, 9, 7, 1, -8 },
  { 165, 7, 8, 7, 0, -8 },
  { 172, 6, 8, 7, 1, -8 },
  { 178, 6, 8, 7, 1, -8 },
  { 184, 6, 8, 7, 1, -8 },
  { 190, 5, 8, 7, 1, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 6, 8, 7, 0, -8 },
  { 206, 5, 8, 7, 1, -8 },
  { 211, 5, 8, 7, 1, -8 },
  { 216, 5, 8, 7, 1, -8 },
  { 221, 6, 8, 7, 1, -8 },
  { 227, 5, 8, 7, 1, -8 },
  { 232, 6, 8, 7, 1, -8 },
  { 238, 5, 8, 7, 1, -8 },
  { 243, 7, 8, 7, 0, -8 },
  { 250, 6, 8, 7, 1, -8 },
  { 256, 7, 10, 7, 0, -8 },
  { 265, 6, 8, 7, 1, -8 },
  { 271, 7, 8, 7, 0, -8 },
  { 278, 7, 8, 7, 0, -8 },
  { 285, 5, 8, 7, 1, -8 },
  { 290, 7, 8, 7, 0, -8 },
  { 297, 7, 8, 7, 0, -8 },
  { 304, 7, 8, 7, 0, -8 },
  { 311, 7, 8, 7, 0, -8 },
  { 318, 6, 8, 7, 1, -8 },
  { 324, 4, 11, 7, 2, -9 },
  { 330, 5, 11, 7, 1, -9 },
  { 337, 4, 11, 7, 1, -9 },
  { 343, 7, 5, 7, 0, -8 },
  { 348, 5, 1, 7, 1, 1 },
  { 349, 2, 3, 7, 2, -10 },
  { 350, 6, 6, 7, 1, -6 },
  { 355, 6, 9, 7, 1, -9 },
  { 362, 5, 6, 7, 1, -6 },
  { 366, 5, 9, 7, 1, -9 },
  { 372, 6, 6, 7, 1, -6 },
  { 377, 6, 9, 7, 1, -9 },
  { 384, 6, 9, 7, 1, -7 },
  { 391, 5, 9, 7, 1, -9 },
  { 397, 6, 9, 7, 1, -9 },
  { 404, 4, 11, 7, 1, -9 },
  { 410, 6, 9, 7, 1, -9 },
  { 417, 5, 9, 7, 1, -9 },
  { 423, 7, 6, 7, 0, -6 },
  { 429, 5, 6, 7, 1, -6 },
  { 433, 6, 6, 7, 1, -6 },
  { 438, 6, 8, 7, 1, -6 },
  { 444, 5, 8, 7, 1, -6 },
  { 449, 6, 6, 7, 1, -6 },
  { 454, 5, 6, 7, 1, -6 },
  { 458, 6, 8, 7, 0, -8 },
  { 464, 5, 6, 7, 1, -6 },
  { 468, 7, 6, 7, 0, -6 },
  { 474, 7, 6, 7, 0, -6 },
  { 480, 7, 6, 7, 0, -6 },
  { 486, 7, 8, 7, 0, -6 },
  { 493, 5, 6, 7, 1, -6 },
  { 497, 5, 11, 7, 1, -9 },
  { 504, 1, 11, 7, 3, -9 },
  { 506, 5, 11, 7, 1, -9 },
  { 513, 7, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_SEMIBOLD12PT7B_H_
