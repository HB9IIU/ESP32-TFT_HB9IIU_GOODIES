#ifndef _IBMPLEXMONO_SEMIBOLD38PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE1, 0xC3,
  0x87, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x0F, 0xF8, 0xFF, 0x3F, 0xE3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0x3F, 0xC0, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xE1, 0xE0, 0xFF, 0x87, 0xFB, 0xFE, 0x3F, 0xEF, 0xF8,
  0xFF, 0xBF, 0xE3, 0xFE, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x73, 0xE7, 0xC7,
  0x0C, 0x7C, 0x70, 0x87, 0xC7, 0x00, 0x7C, 0x70, 0x07, 0xE7, 0x00, 0x3F,
  0x70, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x73, 0xF0, 0x07, 0x1F, 0x00, 0x70, 0xF0, 0x07, 0x0F,
  0x10, 0x70, 0xF3, 0x87, 0x1F, 0x7E, 0x73, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3E, 0x7F, 0x80, 0x78, 0xFF, 0x81,
  0xE3, 0xFF, 0x83, 0xC7, 0x8F, 0x0F, 0x0E, 0x1E, 0x1E, 0x3C, 0x1C, 0x78,
  0x78, 0x38, 0xF0, 0x70, 0x73, 0xC0, 0xE1, 0xE7, 0x01, 0xE3, 0xDE, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x03, 0xDE, 0x3C, 0x0F, 0x38, 0x38, 0x1E, 0x70, 0x70, 0x78,
  0xE0, 0xE0, 0xF1, 0xC1, 0xC3, 0xC3, 0x83, 0x87, 0x87, 0x07, 0x1E, 0x0F,
  0x1E, 0x38, 0x0F, 0xF8, 0xF0, 0x1F, 0xE3, 0xC0, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xE1, 0xF0, 0x1E,
  0x07, 0x00, 0xF0, 0x20, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x9F, 0xF1, 0xFD, 0xFF,
  0x8F, 0xEF, 0xBE, 0x78, 0xF8, 0xFB, 0xC7, 0x87, 0xFE, 0x3C, 0x1F, 0xE1,
  0xE0, 0x7F, 0x0F, 0x01, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0xFF, 0x0F, 0xFF,
  0x7C, 0x7F, 0xF3, 0xF1, 0xFF, 0x0F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x38, 0x7C,
  0x31, 0xF3, 0xEF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x40,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x7C,
  0x01, 0xF1, 0xF0, 0x1F, 0x07, 0xC0, 0x70, 0x3C, 0x01, 0x80, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x9F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7C,
  0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x71, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x87, 0x1F,
  0x78, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xE3, 0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0,
  0xF8, 0x7C, 0x07, 0x07, 0xC0, 0x20, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE1, 0xF9,
  0xF0, 0x1F, 0xBE, 0x01, 0xF0, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xE3, 0xC0, 0x7E, 0x08, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF1, 0x00, 0x3F, 0x38, 0x03, 0xF7, 0xC0, 0x3E,
  0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x79, 0xF0, 0x03, 0xCF,
  0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x87, 0x80, 0x7C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x1F, 0x81,
  0xE7, 0xFC, 0x3D, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9E, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x88, 0x01, 0xF3,
  0x00, 0x7E, 0xF0, 0x0F, 0xBF, 0x83, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x8F, 0x81, 0xF7, 0xFC, 0x3D, 0xFF, 0xCF, 0xFF, 0xFD,
  0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x0F, 0xDF, 0x83, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xBC, 0x01, 0xF7, 0x80, 0x7E, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x83, 0xFB, 0xFF, 0xFE,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xFE, 0xF9, 0xFF, 0xFE, 0x1F, 0xF7,
  0xC1, 0xF8, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0, 0x3E, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xFD, 0xC0, 0x3E,
  0x20, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x07, 0x9E, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x79, 0xFE, 0x1F, 0xBF, 0xC7, 0xFF, 0xF8, 0xF1, 0xFF,
  0x1C, 0x1F, 0xE7, 0x83, 0xFC, 0xF0, 0x7F, 0x9E, 0x0F, 0xF3, 0xC1, 0xFE,
  0x78, 0x3F, 0xCF, 0x07, 0xF8, 0xE0, 0xFF, 0x1E, 0x1F, 0xE3, 0xFF, 0xFC,
  0x3F, 0x7B, 0x83, 0xEF, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xBC, 0x00, 0x3E, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x1E,
  0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81,
  0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xE0, 0x7E,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF,
  0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF0,
  0xFC, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xE7, 0xC0, 0x3E, 0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x83, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7E, 0x1F, 0x9F, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x0E, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xDF, 0x01, 0xF7, 0xE0, 0xFC, 0xFF, 0xEF, 0x3F, 0xFB, 0xC7,
  0xFC, 0xF0, 0x7C, 0x3C, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE3, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFD, 0xF0,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFB,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xB8, 0xEF, 0xF7,
  0xBD, 0xFE, 0xF7, 0xBF, 0xCE, 0xE7, 0xF9, 0xFC, 0xFF, 0x3F, 0x1F, 0xE3,
  0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC1,
  0x07, 0xF8, 0x20, 0xFF, 0x04, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xF7, 0x87, 0xFB, 0xC3, 0xFD, 0xE1, 0xFE, 0x78, 0xFF, 0x3C,
  0x7F, 0x9E, 0x3F, 0xC7, 0x9F, 0xE3, 0xCF, 0xF1, 0xF7, 0xF8, 0x7B, 0xFC,
  0x3D, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE3,
  0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF3, 0xE0, 0x3E, 0x3F,
  0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x81, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0x1F, 0x03,
  0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7,
  0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x03, 0xE3, 0xE0,
  0x1C, 0x7C, 0x00, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x30, 0x01, 0xF3, 0x80, 0x3F, 0x7E, 0x07, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D,
  0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xE1, 0xFE,
  0x1F, 0x0F, 0xF0, 0xF8, 0xFF, 0x87, 0xC7, 0xBE, 0x7F, 0x3D, 0xF3, 0xB9,
  0xE7, 0x9D, 0xCF, 0x3C, 0xEE, 0x79, 0xE7, 0x73, 0xCF, 0x3B, 0x9E, 0x7B,
  0x9E, 0xF3, 0xDC, 0xF7, 0x9E, 0xE3, 0xBC, 0xF7, 0x1D, 0xE7, 0xB8, 0xEF,
  0x3D, 0xC7, 0x79, 0xFE, 0x3F, 0xCF, 0xE1, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xF8,
  0x7E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xFC, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xF7, 0xE0, 0x0F,
  0xBE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE1,
  0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x7C, 0x07,
  0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0x10,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0x38, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x04, 0x07, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xC1, 0xF8, 0x60, 0x1F, 0x04,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3E,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xFC, 0x7F,
  0xF7, 0xEF, 0xFE, 0xFC, 0xFF, 0x8F, 0x87, 0xC0, 0xF0, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE,
  0xFC, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7E, 0xF7, 0xFF, 0xBD, 0xFF, 0xCF, 0x3F, 0xE3, 0xC3, 0xE0,
  0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE1, 0xFF, 0xE0,
  0x7B, 0xE0, 0x11, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x23, 0xF0, 0x1C, 0xFC, 0x1F, 0x7F, 0xFF,
  0x9F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x07, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7E, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7D, 0xF8,
  0x3F, 0x7F, 0xFF, 0xCF, 0xFD, 0xF1, 0xFE, 0x7C, 0x3F, 0x1F, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F,
  0x9E, 0x00, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x43, 0xF0, 0x3C,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xE0,
  0xF8, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7E,
  0x0F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE7, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF,
  0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF, 0x80, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xDF, 0x03, 0xF3, 0xE0, 0xFC,
  0x7C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xDF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0x7C, 0x0F, 0x8F, 0xC1,
  0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3F, 0x7C, 0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xC3, 0xCF, 0x3E, 0x7E, 0xF7, 0xF7,
  0xFF, 0x7F, 0xFF, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF8, 0xF8, 0x7C, 0xFF, 0x3E,
  0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xDF,
  0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0xF0, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE, 0xFC,
  0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7E, 0xF7, 0xFF, 0xBD, 0xFF, 0xCF, 0x3F, 0xE3, 0xC3, 0xE0, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D,
  0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7D, 0xF8, 0x3F, 0x7F, 0xFF, 0xCF, 0xFD, 0xF1, 0xFE, 0x7C,
  0x3F, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x7E, 0x07, 0x1F, 0x00, 0x87, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF3, 0x00, 0x7D, 0xF0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF, 0xE0,
  0x1F, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xFF, 0xFF, 0xBF, 0xF7, 0xCF, 0xF3, 0xE3, 0xF1, 0xF0, 0xFC, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x8F, 0x80, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x7D, 0xF0, 0x03, 0xDE, 0x00,
  0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F,
  0x87, 0xF8, 0xEE, 0x3F, 0xC7, 0x71, 0xDE, 0x3B, 0x8E, 0x71, 0xDC, 0x73,
  0xCE, 0xE7, 0x9E, 0x67, 0x3C, 0xF7, 0x19, 0xE7, 0xB8, 0xEF, 0x3D, 0xC7,
  0x79, 0xEE, 0x3B, 0x8F, 0x71, 0xDC, 0x3B, 0x0E, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1,
  0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x3E, 0x7E, 0x01, 0xF1, 0xF0, 0x1F,
  0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x80, 0xF9, 0xF8, 0x03, 0xF0, 0xF8, 0x00,
  0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x3F, 0xF8, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0x00, 0xC7, 0xF0,
  0x3D, 0xFF, 0x07, 0xBF, 0xF0, 0xFF, 0x9F, 0x3D, 0xE1, 0xFF, 0xBC, 0x3F,
  0xE7, 0x03, 0xFC, 0xE0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 27, 23, 8, -27 },
  { 25, 13, 12, 23, 5, -28 },
  { 45, 22, 27, 23, 0, -27 },
  { 120, 20, 35, 23, 1, -31 },
  { 208, 23, 27, 23, 0, -27 },
  { 286, 21, 27, 23, 1, -27 },
  { 357, 5, 12, 23, 9, -28 },
  { 365, 13, 34, 23, 7, -29 },
  { 421, 13, 34, 23, 3, -29 },
  { 477, 21, 19, 23, 1, -21 },
  { 527, 18, 18, 23, 2, -21 },
  { 568, 9, 12, 23, 7, -6 },
  { 582, 11, 4, 23, 6, -14 },
  { 588, 7, 7, 23, 8, -7 },
  { 595, 17, 34, 23, 3, -29 },
  { 668, 20, 27, 23, 1, -27 },
  { 736, 20, 27, 23, 2, -27 },
  { 804, 19, 27, 23, 2, -27 },
  { 869, 20, 27, 23, 1, -27 },
  { 937, 21, 27, 23, 1, -27 },
  { 1008, 19, 27, 23, 2, -27 },
  { 1073, 19, 27, 23, 2, -27 },
  { 1138, 19, 27, 23, 2, -27 },
  { 1203, 19, 27, 23, 2, -27 },
  { 1268, 19, 27, 23, 2, -27 },
  { 1333, 7, 20, 23, 8, -20 },
  { 1351, 9, 26, 23, 7, -20 },
  { 1381, 17, 23, 23, 3, -23 },
  { 1430, 18, 13, 23, 2, -18 },
  { 1460, 17, 23, 23, 3, -23 },
  { 1509, 17, 27, 23, 3, -27 },
  { 1567, 19, 31, 23, 2, -27 },
  { 1641, 22, 27, 23, 0, -27 },
  { 1716, 18, 27, 23, 3, -27 },
  { 1777, 19, 27, 23, 2, -27 },
  { 1842, 18, 27, 23, 3, -27 },
  { 1903, 17, 27, 23, 3, -27 },
  { 1961, 17, 27, 23, 3, -27 },
  { 2019, 18, 27, 23, 2, -27 },
  { 2080, 17, 27, 23, 3, -27 },
  { 2138, 17, 27, 23, 3, -27 },
  { 2196, 17, 27, 23, 2, -27 },
  { 2254, 20, 27, 23, 3, -27 },
  { 2322, 17, 27, 23, 4, -27 },
  { 2380, 19, 27, 23, 2, -27 },
  { 2445, 17, 27, 23, 3, -27 },
  { 2503, 20, 27, 23, 1, -27 },
  { 2571, 18, 27, 23, 3, -27 },
  { 2632, 20, 34, 23, 1, -27 },
  { 2717, 19, 27, 23, 3, -27 },
  { 2782, 20, 27, 23, 1, -27 },
  { 2850, 21, 27, 23, 1, -27 },
  { 2921, 18, 27, 23, 2, -27 },
  { 2982, 21, 27, 23, 1, -27 },
  { 3053, 21, 27, 23, 1, -27 },
  { 3124, 21, 27, 23, 1, -27 },
  { 3195, 23, 27, 23, 0, -27 },
  { 3273, 19, 27, 23, 2, -27 },
  { 3338, 12, 34, 23, 7, -29 },
  { 3389, 17, 34, 23, 3, -29 },
  { 3462, 11, 34, 23, 4, -29 },
  { 3509, 21, 17, 23, 1, -27 },
  { 3554, 19, 4, 23, 2, 3 },
  { 3564, 8, 9, 23, 6, -31 },
  { 3573, 19, 20, 23, 2, -20 },
  { 3621, 18, 28, 23, 3, -28 },
  { 3684, 17, 20, 23, 3, -20 },
  { 3727, 18, 28, 23, 2, -28 },
  { 3790, 19, 20, 23, 2, -20 },
  { 3838, 19, 28, 23, 2, -28 },
  { 3905, 20, 31, 23, 2, -23 },
  { 3983, 17, 28, 23, 3, -28 },
  { 4043, 17, 30, 23, 4, -30 },
  { 4107, 14, 38, 23, 3, -30 },
  { 4174, 19, 28, 23, 3, -28 },
  { 4241, 17, 28, 23, 3, -28 },
  { 4301, 20, 20, 23, 1, -20 },
  { 4351, 17, 20, 23, 3, -20 },
  { 4394, 19, 20, 23, 2, -20 },
  { 4442, 18, 28, 23, 3, -20 },
  { 4505, 18, 28, 23, 2, -20 },
  { 4568, 18, 20, 23, 3, -20 },
  { 4613, 18, 20, 23, 2, -20 },
  { 4658, 18, 27, 23, 2, -27 },
  { 4719, 17, 20, 23, 3, -20 },
  { 4762, 20, 20, 23, 1, -20 },
  { 4812, 21, 20, 23, 1, -20 },
  { 4865, 21, 20, 23, 1, -20 },
  { 4918, 21, 28, 23, 1, -20 },
  { 4992, 17, 20, 23, 3, -20 },
  { 5035, 15, 34, 23, 4, -29 },
  { 5099, 4, 34, 23, 9, -29 },
  { 5116, 15, 34, 23, 4, -29 },
  { 5180, 19, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_SEMIBOLD38PT7B_H_
