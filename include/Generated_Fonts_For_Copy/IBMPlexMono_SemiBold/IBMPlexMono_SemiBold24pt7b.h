#ifndef _IBMPLEXMONO_SEMIBOLD24PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x66, 0x20, 0x0F, 0xFF, 0xF0, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x07, 0x30, 0x19, 0xC0, 0x67, 0x01,
  0x9C, 0x0E, 0x61, 0xF9, 0xF7, 0xE7, 0xC3, 0x38, 0x0C, 0xE0, 0x33, 0x8F,
  0xCF, 0xBF, 0x3E, 0x18, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0x80,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0x83, 0xFE, 0x3F, 0xF9, 0xD9, 0x9C,
  0xC8, 0xF6, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0x38, 0x18,
  0xC8, 0xCF, 0xF6, 0x77, 0xFF, 0x9F, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x0D, 0xF8, 0x66, 0x63, 0xB9, 0xCC, 0xE7, 0x73, 0x9D, 0x86, 0x6E,
  0x1F, 0x80, 0x3C, 0xF0, 0x07, 0xE0, 0xD9, 0xC6, 0x63, 0x19, 0x8C, 0xC6,
  0x37, 0x19, 0xD8, 0x7E, 0xE0, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0x8E, 0x0E,
  0x20, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x3E, 0x3D, 0xDC, 0xF7,
  0x3B, 0x38, 0xEC, 0xE1, 0xE1, 0x83, 0x87, 0x1F, 0x1F, 0xCE, 0x1E, 0x3C,
  0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07,
  0xF0, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x06, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC1, 0x8E, 0x6F, 0xFF, 0x7F, 0xFC, 0x7E, 0x01, 0xF0, 0x1F, 0x81,
  0xCE, 0x1E, 0x38, 0x21, 0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x0F, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3D,
  0xE7, 0x9C, 0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xFF, 0xF7, 0xBF, 0xE0, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0xCE, 0xE7, 0x7F, 0x33, 0xF8, 0x1D, 0xC0, 0xEF,
  0x07, 0x38, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x0F,
  0xE0, 0xF7, 0x0F, 0x38, 0x71, 0xC1, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x0F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0xF2, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0x20, 0xF0, 0x0F, 0x00,
  0xE0, 0xFC, 0x0F, 0x80, 0xFE, 0x00, 0xF0, 0x07, 0x60, 0x7F, 0x0F, 0xFF,
  0xE7, 0xFE, 0x1F, 0x80, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xDC,
  0x0E, 0xE0, 0x67, 0x06, 0x38, 0x71, 0xC3, 0x0E, 0x38, 0x71, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0x00, 0x70, 0x07, 0x78, 0x6F, 0xE7, 0xFF, 0x70, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x60, 0x7F, 0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x3C, 0x7F, 0xEE, 0xFF, 0xF0, 0xFF,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xE3, 0xFC, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xEE, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0x0F, 0x70, 0x77, 0x07, 0x70,
  0xE3, 0xFC, 0x1F, 0x87, 0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0x7F,
  0xF7, 0xFE, 0x1F, 0x80, 0x0F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0x71, 0xEE, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0xF7, 0xBF, 0xE0, 0x00, 0x00, 0x07,
  0xBD, 0xFF, 0x00, 0x79, 0xE7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x9E,
  0x71, 0xC7, 0x18, 0xE0, 0x00, 0x40, 0x30, 0x3C, 0x3E, 0x3E, 0x3E, 0x0F,
  0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xC0, 0x10, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x38, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1C, 0x07, 0x07, 0xC7, 0xC7, 0xE3, 0xE0,
  0xE0, 0x20, 0x00, 0x1F, 0x0F, 0xF3, 0xFF, 0x70, 0xEC, 0x1E, 0x03, 0x80,
  0x70, 0x3C, 0x1F, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80,
  0xF0, 0x1C, 0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0x60, 0x3E, 0x3B,
  0xE7, 0xFE, 0x67, 0xEE, 0x3E, 0xE3, 0xEE, 0x3E, 0xE3, 0xEE, 0x3E, 0x7F,
  0xE7, 0xB6, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C,
  0x70, 0xE1, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xF9, 0xC0, 0xE7, 0x03, 0x9C,
  0x0F, 0xF0, 0x1C, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x1F, 0xC3, 0xF8,
  0x77, 0xFC, 0xFF, 0x9F, 0xFB, 0x87, 0xF0, 0x7E, 0x0F, 0xC3, 0xFF, 0xFF,
  0xFE, 0xFF, 0x80, 0x0F, 0x83, 0xFE, 0x3F, 0xE7, 0x8F, 0x70, 0x7F, 0x04,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x04, 0x70, 0x77, 0x8F,
  0x3F, 0xE3, 0xFE, 0x0F, 0x80, 0xFF, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xFF, 0xF7, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8E, 0xF0,
  0x7E, 0x04, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF, 0x07, 0xF0,
  0x77, 0x8F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7E,
  0x0E, 0xE3, 0xDF, 0xF9, 0xFE, 0x1F, 0x00, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE,
  0x3C, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8E,
  0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x7F, 0x0F,
  0xF8, 0xFF, 0x9F, 0xFD, 0xBF, 0xDB, 0xEF, 0xBE, 0xF3, 0xE7, 0x3E, 0x63,
  0xE6, 0x3E, 0x23, 0xE4, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0xF0,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xB1, 0xF7, 0x3E, 0x67, 0xCE, 0xF9,
  0xDF, 0x1B, 0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xE0, 0x0F,
  0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEF, 0x07, 0x38, 0x79, 0xFF, 0x87,
  0xF8, 0x1F, 0x80, 0xFF, 0x9F, 0xFB, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xFF, 0xFF, 0xFB, 0xFE, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEF, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEF, 0x07,
  0x38, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1,
  0xCE, 0x1E, 0xE0, 0xF0, 0x1F, 0x83, 0xFE, 0x7F, 0xF7, 0x06, 0xF0, 0x4F,
  0x00, 0x78, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0xF0, 0x07, 0x40, 0x7F,
  0x0F, 0xFF, 0xF7, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x77, 0x07, 0x70, 0x77, 0x0F, 0x7F, 0xE3, 0xFE, 0x1F, 0x80,
  0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0x87,
  0x0F, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0xE0, 0x1D, 0x80, 0x76, 0x01, 0xD8,
  0x07, 0x63, 0x9D, 0x8E, 0x76, 0x79, 0xDD, 0xE6, 0x77, 0x99, 0xDB, 0x67,
  0x6D, 0x9F, 0x36, 0x7C, 0xD9, 0xF3, 0x67, 0xCF, 0x9F, 0x1E, 0x3C, 0x78,
  0x70, 0x3D, 0xE0, 0xE3, 0xC7, 0x07, 0x1C, 0x1E, 0xE0, 0x3B, 0x80, 0xFC,
  0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x07, 0xB8, 0x1C, 0xF0, 0xF1,
  0xC3, 0x87, 0x9C, 0x0E, 0xF0, 0x3C, 0xF0, 0x1D, 0xC0, 0xE7, 0x83, 0x8E,
  0x1E, 0x3C, 0x70, 0x73, 0xC1, 0xEE, 0x03, 0xB8, 0x0F, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x0F,
  0x00, 0x7C, 0x07, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0x71, 0xC3, 0x8E, 0x0E,
  0xE0, 0x77, 0x01, 0xD0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x67, 0x1C,
  0x61, 0x80, 0x1F, 0x83, 0xFE, 0x1C, 0x78, 0x41, 0xC0, 0x0E, 0x0F, 0xF1,
  0xFF, 0x9E, 0x1C, 0xE0, 0xE7, 0x8F, 0x1F, 0xFE, 0x7C, 0xF0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0xFE, 0xF1, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0xFF, 0xDD, 0xF0, 0x1F,
  0x0F, 0xF9, 0xC7, 0xF0, 0x4E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x8E,
  0x3D, 0xFF, 0x0F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x1E, 0x77, 0xF7, 0x70, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x77, 0x0F, 0x7F, 0x71, 0xE7, 0x0F, 0x83, 0xFC, 0x78, 0xE7,
  0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x86, 0x3F, 0xF0,
  0xFC, 0x07, 0xE1, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x07, 0x87, 0xF0, 0x7F, 0xC7, 0x0E, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x3F, 0xC0, 0xFC, 0x08, 0x00, 0xC0, 0x07, 0xFE, 0x1F,
  0xF9, 0xFF, 0xFC, 0x07, 0xE0, 0x3B, 0xFF, 0x8F, 0xF0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0x7E, 0xF1, 0xDC, 0x3F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x0E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0xFF, 0xFF, 0xFC, 0x07,
  0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x77, 0xFB,
  0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE,
  0x3C, 0xE7, 0x8E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0E, 0x78, 0xE3, 0x8E,
  0x1C, 0xE1, 0xEE, 0x0F, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xFF, 0xFF, 0xFC, 0xCC, 0xED, 0xFF, 0xE7, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xE7,
  0x9D, 0xFB, 0xC7, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x70, 0x1F, 0x83, 0xFC, 0x70, 0xE7, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x0E, 0x3F, 0xC1, 0xF8, 0xE7, 0x9F,
  0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3F,
  0xFF, 0x77, 0xCE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x77,
  0xF7, 0x70, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77,
  0x0F, 0x7F, 0x71, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xFC, 0xFF, 0xBC, 0x77, 0x8F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x83, 0xFF, 0x7F, 0xE0, 0x1F, 0xC3, 0xFE, 0x70, 0x77, 0x04, 0x70,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0x40, 0x77, 0x0F, 0xFF, 0xE1, 0xF8, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x07,
  0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xFE, 0x3D, 0xFB, 0x9E, 0x70, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x0E,
  0x38, 0xE3, 0x8C, 0x39, 0xC1, 0xDC, 0x1D, 0x81, 0xF8, 0x0F, 0x80, 0xF0,
  0xE3, 0x8D, 0x8E, 0x76, 0x79, 0xD9, 0xE7, 0x66, 0x99, 0x9B, 0x67, 0x6D,
  0x9D, 0x36, 0x7C, 0xD8, 0xF3, 0x63, 0xC7, 0x8F, 0x1E, 0xF0, 0x73, 0xC7,
  0x0E, 0x70, 0x3B, 0x81, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x3D, 0xC1,
  0xCF, 0x1C, 0x39, 0xC0, 0xF0, 0xE0, 0x7F, 0x83, 0x9C, 0x1C, 0xE1, 0xC3,
  0x8E, 0x1C, 0x60, 0xE7, 0x03, 0xB8, 0x1D, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x0F, 0x80, 0x78, 0x00, 0xFF, 0xDF, 0xF8,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC7, 0xF1, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x07, 0x3F, 0x0F, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x3F, 0x80, 0x60, 0x18, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x1C,
  0x03, 0xF0, 0xFC, 0x70, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x63, 0xF8, 0xFC, 0x00, 0x3C, 0x37, 0xE3, 0x67, 0x7E, 0x3E, 0xC1, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 8, 14, 3, -18 },
  { 18, 14, 17, 14, 0, -17 },
  { 48, 13, 22, 14, 1, -20 },
  { 84, 14, 17, 14, 0, -17 },
  { 114, 14, 17, 14, 0, -17 },
  { 144, 3, 8, 14, 6, -18 },
  { 147, 8, 21, 14, 4, -18 },
  { 168, 8, 21, 14, 2, -18 },
  { 189, 13, 12, 14, 1, -13 },
  { 209, 12, 12, 14, 1, -13 },
  { 227, 6, 8, 14, 4, -4 },
  { 233, 8, 3, 14, 3, -9 },
  { 236, 5, 4, 14, 5, -4 },
  { 239, 11, 21, 14, 2, -18 },
  { 268, 13, 17, 14, 1, -17 },
  { 296, 13, 17, 14, 1, -17 },
  { 324, 12, 17, 14, 1, -17 },
  { 350, 12, 17, 14, 1, -17 },
  { 376, 13, 17, 14, 1, -17 },
  { 404, 12, 17, 14, 1, -17 },
  { 430, 12, 17, 14, 1, -17 },
  { 456, 12, 17, 14, 1, -17 },
  { 482, 12, 17, 14, 1, -17 },
  { 508, 12, 17, 14, 1, -17 },
  { 534, 5, 13, 14, 5, -13 },
  { 543, 6, 17, 14, 4, -13 },
  { 556, 10, 14, 14, 2, -14 },
  { 574, 12, 7, 14, 1, -11 },
  { 585, 10, 14, 14, 2, -14 },
  { 603, 11, 17, 14, 2, -17 },
  { 627, 12, 20, 14, 1, -17 },
  { 657, 14, 17, 14, 0, -17 },
  { 687, 11, 17, 14, 2, -17 },
  { 711, 12, 17, 14, 1, -17 },
  { 737, 11, 17, 14, 2, -17 },
  { 761, 11, 17, 14, 2, -17 },
  { 785, 11, 17, 14, 2, -17 },
  { 809, 12, 17, 14, 1, -17 },
  { 835, 11, 17, 14, 2, -17 },
  { 859, 11, 17, 14, 2, -17 },
  { 883, 11, 17, 14, 1, -17 },
  { 907, 12, 17, 14, 2, -17 },
  { 933, 11, 17, 14, 2, -17 },
  { 957, 12, 17, 14, 1, -17 },
  { 983, 11, 17, 14, 2, -17 },
  { 1007, 13, 17, 14, 1, -17 },
  { 1035, 11, 17, 14, 2, -17 },
  { 1059, 13, 21, 14, 1, -17 },
  { 1094, 12, 17, 14, 2, -17 },
  { 1120, 12, 17, 14, 1, -17 },
  { 1146, 13, 17, 14, 1, -17 },
  { 1174, 12, 17, 14, 1, -17 },
  { 1200, 14, 17, 14, 0, -17 },
  { 1230, 14, 17, 14, 0, -17 },
  { 1260, 14, 17, 14, 0, -17 },
  { 1290, 14, 17, 14, 0, -17 },
  { 1320, 12, 17, 14, 1, -17 },
  { 1346, 7, 21, 14, 5, -18 },
  { 1365, 11, 21, 14, 2, -18 },
  { 1394, 8, 21, 14, 2, -18 },
  { 1415, 13, 11, 14, 1, -17 },
  { 1433, 12, 3, 14, 1, 2 },
  { 1438, 5, 5, 14, 4, -19 },
  { 1442, 13, 12, 14, 1, -12 },
  { 1462, 11, 18, 14, 2, -18 },
  { 1487, 11, 12, 14, 2, -12 },
  { 1504, 12, 18, 14, 1, -18 },
  { 1531, 12, 12, 14, 1, -12 },
  { 1549, 11, 18, 14, 2, -18 },
  { 1574, 13, 19, 14, 1, -14 },
  { 1605, 11, 18, 14, 2, -18 },
  { 1630, 11, 18, 14, 2, -18 },
  { 1655, 9, 23, 14, 2, -18 },
  { 1681, 12, 18, 14, 2, -18 },
  { 1708, 11, 18, 14, 2, -18 },
  { 1733, 12, 12, 14, 1, -12 },
  { 1751, 11, 12, 14, 2, -12 },
  { 1768, 12, 12, 14, 1, -12 },
  { 1786, 11, 17, 14, 2, -12 },
  { 1810, 12, 17, 14, 1, -12 },
  { 1836, 11, 12, 14, 2, -12 },
  { 1853, 12, 12, 14, 1, -12 },
  { 1871, 12, 17, 14, 1, -17 },
  { 1897, 11, 12, 14, 2, -12 },
  { 1914, 12, 12, 14, 1, -12 },
  { 1932, 14, 12, 14, 0, -12 },
  { 1953, 13, 12, 14, 1, -12 },
  { 1973, 13, 17, 14, 1, -12 },
  { 2001, 11, 12, 14, 2, -12 },
  { 2018, 10, 21, 14, 2, -18 },
  { 2045, 3, 21, 14, 6, -18 },
  { 2053, 10, 21, 14, 2, -18 },
  { 2080, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_SEMIBOLD24PT7B_H_
