#ifndef _IBMPLEXMONO_SEMIBOLD45PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC,
  0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x3F, 0xF8, 0x7F, 0xE7, 0xFF,
  0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x9F, 0xF8, 0x7F, 0xF3, 0xFF, 0x0F, 0xFE,
  0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE1,
  0xF0, 0x00, 0x3C, 0x3E, 0x03, 0xFF, 0x87, 0xFE, 0x7F, 0xF0, 0xFF, 0xCF,
  0xFE, 0x1F, 0xF9, 0xFF, 0x87, 0xFF, 0x3F, 0xF0, 0xFF, 0xE0, 0x1E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFD, 0xFC, 0xF7, 0xF3, 0xF1, 0xE3, 0xC7,
  0xC3, 0xC1, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7E,
  0x3C, 0x00, 0xFE, 0x78, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3D,
  0xFE, 0x00, 0x78, 0xFC, 0x00, 0xF1, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xC3,
  0xE4, 0x07, 0x87, 0xCE, 0x0F, 0x1F, 0xBE, 0x1E, 0x3F, 0xFF, 0x3D, 0xFD,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7C,
  0xFF, 0xE0, 0x1F, 0x3E, 0x3C, 0x03, 0xC7, 0x83, 0xC0, 0xF8, 0xF0, 0x78,
  0x1E, 0x1E, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x0F,
  0x07, 0x87, 0x81, 0xE0, 0xF1, 0xF0, 0x3C, 0x1E, 0x3C, 0x07, 0xC7, 0xCF,
  0x80, 0x7F, 0xF1, 0xE0, 0x07, 0xFC, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xCF, 0xFE, 0x01, 0xF1, 0xE3,
  0xC0, 0x3E, 0x78, 0x3C, 0x07, 0x8F, 0x07, 0x81, 0xF1, 0xE0, 0xF0, 0x3C,
  0x3C, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x0F,
  0x0F, 0x03, 0xC1, 0xE3, 0xE0, 0x78, 0x3C, 0x78, 0x07, 0x8F, 0x1F, 0x00,
  0xFF, 0xE3, 0xC0, 0x0F, 0xF8, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x04, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x1F, 0xF8, 0x7F, 0x8F, 0xFF, 0x1F, 0xE7, 0xEF, 0xC7, 0xF9, 0xF1,
  0xF9, 0xF0, 0xFC, 0x7F, 0x78, 0x3E, 0x0F, 0xDE, 0x0F, 0x81, 0xFF, 0x83,
  0xE0, 0x3F, 0xE0, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x83, 0xF8, 0x3F, 0xF0, 0x7F, 0xFE, 0xFE, 0x1F, 0xFF, 0x9F, 0x83, 0xFF,
  0xC3, 0xF0, 0x7F, 0xE0, 0x7E, 0x07, 0xE0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1F, 0x03, 0x7E, 0x3E, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xEF,
  0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0xC0, 0x18, 0x00, 0x80, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xCF, 0xF3, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x1F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFC, 0x7C, 0x7F, 0xF8, 0xF8, 0xFF, 0xF1,
  0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xFC, 0x07,
  0xF1, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0x80,
  0x3F, 0x9F, 0x80, 0x7F, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0x78, 0x1F, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0x1F, 0x80, 0x7E, 0x7E,
  0x00, 0xFE, 0x3C, 0x00, 0xFC, 0x10, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xF0, 0x3F, 0x87, 0x80, 0x3F, 0x86, 0x00, 0x7F, 0x04, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x08, 0x00, 0x7E, 0x78,
  0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE1, 0xFC, 0x03, 0xC7, 0xFE,
  0x07, 0x9F, 0xFE, 0x0F, 0x7F, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0x83, 0xFC,
  0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8C, 0x00, 0x3F, 0x3C, 0x00, 0xFE, 0xFC,
  0x01, 0xFB, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xFE, 0x0F, 0xDF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x7E, 0xFF, 0xFE, 0xFF, 0x83, 0xFD, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xF8, 0xFE, 0x0F,
  0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF8, 0x3F, 0x83, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF1, 0xFE, 0x0F, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFB, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xBF, 0xC1, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFB, 0xF0, 0x7F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x18, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8,
  0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x3C, 0xF0, 0x3E, 0x79, 0xE0, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xC7,
  0xFF, 0x1F, 0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x78, 0x1F, 0xF8, 0xF0, 0x3F,
  0xF1, 0xE0, 0x7F, 0xE3, 0xC0, 0xFF, 0xC7, 0x81, 0xFF, 0x8F, 0x03, 0xFF,
  0x1E, 0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x7C, 0x1F, 0xF8, 0x78, 0x3E, 0xF0,
  0xFF, 0xFD, 0xE0, 0xFF, 0xFB, 0xC0, 0xFD, 0xF7, 0xC0, 0x40, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xE7, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80,
  0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7C, 0x07, 0xF3, 0xE0, 0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0xFE, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3E, 0x01,
  0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xF8, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x38, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x03, 0xF1, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x01, 0x8F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xF0, 0x0F,
  0xCF, 0xE0, 0xFF, 0x3F, 0xFF, 0x7C, 0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC1,
  0xFF, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x10, 0x07, 0xEF, 0x80, 0x3F, 0xFC, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xBF, 0x80, 0xFF, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFB, 0xC7, 0xBF, 0xF7, 0xCF,
  0x7F, 0xEF, 0xBE, 0xFF, 0xCF, 0xF9, 0xFF, 0x9F, 0xF3, 0xFF, 0x1F, 0xC7,
  0xFE, 0x3F, 0x8F, 0xFC, 0x7F, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF0, 0xFF, 0xC1, 0xC1, 0xFF, 0x83, 0x83, 0xFF, 0x02, 0x07, 0xFE,
  0x04, 0x0F, 0xFC, 0x08, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xDF, 0x07, 0xFE, 0xF8, 0x3F, 0xF7, 0xE1, 0xFF, 0x9F, 0x0F,
  0xFC, 0xF8, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC3,
  0xE7, 0xFE, 0x1F, 0x3F, 0xF0, 0xFD, 0xFF, 0x83, 0xEF, 0xFC, 0x1F, 0x7F,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xF0, 0x3F, 0x9F, 0xC0, 0x1E, 0x3F, 0x00, 0x18, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x10, 0x00, 0x7E, 0x70, 0x01, 0xFD,
  0xF0, 0x03, 0xF7, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8,
  0x3F, 0x0F, 0xFC, 0x3F, 0x87, 0xDE, 0x1F, 0xC3, 0xCF, 0x8F, 0xE1, 0xE7,
  0xC7, 0xF0, 0xF3, 0xE3, 0xB8, 0x79, 0xF1, 0xDE, 0x7C, 0xF9, 0xEF, 0x3E,
  0x7C, 0xF7, 0x9F, 0x3E, 0x7B, 0xCF, 0x9F, 0x3D, 0xE7, 0xCF, 0x9C, 0x7B,
  0xE7, 0xDE, 0x3D, 0xF3, 0xEF, 0x1E, 0xF9, 0xF7, 0x8F, 0x7C, 0xFB, 0xC7,
  0xBE, 0x7D, 0xE3, 0xDF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x87,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xAF, 0x00, 0x07, 0xA1, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x08, 0x1E, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0x81, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xF8, 0x3F, 0x83, 0x80, 0x7F, 0x04, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x80, 0xFC, 0xF8,
  0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xF7, 0xFF, 0x9F, 0xCF, 0xFC, 0x1F, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x0F, 0xCF, 0xFC, 0x3F, 0x3F, 0xF8, 0xFD, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xBF, 0x80, 0x7E, 0xFF, 0x07, 0xFB, 0xFF, 0xFF, 0xCF, 0xDF,
  0xFF, 0x3F, 0x3F, 0xF8, 0xFC, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xC1, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x18, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x06, 0x1F, 0x80, 0x7C,
  0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF,
  0x3F, 0x3F, 0xFE, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x83, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xFF, 0x3F, 0x0F, 0xFC, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x40, 0xFC, 0x01, 0xC1, 0xFC, 0x0F, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0,
  0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x83, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x7C, 0x00, 0x7F, 0x78, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x1F, 0xF1, 0xF9, 0xFF, 0xCF, 0xDF,
  0xFF, 0x7E, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x7F, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0x9F, 0x80, 0xFE,
  0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0xF9, 0xE7, 0xE3, 0xFB, 0xCF, 0xE7,
  0xF7, 0xBF, 0xDF, 0xFF, 0x7F, 0xBF, 0xFF, 0x1F, 0xC7, 0xFE, 0x1F, 0x0F,
  0xF8, 0x3E, 0x1F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F,
  0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8,
  0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F, 0x83,
  0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E,
  0x0F, 0x00, 0x3F, 0x07, 0xE3, 0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF,
  0xDF, 0xFF, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xFC,
  0x1F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF3, 0xFF, 0x0F, 0xCF, 0xFE,
  0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0xC1, 0xFE, 0xFF,
  0xFF, 0xF3, 0xF7, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F, 0x3F, 0xF0, 0xFC, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xF3, 0xF1, 0xFF, 0xCF, 0xCF, 0xFF, 0xBF, 0x3F, 0xFF,
  0xFD, 0xFE, 0x0F, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xE0, 0x1F, 0xDF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFB, 0xF1,
  0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xD8, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFE, 0x07, 0xC3, 0xE0, 0x02, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x40, 0x03, 0xF3,
  0xC0, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0xC1, 0xFE, 0xFF,
  0xFB, 0xF7, 0xFF, 0xDF, 0x9F, 0xFC, 0xFC, 0x7F, 0xC7, 0xE0, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x3E, 0x07, 0xFC, 0x1F,
  0x03, 0xFE, 0x0F, 0xC3, 0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFF, 0xC3,
  0xF8, 0x7F, 0xE1, 0xDC, 0x3E, 0xF0, 0xEE, 0x1E, 0x78, 0x77, 0x8F, 0x3C,
  0x7B, 0xC7, 0x9F, 0x3D, 0xE3, 0xCF, 0x9C, 0x71, 0xE7, 0xCE, 0x39, 0xF3,
  0xE7, 0x1C, 0xF9, 0xF3, 0x8F, 0x7C, 0x7B, 0xC7, 0xBC, 0x3D, 0xE3, 0xDE,
  0x1E, 0xE0, 0xEF, 0x0F, 0x70, 0x77, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0xFE, 0x01,
  0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x1C, 0x3F, 0xC0, 0x3C,
  0xFF, 0xC0, 0xF9, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xCF, 0x9F, 0xCF, 0x9E,
  0x1F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF9, 0xE0, 0x1F, 0xE1, 0xC0,
  0x1F, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 32, 27, 9, -31 },
  { 37, 15, 14, 27, 6, -33 },
  { 64, 27, 31, 27, 0, -31 },
  { 169, 23, 43, 27, 2, -37 },
  { 293, 27, 33, 27, 0, -32 },
  { 405, 26, 33, 27, 1, -32 },
  { 513, 5, 14, 27, 11, -33 },
  { 522, 15, 40, 27, 8, -34 },
  { 597, 15, 40, 27, 4, -34 },
  { 672, 23, 23, 27, 2, -25 },
  { 739, 21, 23, 27, 3, -25 },
  { 800, 10, 14, 27, 8, -7 },
  { 818, 13, 5, 27, 7, -16 },
  { 827, 9, 8, 27, 9, -8 },
  { 836, 19, 40, 27, 4, -34 },
  { 931, 23, 33, 27, 2, -32 },
  { 1026, 24, 31, 27, 2, -31 },
  { 1119, 23, 32, 27, 2, -32 },
  { 1211, 23, 33, 27, 1, -32 },
  { 1306, 25, 31, 27, 1, -31 },
  { 1403, 23, 32, 27, 2, -31 },
  { 1495, 23, 32, 27, 2, -31 },
  { 1587, 23, 31, 27, 2, -31 },
  { 1677, 23, 33, 27, 2, -32 },
  { 1772, 23, 32, 27, 2, -32 },
  { 1864, 9, 24, 27, 9, -24 },
  { 1891, 10, 31, 27, 8, -24 },
  { 1930, 19, 27, 27, 4, -27 },
  { 1995, 21, 15, 27, 3, -21 },
  { 2035, 19, 27, 27, 4, -27 },
  { 2100, 20, 33, 27, 3, -32 },
  { 2183, 23, 37, 27, 2, -32 },
  { 2290, 25, 31, 27, 1, -31 },
  { 2387, 21, 31, 27, 4, -31 },
  { 2469, 23, 33, 27, 2, -32 },
  { 2564, 22, 31, 27, 3, -31 },
  { 2650, 20, 31, 27, 4, -31 },
  { 2728, 20, 31, 27, 4, -31 },
  { 2806, 22, 33, 27, 2, -32 },
  { 2897, 21, 31, 27, 3, -31 },
  { 2979, 19, 31, 27, 4, -31 },
  { 3053, 21, 32, 27, 2, -31 },
  { 3137, 24, 31, 27, 3, -31 },
  { 3230, 20, 31, 27, 4, -31 },
  { 3308, 23, 31, 27, 2, -31 },
  { 3398, 21, 31, 27, 3, -31 },
  { 3480, 23, 33, 27, 2, -32 },
  { 3575, 21, 31, 27, 4, -31 },
  { 3657, 23, 41, 27, 2, -32 },
  { 3775, 22, 31, 27, 4, -31 },
  { 3861, 23, 33, 27, 2, -32 },
  { 3956, 25, 31, 27, 1, -31 },
  { 4053, 21, 32, 27, 3, -31 },
  { 4137, 25, 31, 27, 1, -31 },
  { 4234, 25, 31, 27, 1, -31 },
  { 4331, 25, 31, 27, 1, -31 },
  { 4428, 27, 31, 27, 0, -31 },
  { 4533, 23, 31, 27, 2, -31 },
  { 4623, 14, 40, 27, 9, -34 },
  { 4693, 19, 40, 27, 4, -34 },
  { 4788, 14, 40, 27, 4, -34 },
  { 4858, 25, 20, 27, 1, -31 },
  { 4921, 21, 5, 27, 3, 3 },
  { 4935, 9, 10, 27, 7, -36 },
  { 4947, 22, 25, 27, 3, -24 },
  { 5016, 22, 34, 27, 3, -33 },
  { 5110, 21, 25, 27, 3, -24 },
  { 5176, 22, 34, 27, 2, -33 },
  { 5270, 23, 25, 27, 2, -24 },
  { 5342, 22, 33, 27, 3, -33 },
  { 5433, 24, 38, 27, 2, -28 },
  { 5547, 21, 33, 27, 3, -33 },
  { 5634, 21, 34, 27, 4, -34 },
  { 5724, 16, 43, 27, 4, -34 },
  { 5810, 23, 33, 27, 3, -33 },
  { 5905, 21, 33, 27, 3, -33 },
  { 5992, 23, 24, 27, 2, -24 },
  { 6061, 21, 24, 27, 3, -24 },
  { 6124, 23, 25, 27, 2, -24 },
  { 6196, 22, 33, 27, 3, -24 },
  { 6287, 22, 33, 27, 2, -24 },
  { 6378, 22, 23, 27, 3, -23 },
  { 6442, 22, 25, 27, 2, -24 },
  { 6511, 22, 31, 27, 2, -31 },
  { 6597, 21, 24, 27, 3, -23 },
  { 6660, 23, 23, 27, 2, -23 },
  { 6727, 25, 23, 27, 1, -23 },
  { 6799, 23, 23, 27, 2, -23 },
  { 6866, 25, 32, 27, 1, -23 },
  { 6966, 21, 23, 27, 3, -23 },
  { 7027, 19, 40, 27, 4, -34 },
  { 7122, 5, 40, 27, 11, -34 },
  { 7147, 19, 40, 27, 4, -34 },
  { 7242, 23, 11, 27, 2, -19 },
};

const GFXfont IBMPlexMono_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_SEMIBOLD45PT7B_H_
