#ifndef _IBMPLEXMONO_SEMIBOLD65PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFC, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF,
  0xC0, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xF0, 0x3F, 0xFF,
  0x3F, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xFF, 0xCF, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xFF,
  0x81, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xFE,
  0x7F, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0x81,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x7E, 0xFF, 0xE0, 0xFF, 0x8F, 0xC3,
  0xF8, 0x3F, 0xE1, 0xF8, 0x3E, 0x07, 0xF8, 0x3F, 0x01, 0x80, 0xFF, 0x07,
  0xE0, 0x20, 0x1F, 0xE0, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x7F,
  0x83, 0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x00,
  0x3F, 0xF1, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xFF,
  0x00, 0x00, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x80, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x01,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x03, 0xFC, 0x10, 0x07, 0xE0, 0xFF, 0x07,
  0x80, 0xFC, 0x1F, 0xE1, 0xF8, 0x1F, 0x87, 0xFC, 0x7F, 0xC3, 0xF1, 0xFF,
  0x1F, 0xFE, 0x7E, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x00,
  0x0F, 0xC3, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0xFC, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF0,
  0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x7F, 0x00,
  0x7E, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC7, 0xE0, 0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x03,
  0xF1, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x83,
  0xF8, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0xC1,
  0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x00,
  0x3F, 0xF8, 0x20, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xFB, 0xFE, 0x1F,
  0xFC, 0x7F, 0x8F, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0xE7, 0xE0, 0x3F, 0xC1,
  0xFF, 0x3F, 0x03, 0xFC, 0x07, 0xFD, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xE7, 0xFE, 0x07, 0xFF,
  0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x20,
  0x03, 0xF8, 0x00, 0x87, 0x80, 0x7F, 0x00, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x3F, 0xF9, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0x83, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xE1, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0xF0, 0x00,
  0x78, 0x07, 0xFC, 0x00, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xE0, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0xC0, 0xF0, 0x00,
  0x3F, 0xE0, 0x10, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF0, 0x1F, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0x81,
  0xE0, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC1, 0x80, 0x00, 0x3F, 0xE1, 0xC0, 0x00, 0x1F, 0xF1, 0xF0,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xF0, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xC3, 0xFF, 0xE0, 0x0F, 0xE3, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x03,
  0xFB, 0xFF, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x00,
  0x3F, 0xE3, 0xE0, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF1, 0xFF,
  0xE0, 0x0F, 0xF1, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0x07, 0xF9, 0xFF,
  0xFF, 0xC3, 0xFD, 0xFF, 0xFF, 0xF1, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0,
  0x1F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x7F, 0x9F,
  0xC0, 0x01, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F,
  0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x1F,
  0xFD, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xFE,
  0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0x83, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFE,
  0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xE3, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC,
  0x0F, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xC7, 0xC0, 0x01, 0xFF, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x7C,
  0x3F, 0x7E, 0x01, 0xFF, 0x3F, 0x7E, 0x03, 0xFF, 0xBF, 0x7E, 0x07, 0xFF,
  0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0xE0,
  0x7F, 0xFE, 0x0F, 0xF9, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x7E, 0x03, 0xFF,
  0xBF, 0x7E, 0x03, 0xFF, 0xBF, 0x7F, 0x01, 0xFF, 0x3F, 0x3F, 0x00, 0x38,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F,
  0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF,
  0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF1,
  0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x03, 0xC1, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x0F, 0xF0, 0x00,
  0x1F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xF8, 0xFF, 0x00,
  0x1F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xCF, 0xF0,
  0x01, 0xFF, 0x9F, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x01, 0x00, 0x07, 0xFC, 0x7C, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xDF, 0xC3, 0xF7, 0xFF, 0xEF, 0xE3, 0xFB,
  0xFF, 0xF3, 0xF9, 0xF9, 0xFF, 0xF9, 0xFC, 0xFC, 0xFF, 0xFC, 0xFE, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xC1, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0x07,
  0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7C, 0x0F, 0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0xF8, 0x0E, 0x03, 0xFF, 0xFC,
  0x07, 0x01, 0xFF, 0xFE, 0x01, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x7F, 0xFF,
  0x80, 0x40, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF,
  0xBF, 0xC0, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFC,
  0xFF, 0x07, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0x07,
  0xF1, 0xFF, 0xFE, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xE7, 0xFF, 0xF8, 0x1F,
  0xCF, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xC0, 0x7F,
  0x7F, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC0, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFE, 0x0F, 0xFC, 0x00,
  0x0F, 0x03, 0xFE, 0x00, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x20, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x40, 0x00, 0x07, 0xFC,
  0x38, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x9F,
  0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x7F, 0x81, 0xFC, 0xFE, 0x07, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xE0, 0x7F,
  0x3F, 0x81, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0xE0, 0xFE, 0x7F, 0x03, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xF8, 0x3F, 0x9F,
  0xE1, 0xFF, 0xC1, 0xFC, 0xFF, 0x0F, 0xBE, 0x0F, 0xE3, 0xF8, 0x7D, 0xF0,
  0x7E, 0x1F, 0xC3, 0xEF, 0xC3, 0xF0, 0xFE, 0x1F, 0x7E, 0x3F, 0x87, 0xF1,
  0xFB, 0xF1, 0xFC, 0x3F, 0x8F, 0x8F, 0x8F, 0xE1, 0xFC, 0x7C, 0x7C, 0x7F,
  0x0F, 0xE3, 0xE3, 0xE3, 0xF8, 0x7F, 0x1F, 0x1F, 0x9F, 0xC3, 0xF9, 0xF8,
  0xFC, 0xFE, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0, 0xFE, 0x7C, 0x1F, 0x3F, 0x87,
  0xF3, 0xE0, 0xF9, 0xFC, 0x3F, 0x9F, 0x07, 0xCF, 0xE1, 0xFC, 0xF8, 0x3F,
  0x7F, 0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x81, 0xFF,
  0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x1C, 0x01, 0xF8, 0x1F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x07,
  0xFC, 0x03, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF,
  0xF0, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC,
  0x7F, 0xC0, 0x07, 0xE1, 0xFF, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x08, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x40, 0x7F, 0xC0,
  0x00, 0xE0, 0x7F, 0xC0, 0x03, 0xF0, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFD,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x40, 0xFF, 0x80,
  0x01, 0xC1, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFB, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x03,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0xE0, 0xFF, 0x1F, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0x3F, 0xCF, 0xFF, 0xF9,
  0xFE, 0xFF, 0xFF, 0xEF, 0xF7, 0xFF, 0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8,
  0x3F, 0xC0, 0x07, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x7C, 0x1F,
  0xC7, 0xF8, 0x3F, 0xE3, 0xF8, 0xFF, 0x87, 0xFE, 0x7F, 0x3F, 0xF1, 0xFF,
  0xCF, 0xE7, 0xFE, 0x7F, 0xFD, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFC, 0x3F, 0xF1, 0xFE, 0xFF, 0x07, 0xF8, 0x1F, 0xDF, 0xC0,
  0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFC,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xC7, 0xFF, 0xF1, 0xFE,
  0x3F, 0xFF, 0xCF, 0xF3, 0xFF, 0xFE, 0x7F, 0xBF, 0xFF, 0xFB, 0xFD, 0xFF,
  0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03,
  0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF,
  0xF0, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFD,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x80, 0x7F, 0xDE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0x80, 0x00, 0x81,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x03, 0xFC, 0x38, 0x00,
  0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xBF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0x9F,
  0xE7, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xC7, 0xF8, 0x3F, 0xF8, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xBF, 0x01, 0xFF, 0x01, 0xF9,
  0xFC, 0x0F, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0xE0, 0x7E, 0x7F, 0x07, 0xFF,
  0x03, 0xF3, 0xF8, 0x3E, 0xF8, 0x3F, 0x9F, 0xC1, 0xF7, 0xC1, 0xFC, 0xFE,
  0x0F, 0xBE, 0x0F, 0xE7, 0xF0, 0x7D, 0xF0, 0x7F, 0x1F, 0x83, 0xE7, 0xC3,
  0xF0, 0xFC, 0x3E, 0x3E, 0x1F, 0x87, 0xE1, 0xF1, 0xF0, 0xFC, 0x3F, 0x8F,
  0x8F, 0x87, 0xE1, 0xFC, 0x7C, 0x7C, 0x3F, 0x0F, 0xE3, 0xE3, 0xE1, 0xF8,
  0x7F, 0x1F, 0x1F, 0x9F, 0xC3, 0xF8, 0xF0, 0x7C, 0xFE, 0x0F, 0xCF, 0x83,
  0xE7, 0xE0, 0x7E, 0x7C, 0x1F, 0x3F, 0x03, 0xF3, 0xE0, 0xF9, 0xF8, 0x1F,
  0x9F, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x3F, 0x7E, 0x07, 0xF7, 0x80, 0xFB,
  0xF0, 0x3F, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x1C,
  0x03, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xF0, 0x03,
  0xF1, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xC0,
  0xFC, 0xFF, 0x3F, 0xF0, 0xFE, 0x7F, 0x0F, 0xFC, 0xFF, 0x3F, 0x03, 0xFF,
  0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0x8F, 0xC0, 0x0F,
  0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0xC0, 0x38, 0x00,
  0x1F, 0x80,
};

const GFXglyph IBMPlexMono_SemiBold65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 11, 46, 39, 14, -45 },
  { 65, 21, 20, 39, 9, -48 },
  { 118, 37, 45, 39, 1, -45 },
  { 327, 35, 61, 39, 2, -53 },
  { 594, 39, 47, 39, 0, -46 },
  { 824, 37, 47, 39, 1, -46 },
  { 1042, 7, 20, 39, 16, -48 },
  { 1060, 22, 58, 39, 12, -49 },
  { 1220, 22, 58, 39, 5, -49 },
  { 1380, 35, 33, 39, 2, -36 },
  { 1525, 31, 31, 39, 4, -35 },
  { 1646, 15, 21, 39, 12, -11 },
  { 1686, 21, 8, 39, 9, -24 },
  { 1707, 13, 12, 39, 13, -11 },
  { 1727, 29, 58, 39, 5, -49 },
  { 1938, 35, 47, 39, 2, -46 },
  { 2144, 34, 45, 39, 3, -45 },
  { 2336, 33, 46, 39, 3, -46 },
  { 2526, 33, 47, 39, 2, -46 },
  { 2720, 35, 45, 39, 2, -45 },
  { 2917, 33, 46, 39, 3, -45 },
  { 3107, 33, 46, 39, 3, -45 },
  { 3297, 31, 45, 39, 4, -45 },
  { 3472, 33, 47, 39, 3, -46 },
  { 3666, 33, 46, 39, 3, -46 },
  { 3856, 13, 35, 39, 13, -34 },
  { 3913, 15, 44, 39, 12, -34 },
  { 3996, 27, 38, 39, 6, -39 },
  { 4125, 31, 22, 39, 4, -31 },
  { 4211, 27, 38, 39, 6, -39 },
  { 4340, 30, 47, 39, 4, -46 },
  { 4517, 32, 53, 39, 3, -46 },
  { 4729, 37, 45, 39, 1, -45 },
  { 4938, 31, 45, 39, 5, -45 },
  { 5113, 33, 47, 39, 3, -46 },
  { 5307, 31, 45, 39, 5, -45 },
  { 5482, 29, 45, 39, 5, -45 },
  { 5646, 30, 45, 39, 5, -45 },
  { 5815, 32, 47, 39, 3, -46 },
  { 6003, 31, 45, 39, 4, -45 },
  { 6178, 29, 45, 39, 5, -45 },
  { 6342, 30, 46, 39, 3, -45 },
  { 6515, 34, 45, 39, 5, -45 },
  { 6707, 29, 45, 39, 6, -45 },
  { 6871, 33, 45, 39, 3, -45 },
  { 7057, 31, 45, 39, 4, -45 },
  { 7232, 35, 47, 39, 2, -46 },
  { 7438, 31, 45, 39, 5, -45 },
  { 7613, 35, 58, 39, 2, -46 },
  { 7867, 32, 45, 39, 5, -45 },
  { 8047, 34, 47, 39, 2, -46 },
  { 8247, 35, 45, 39, 2, -45 },
  { 8444, 31, 46, 39, 4, -45 },
  { 8623, 37, 45, 39, 1, -45 },
  { 8832, 37, 45, 39, 1, -45 },
  { 9041, 37, 45, 39, 1, -45 },
  { 9250, 37, 45, 39, 1, -45 },
  { 9459, 33, 45, 39, 3, -45 },
  { 9645, 20, 58, 39, 13, -49 },
  { 9790, 29, 58, 39, 5, -49 },
  { 10001, 20, 58, 39, 6, -49 },
  { 10146, 35, 29, 39, 2, -45 },
  { 10273, 31, 7, 39, 4, 5 },
  { 10301, 14, 15, 39, 10, -52 },
  { 10328, 33, 35, 39, 4, -34 },
  { 10473, 32, 49, 39, 4, -48 },
  { 10669, 31, 35, 39, 4, -34 },
  { 10805, 32, 49, 39, 3, -48 },
  { 11001, 31, 35, 39, 4, -34 },
  { 11137, 32, 48, 39, 4, -48 },
  { 11329, 34, 54, 39, 3, -40 },
  { 11559, 29, 48, 39, 5, -48 },
  { 11733, 30, 49, 39, 6, -49 },
  { 11917, 24, 62, 39, 6, -49 },
  { 12103, 33, 48, 39, 5, -48 },
  { 12301, 29, 48, 39, 5, -48 },
  { 12475, 35, 34, 39, 2, -34 },
  { 12624, 29, 34, 39, 5, -34 },
  { 12748, 33, 35, 39, 3, -34 },
  { 12893, 32, 47, 39, 4, -34 },
  { 13081, 32, 47, 39, 3, -34 },
  { 13269, 31, 34, 39, 5, -34 },
  { 13401, 31, 35, 39, 4, -34 },
  { 13537, 31, 45, 39, 3, -45 },
  { 13712, 29, 35, 39, 5, -34 },
  { 13839, 35, 34, 39, 2, -34 },
  { 13988, 37, 34, 39, 1, -34 },
  { 14146, 35, 34, 39, 2, -34 },
  { 14295, 35, 47, 39, 2, -34 },
  { 14501, 29, 34, 39, 5, -34 },
  { 14625, 27, 58, 39, 6, -49 },
  { 14821, 7, 58, 39, 16, -49 },
  { 14872, 27, 58, 39, 6, -49 },
  { 15068, 33, 16, 39, 3, -28 },
};

const GFXfont IBMPlexMono_SemiBold65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_SEMIBOLD65PT7B_H_
