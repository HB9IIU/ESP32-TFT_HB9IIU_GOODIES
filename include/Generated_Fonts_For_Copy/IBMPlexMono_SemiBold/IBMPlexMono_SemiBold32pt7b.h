#ifndef _IBMPLEXMONO_SEMIBOLD32PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xE7, 0x9C, 0x71, 0xC7, 0x0C, 0x20, 0x00,
  0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x0F, 0xE3,
  0xF9, 0xFC, 0x7F, 0x3F, 0x9F, 0xE0, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC1, 0xFE, 0x3F, 0xBF, 0xCF, 0xF7, 0xF1, 0xFE, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF, 0xE1,
  0xFF, 0xF9, 0xF3, 0x3E, 0xF1, 0x8C, 0x78, 0xC0, 0x3C, 0x60, 0x1E, 0x30,
  0x0F, 0xD8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0xCF, 0x80, 0x63, 0xC0, 0x31, 0xE4, 0x18, 0xF3, 0x0C, 0x7B, 0xE6, 0x7B,
  0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1F, 0x01, 0xE7, 0xF0, 0x39, 0xFF, 0x07, 0x38, 0xE1, 0xCF, 0x1C,
  0x39, 0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x70, 0x7F, 0xCE, 0x07, 0xF3,
  0x80, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x73, 0xFC, 0x1E, 0x7F, 0x83, 0x9C,
  0x78, 0xF3, 0x87, 0x1C, 0x70, 0xE7, 0x8E, 0x1C, 0xE1, 0xC7, 0xBC, 0x1F,
  0xE7, 0x03, 0xFD, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0xF1, 0xE0, 0x78, 0x30, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0xF9, 0xFE, 0x3E, 0x7B, 0xCF, 0xBC,
  0xFB, 0x8F, 0x1E, 0xE3, 0x83, 0xF0, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x87,
  0xE1, 0xFF, 0x3C, 0x7F, 0xCF, 0x87, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C,
  0x13, 0xCE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x01, 0xEF, 0x01, 0xF3, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0x10, 0x10,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x7E, 0xF9, 0xF3, 0xE7, 0x8F, 0x3C, 0x78,
  0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xEF, 0xFF, 0xFB, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x83,
  0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0xE3, 0xFC, 0x79, 0xFE, 0x3C, 0xFF, 0x1C, 0x7F, 0x80, 0x3F, 0xC0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x87, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x03,
  0xEF, 0x03, 0xE7, 0x83, 0xE3, 0xC0, 0xE1, 0xE0, 0x30, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x87, 0xC7, 0x81,
  0xF5, 0x80, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0x30, 0x1F, 0x10,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x07, 0xFC, 0x07, 0xF0, 0x07,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x20, 0x0F, 0x70,
  0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x1E, 0xF0,
  0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x87, 0x83,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x71, 0xF0, 0x77, 0xFC, 0x7F, 0xFE, 0xF8, 0x3E, 0x10, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x20, 0x1F, 0x70, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0xF8, 0x3D,
  0xFF, 0x1F, 0xFF, 0xCF, 0xC3, 0xEF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0x8F, 0x07, 0xC7, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x3C, 0x1E, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xC7, 0xC1,
  0xF3, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0xDF,
  0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0x83, 0xC7, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x07, 0xE7, 0xFF, 0xE1, 0xFE, 0xF0,
  0x7E, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7B, 0xEF, 0xFF, 0xFB, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0xFE, 0xF8, 0x3C, 0xF9, 0xFB, 0xF7,
  0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF, 0x9F, 0x3E, 0x78, 0xF3,
  0xC7, 0x8F, 0x1C, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x3E,
  0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0x80, 0xF0, 0x06, 0x00, 0x20,
  0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC3, 0xEF, 0x03, 0xE6, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3C, 0x1E, 0x38, 0x07, 0x78, 0x07, 0x70, 0xF7, 0x71, 0xFF, 0x71,
  0xFF, 0x73, 0xC7, 0xF3, 0x87, 0xF3, 0x87, 0xF3, 0x87, 0xF3, 0x87, 0xF3,
  0x87, 0x73, 0xC7, 0x73, 0xFF, 0x71, 0xFF, 0x70, 0xF7, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3C, 0x07, 0x87, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x01, 0xE7, 0x80,
  0x3D, 0xF0, 0x07, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF,
  0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xFF, 0xE3, 0xFF,
  0x87, 0xFF, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7B, 0xC1, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x08,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x10, 0xF8, 0x0F, 0x78, 0x1E, 0x7C, 0x3E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x08, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x1F, 0x3F, 0xFF,
  0x1F, 0xEF, 0x07, 0xCF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE,
  0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0x87, 0xC7, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0,
  0xFB, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF,
  0x83, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x7C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xEE, 0xFF, 0xEE,
  0xEF, 0xEF, 0xEF, 0xE7, 0xCF, 0xE7, 0xCF, 0xE3, 0xCF, 0xE3, 0x8F, 0xE3,
  0x8F, 0xE1, 0x8F, 0xE1, 0x0F, 0xE1, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xF7, 0x1F, 0xEF, 0x3F,
  0xCE, 0x7F, 0x9E, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xC0, 0x07,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xC7, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0x3E,
  0x07, 0x8F, 0x87, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC3,
  0xC7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E,
  0xF0, 0x1F, 0x78, 0x0F, 0x3E, 0x07, 0x8F, 0x87, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFB, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFE, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF8, 0xF0, 0xF1,
  0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xC0, 0x07, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0x63, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x20, 0x0F, 0xB8, 0x07,
  0xBF, 0x07, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xF0, 0xF3, 0xFF, 0xE3, 0xFF, 0x81,
  0xFC, 0x00, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E, 0x78,
  0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x87,
  0x83, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xC0,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x78, 0xEF, 0x3E, 0x3B, 0xCF, 0x8E, 0xF3, 0xE3,
  0xBC, 0xF8, 0xEF, 0x37, 0x3B, 0xCD, 0xDE, 0xF7, 0x77, 0x9D, 0xDD, 0xE7,
  0x73, 0x79, 0xDC, 0xDE, 0x76, 0x3F, 0x9D, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0xC0, 0x7C, 0x03, 0xC7, 0x80, 0xF8, 0xF8,
  0x1E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x1F, 0x3C, 0x01, 0xEF, 0x80, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x79, 0xF0, 0x0F, 0x1F, 0x03, 0xC1,
  0xE0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0xC0, 0x7D, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xEF, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x03, 0xC1, 0xE0, 0xF8, 0x3E,
  0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0xF7, 0x80, 0x79, 0xE0, 0x78, 0xF0, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x07,
  0x9E, 0x03, 0xCF, 0x00, 0xFF, 0x00, 0x79, 0x80, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x31, 0xE1, 0xE1, 0xC3, 0xC3, 0x82, 0x80, 0x0F, 0xC0,
  0x3F, 0xF0, 0x7F, 0xF8, 0xF8, 0x7C, 0x20, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF8, 0x7C, 0xFF, 0xFF, 0x7F, 0x9F, 0x1F, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0,
  0xF3, 0xF8, 0xF7, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E,
  0xFC, 0x3E, 0xF7, 0xFC, 0xF3, 0xF8, 0xF1, 0xF0, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0x8F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x81, 0xCF, 0x87, 0xCF, 0xFF,
  0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x1F, 0xCF, 0x3F, 0xEF,
  0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xEF,
  0x1F, 0xCF, 0x0F, 0x8F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xEF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x8F, 0x83, 0x8F, 0xFF, 0x8F, 0xFC, 0x07, 0xF0,
  0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x1F, 0x00, 0x3F, 0x0F, 0xFF, 0x3F, 0xF0, 0x7F, 0xF8, 0x78, 0x3C,
  0x78, 0x3C, 0xF0, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xE0, 0x30, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x30, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFE,
  0x1F, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0xF8, 0xFB, 0xF9, 0xFF, 0xFB, 0xF0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0,
  0x3E, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0xBE,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFD, 0xE0, 0x7C, 0xF8, 0x3E,
  0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x8E, 0x7F,
  0xCF, 0xBF, 0xFF, 0xFE, 0x7C, 0xFF, 0x1C, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F,
  0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFE, 0x38, 0x7F, 0x1C,
  0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0x80, 0xF9, 0xF1,
  0xF7, 0xF3, 0xFF, 0xF7, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3C, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x7C, 0x3C, 0x7F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0xF1, 0xF0, 0xF3, 0xF8, 0xF7, 0xFC, 0xFC, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x1E, 0xFC, 0x3E, 0xF7, 0xFC, 0xF3, 0xF8,
  0xF1, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x8F, 0x1F, 0xCF, 0x3F, 0xEF, 0x7C, 0x1F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xEF, 0x1F, 0xCF, 0x0F, 0x8F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0xBF, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xFB, 0xE1, 0xE7, 0x80, 0x8F, 0x00, 0x1E, 0x00, 0x3F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0xF6, 0x01, 0xFF, 0x07,
  0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x83, 0xEF, 0x8F, 0xDF, 0xF7, 0x9F, 0xEF, 0x1F, 0x1E, 0xF8, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x07, 0x1E, 0x03, 0xCE, 0x01, 0xEF, 0x00,
  0x77, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0,
  0xF1, 0xEE, 0x1E, 0x3D, 0xC7, 0xC7, 0x38, 0xF8, 0xE7, 0x1B, 0x1C, 0xE3,
  0x63, 0x9E, 0x6E, 0x73, 0xCD, 0xCE, 0x3B, 0xB9, 0xC7, 0x73, 0x78, 0xEE,
  0x6E, 0x1D, 0x8D, 0xC3, 0xB1, 0xF8, 0x76, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x0F, 0xBE, 0x0F, 0x8F, 0x87, 0x83, 0xC7,
  0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x01, 0xE7, 0xC0, 0xF1, 0xF0, 0xF0, 0x78,
  0xF0, 0x3E, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF,
  0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x07, 0x9C, 0x03, 0xDE, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x8F, 0xF8, 0x7E,
  0x03, 0xFE, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0x80, 0xFC, 0x3F, 0xE1,
  0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0x0E, 0x03, 0x1F,
  0xC1, 0xCF, 0xE1, 0xEE, 0x78, 0xE7, 0x1E, 0x73, 0x87, 0xFB, 0xC1, 0xF8,
  0xC0, 0x78,
};

const GFXglyph IBMPlexMono_SemiBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 22, 19, 7, -22 },
  { 18, 11, 10, 19, 4, -24 },
  { 32, 19, 22, 19, 0, -22 },
  { 85, 17, 28, 19, 1, -25 },
  { 145, 19, 22, 19, 0, -22 },
  { 198, 18, 22, 19, 1, -22 },
  { 248, 3, 10, 19, 8, -24 },
  { 252, 11, 28, 19, 6, -24 },
  { 291, 10, 28, 19, 3, -24 },
  { 326, 17, 16, 19, 1, -18 },
  { 360, 15, 15, 19, 2, -17 },
  { 389, 7, 10, 19, 6, -5 },
  { 398, 10, 3, 19, 5, -11 },
  { 402, 6, 6, 19, 7, -6 },
  { 407, 15, 28, 19, 2, -24 },
  { 460, 17, 22, 19, 1, -22 },
  { 507, 17, 22, 19, 1, -22 },
  { 554, 17, 22, 19, 1, -22 },
  { 601, 16, 22, 19, 1, -22 },
  { 645, 17, 22, 19, 1, -22 },
  { 692, 16, 22, 19, 2, -22 },
  { 736, 17, 22, 19, 1, -22 },
  { 783, 15, 22, 19, 2, -22 },
  { 825, 17, 22, 19, 1, -22 },
  { 872, 17, 22, 19, 1, -22 },
  { 919, 6, 17, 19, 7, -17 },
  { 932, 7, 22, 19, 6, -17 },
  { 952, 13, 19, 19, 3, -19 },
  { 983, 15, 10, 19, 2, -15 },
  { 1002, 13, 19, 19, 3, -19 },
  { 1033, 15, 22, 19, 2, -22 },
  { 1075, 16, 26, 19, 1, -22 },
  { 1127, 19, 22, 19, 0, -22 },
  { 1180, 15, 22, 19, 3, -22 },
  { 1222, 16, 22, 19, 2, -22 },
  { 1266, 16, 22, 19, 2, -22 },
  { 1310, 14, 22, 19, 3, -22 },
  { 1349, 14, 22, 19, 3, -22 },
  { 1388, 16, 22, 19, 1, -22 },
  { 1432, 15, 22, 19, 2, -22 },
  { 1474, 15, 22, 19, 2, -22 },
  { 1516, 14, 22, 19, 2, -22 },
  { 1555, 17, 22, 19, 2, -22 },
  { 1602, 14, 22, 19, 3, -22 },
  { 1641, 16, 22, 19, 2, -22 },
  { 1685, 15, 22, 19, 2, -22 },
  { 1727, 17, 22, 19, 1, -22 },
  { 1774, 15, 22, 19, 3, -22 },
  { 1816, 17, 28, 19, 1, -22 },
  { 1876, 15, 22, 19, 3, -22 },
  { 1918, 17, 22, 19, 1, -22 },
  { 1965, 17, 22, 19, 1, -22 },
  { 2012, 15, 22, 19, 2, -22 },
  { 2054, 18, 22, 19, 1, -22 },
  { 2104, 18, 22, 19, 1, -22 },
  { 2154, 19, 22, 19, 0, -22 },
  { 2207, 19, 22, 19, 0, -22 },
  { 2260, 16, 22, 19, 2, -22 },
  { 2304, 10, 28, 19, 6, -24 },
  { 2339, 15, 28, 19, 2, -24 },
  { 2392, 10, 28, 19, 3, -24 },
  { 2427, 17, 14, 19, 1, -22 },
  { 2457, 15, 3, 19, 2, 3 },
  { 2463, 7, 7, 19, 5, -25 },
  { 2470, 16, 17, 19, 2, -17 },
  { 2504, 16, 24, 19, 2, -24 },
  { 2552, 15, 17, 19, 2, -17 },
  { 2584, 16, 24, 19, 1, -24 },
  { 2632, 15, 17, 19, 2, -17 },
  { 2664, 16, 24, 19, 2, -24 },
  { 2712, 16, 25, 19, 2, -19 },
  { 2762, 15, 24, 19, 2, -24 },
  { 2807, 15, 25, 19, 3, -25 },
  { 2854, 12, 31, 19, 3, -25 },
  { 2901, 17, 24, 19, 2, -24 },
  { 2952, 15, 24, 19, 2, -24 },
  { 2997, 17, 17, 19, 1, -17 },
  { 3034, 15, 17, 19, 2, -17 },
  { 3066, 16, 17, 19, 2, -17 },
  { 3100, 16, 23, 19, 2, -17 },
  { 3146, 16, 23, 19, 1, -17 },
  { 3192, 16, 17, 19, 2, -17 },
  { 3226, 15, 17, 19, 2, -17 },
  { 3258, 16, 22, 19, 1, -22 },
  { 3302, 15, 17, 19, 2, -17 },
  { 3334, 17, 17, 19, 1, -17 },
  { 3371, 19, 17, 19, 0, -17 },
  { 3412, 17, 17, 19, 1, -17 },
  { 3449, 17, 23, 19, 1, -17 },
  { 3498, 15, 17, 19, 2, -17 },
  { 3530, 13, 28, 19, 3, -24 },
  { 3576, 3, 28, 19, 8, -24 },
  { 3587, 13, 28, 19, 3, -24 },
  { 3633, 17, 8, 19, 1, -14 },
};

const GFXfont IBMPlexMono_SemiBold32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_SEMIBOLD32PT7B_H_
