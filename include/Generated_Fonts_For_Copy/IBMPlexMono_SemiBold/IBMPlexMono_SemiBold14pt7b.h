#ifndef _IBMPLEXMONO_SEMIBOLD14PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x53, 0xF0, 0xDD, 0xDD, 0x12, 0x16, 0x16, 0x77, 0x34, 0x34,
  0xE7, 0x2C, 0x2C, 0x68, 0x10, 0xFB, 0x5E, 0x8D, 0x0E, 0x07, 0x0B, 0x17,
  0x2F, 0xE0, 0x80, 0x71, 0xD2, 0x92, 0xD4, 0x70, 0x07, 0x39, 0x69, 0x49,
  0xC7, 0x3C, 0x64, 0x60, 0x60, 0x30, 0x53, 0xCA, 0xCE, 0xCE, 0x73, 0xFF,
  0x36, 0x4C, 0x88, 0x88, 0x8C, 0x46, 0x30, 0xC1, 0x0C, 0x21, 0x8C, 0x63,
  0x18, 0x8C, 0x4C, 0x00, 0x18, 0x18, 0x7F, 0xFE, 0x1C, 0x36, 0x66, 0x30,
  0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0xFB, 0x40, 0xF0, 0xDF, 0x00, 0x04,
  0x30, 0x86, 0x18, 0x43, 0x0C, 0x21, 0x86, 0x10, 0xC0, 0x3C, 0x66, 0x63,
  0x43, 0x5B, 0xDB, 0x43, 0x63, 0x66, 0x3C, 0x38, 0xB3, 0x64, 0xC1, 0x83,
  0x06, 0x0C, 0x19, 0xFC, 0x79, 0x98, 0x30, 0x60, 0xC3, 0x0C, 0x30, 0xC1,
  0xFC, 0x3C, 0x66, 0x02, 0x06, 0x1C, 0x06, 0x03, 0x03, 0x46, 0xFC, 0x0E,
  0x1E, 0x16, 0x36, 0x26, 0x66, 0xC6, 0xFF, 0x06, 0x06, 0xFD, 0x83, 0x06,
  0x0F, 0xD9, 0x81, 0x83, 0xCC, 0xF0, 0x1C, 0xE1, 0x86, 0x0F, 0xD9, 0xF1,
  0xE3, 0xCC, 0xF0, 0xFF, 0x0E, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0xC0,
  0x79, 0x8B, 0x1E, 0x67, 0x99, 0xB1, 0xE3, 0xCC, 0xF0, 0x79, 0x9A, 0x1C,
  0x3C, 0xEE, 0xC3, 0x06, 0x18, 0xE0, 0xDF, 0x01, 0xBE, 0xDF, 0x00, 0x3E,
  0xD0, 0x04, 0x77, 0xB8, 0xE1, 0xE1, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x83,
  0x83, 0x83, 0x0C, 0xEE, 0x20, 0x7B, 0x30, 0xC3, 0x38, 0xC0, 0x0C, 0x30,
  0xC0, 0x79, 0x8A, 0x1C, 0xFB, 0x74, 0xE9, 0xDB, 0x9F, 0x01, 0x01, 0xC0,
  0x1C, 0x1C, 0x3C, 0x34, 0x26, 0x66, 0x7E, 0x63, 0x43, 0xC3, 0xF9, 0x9B,
  0x16, 0x6F, 0x98, 0xB1, 0xE3, 0xC5, 0xF8, 0x7D, 0x8F, 0x26, 0x0C, 0x18,
  0x30, 0x64, 0xC6, 0xF8, 0xF9, 0x9B, 0x16, 0x3C, 0x78, 0xF1, 0xE2, 0xCD,
  0xF0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0x83, 0x06,
  0x0F, 0xD8, 0x30, 0x60, 0xC1, 0x80, 0x79, 0x9B, 0x2E, 0x0C, 0x1B, 0xF1,
  0xE3, 0xCE, 0xEC, 0xC7, 0x1C, 0x71, 0xFF, 0x1C, 0x71, 0xC7, 0x10, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x7C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xCD, 0xE0, 0xC7, 0x9B, 0x66, 0xCF, 0x1F, 0x36, 0x66, 0xCF, 0x8C,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFC, 0xC7, 0x9F, 0xBD,
  0x7B, 0x76, 0xE5, 0xD3, 0x87, 0x0C, 0xC7, 0x9E, 0x79, 0xF7, 0x5D, 0x77,
  0xCF, 0x30, 0x3C, 0x66, 0x63, 0x43, 0x43, 0xC3, 0x43, 0x63, 0x66, 0x3C,
  0xFD, 0x8B, 0x1E, 0x3C, 0x5F, 0xB0, 0x60, 0xC1, 0x80, 0x3C, 0x66, 0x63,
  0x43, 0x43, 0xC3, 0x43, 0x63, 0x66, 0x3C, 0x18, 0x0E, 0xFD, 0x8B, 0x1E,
  0x3C, 0x5F, 0xB6, 0x66, 0xCD, 0x8C, 0x3E, 0x63, 0x60, 0x60, 0x38, 0x0E,
  0x03, 0x03, 0x46, 0xFC, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE2, 0xCC, 0xF0, 0xC3,
  0x63, 0x62, 0x66, 0x66, 0x36, 0x34, 0x3C, 0x1C, 0x1C, 0xC1, 0xC1, 0xDB,
  0xDB, 0x5B, 0x5F, 0x57, 0x77, 0x67, 0x67, 0xE3, 0x66, 0x36, 0x3C, 0x1C,
  0x1C, 0x3C, 0x26, 0x66, 0xC3, 0xC3, 0x62, 0x66, 0x34, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFE, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0xFC,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC1, 0x06, 0x18, 0x20, 0xC3,
  0x04, 0x18, 0x60, 0x83, 0x04, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0x80, 0x18, 0x3C, 0x34, 0x66, 0x62, 0xC3, 0xFE, 0xCC, 0x80, 0x79,
  0x18, 0x33, 0xEC, 0xD9, 0xBD, 0x80, 0xC1, 0x83, 0x06, 0xEE, 0xD8, 0xF1,
  0xE3, 0xCD, 0xF8, 0x7F, 0x1C, 0x30, 0xC3, 0x17, 0xC0, 0x04, 0x10, 0x5D,
  0xCF, 0x1C, 0x71, 0xCD, 0xD0, 0x79, 0x9B, 0x1F, 0xFC, 0x18, 0x9F, 0x00,
  0x1E, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x31, 0xF8, 0x06, 0xF3, 0x36,
  0x6C, 0xCF, 0x30, 0x7E, 0x87, 0x0F, 0xF0, 0xC3, 0x0C, 0x37, 0xEF, 0x1C,
  0x71, 0xC7, 0x10, 0x18, 0x70, 0x07, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFC,
  0x18, 0xC1, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x80, 0xC1, 0x83, 0x06,
  0x7D, 0x9E, 0x3E, 0x6C, 0xCD, 0x8C, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x33, 0xF0, 0xFD, 0x6E, 0xDD, 0xBB, 0x76, 0xED, 0x80, 0xDF, 0xBC, 0x71,
  0xC7, 0x1C, 0x40, 0x79, 0x9B, 0x1E, 0x3C, 0x79, 0x9E, 0x00, 0xDD, 0xDB,
  0x1E, 0x3C, 0x79, 0xBF, 0x60, 0xC1, 0x80, 0x77, 0x3C, 0x71, 0xC7, 0x37,
  0x41, 0x04, 0x10, 0xF6, 0x70, 0xC1, 0x83, 0x06, 0x3F, 0x00, 0x7F, 0x1C,
  0x1E, 0x0E, 0x17, 0xC0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0xF0,
  0xC7, 0x1C, 0x71, 0xC7, 0x37, 0x40, 0xC7, 0x8B, 0x33, 0x66, 0x87, 0x0C,
  0x00, 0xD9, 0xD9, 0x59, 0x57, 0x57, 0x56, 0x66, 0x63, 0x36, 0x3C, 0x18,
  0x3C, 0x26, 0xE3, 0xC3, 0x62, 0x66, 0x36, 0x34, 0x1C, 0x18, 0x18, 0x18,
  0x70, 0xFC, 0x31, 0x8C, 0x63, 0x0F, 0xC0, 0x3C, 0x83, 0x0C, 0x18, 0x6E,
  0x06, 0x18, 0xC3, 0x08, 0x3C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x41, 0x0C,
  0x20, 0x81, 0xC8, 0x20, 0xC1, 0x04, 0xF0, 0x67, 0x6E, 0x70,
};

const GFXglyph IBMPlexMono_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 12, 8, 1, -11 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 8, 10, 8, 0, -10 },
  { 47, 2, 4, 8, 3, -10 },
  { 48, 4, 13, 8, 3, -11 },
  { 55, 5, 13, 8, 1, -11 },
  { 64, 8, 7, 8, 0, -8 },
  { 71, 7, 7, 8, 1, -8 },
  { 78, 3, 4, 8, 3, -2 },
  { 80, 4, 1, 8, 2, -5 },
  { 81, 3, 3, 8, 3, -3 },
  { 83, 6, 13, 8, 1, -11 },
  { 93, 8, 10, 8, 0, -10 },
  { 103, 7, 10, 8, 1, -10 },
  { 112, 7, 10, 8, 1, -10 },
  { 121, 8, 10, 8, 0, -10 },
  { 131, 8, 10, 8, 0, -10 },
  { 141, 7, 10, 8, 1, -10 },
  { 150, 7, 10, 8, 1, -10 },
  { 159, 7, 10, 8, 1, -10 },
  { 168, 7, 10, 8, 1, -10 },
  { 177, 7, 10, 8, 1, -10 },
  { 186, 3, 8, 8, 3, -8 },
  { 189, 3, 10, 8, 3, -8 },
  { 193, 6, 8, 8, 1, -8 },
  { 199, 7, 4, 8, 1, -6 },
  { 203, 6, 8, 8, 1, -8 },
  { 209, 6, 10, 8, 1, -10 },
  { 217, 7, 12, 8, 1, -10 },
  { 228, 8, 10, 8, 0, -10 },
  { 238, 7, 10, 8, 1, -10 },
  { 247, 7, 10, 8, 1, -10 },
  { 256, 7, 10, 8, 1, -10 },
  { 265, 6, 10, 8, 1, -10 },
  { 273, 7, 10, 8, 1, -10 },
  { 282, 7, 10, 8, 1, -10 },
  { 291, 6, 10, 8, 1, -10 },
  { 299, 6, 10, 8, 1, -10 },
  { 307, 6, 10, 8, 1, -10 },
  { 315, 7, 10, 8, 1, -10 },
  { 324, 7, 10, 8, 1, -10 },
  { 333, 7, 10, 8, 1, -10 },
  { 342, 6, 10, 8, 1, -10 },
  { 350, 8, 10, 8, 0, -10 },
  { 360, 7, 10, 8, 1, -10 },
  { 369, 8, 12, 8, 0, -10 },
  { 381, 7, 10, 8, 1, -10 },
  { 390, 8, 10, 8, 0, -10 },
  { 400, 8, 10, 8, 0, -10 },
  { 410, 7, 10, 8, 1, -10 },
  { 419, 8, 10, 8, 0, -10 },
  { 429, 8, 10, 8, 0, -10 },
  { 439, 8, 10, 8, 0, -10 },
  { 449, 8, 10, 8, 0, -10 },
  { 459, 7, 10, 8, 1, -10 },
  { 468, 4, 13, 8, 3, -11 },
  { 475, 6, 13, 8, 1, -11 },
  { 485, 5, 13, 8, 1, -11 },
  { 494, 8, 6, 8, 0, -10 },
  { 500, 7, 1, 8, 1, 1 },
  { 501, 3, 3, 8, 2, -11 },
  { 503, 7, 7, 8, 1, -7 },
  { 510, 7, 10, 8, 1, -10 },
  { 519, 6, 7, 8, 1, -7 },
  { 525, 6, 10, 8, 1, -10 },
  { 533, 7, 7, 8, 1, -7 },
  { 540, 7, 10, 8, 1, -10 },
  { 549, 7, 11, 8, 1, -8 },
  { 559, 6, 10, 8, 1, -10 },
  { 567, 7, 10, 8, 1, -10 },
  { 576, 5, 13, 8, 1, -10 },
  { 585, 7, 10, 8, 1, -10 },
  { 594, 6, 10, 8, 1, -10 },
  { 602, 7, 7, 8, 1, -7 },
  { 609, 6, 7, 8, 1, -7 },
  { 615, 7, 7, 8, 1, -7 },
  { 622, 7, 10, 8, 1, -7 },
  { 631, 6, 10, 8, 1, -7 },
  { 639, 7, 7, 8, 1, -7 },
  { 646, 6, 7, 8, 1, -7 },
  { 652, 6, 10, 8, 1, -10 },
  { 660, 6, 7, 8, 1, -7 },
  { 666, 7, 7, 8, 1, -7 },
  { 673, 8, 7, 8, 0, -7 },
  { 680, 8, 7, 8, 0, -7 },
  { 687, 8, 10, 8, 0, -7 },
  { 697, 6, 7, 8, 1, -7 },
  { 703, 6, 13, 8, 1, -11 },
  { 713, 2, 13, 8, 3, -11 },
  { 717, 6, 13, 8, 1, -11 },
  { 727, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_SEMIBOLD14PT7B_H_
