#ifndef _IBMPLEXMONO_SEMIBOLD22PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x64, 0x40, 0x0E, 0xFF, 0xE0, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0x80, 0x06, 0x60, 0x73, 0x03, 0xB8, 0x19, 0xC7, 0xCF,
  0xBE, 0x7C, 0x73, 0x03, 0x98, 0x19, 0xC7, 0xCF, 0xBE, 0x7C, 0x33, 0x03,
  0x98, 0x1D, 0xC0, 0xCE, 0x00, 0x06, 0x00, 0xC0, 0x7E, 0x3F, 0xF7, 0x6D,
  0xCD, 0x39, 0x83, 0xB0, 0x7E, 0x07, 0xF8, 0x1F, 0x83, 0x70, 0x66, 0x8C,
  0xF9, 0xBF, 0xFE, 0x3F, 0x80, 0xC0, 0x18, 0x00, 0x3C, 0x1B, 0xE1, 0xB9,
  0x9D, 0x8C, 0xCC, 0x6E, 0x73, 0x61, 0xF4, 0x07, 0x9C, 0x01, 0xF0, 0xF8,
  0xC6, 0xC6, 0x66, 0x33, 0x31, 0xB0, 0xFB, 0x83, 0x80, 0x0F, 0x01, 0xFC,
  0x0E, 0x70, 0x62, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x07, 0xCF, 0x7E, 0x7B,
  0x3B, 0x38, 0xF9, 0xC3, 0x87, 0x1E, 0x3F, 0xB8, 0xF8, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0E, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0E,
  0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0xC1,
  0x83, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x1C, 0x70, 0xC7,
  0x00, 0x0E, 0x01, 0xC0, 0x38, 0x67, 0x3F, 0xFE, 0xFF, 0x83, 0xC0, 0xF8,
  0x3B, 0x8E, 0x38, 0xC2, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF,
  0xFF, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x7B, 0x9C, 0xEE, 0x73, 0x00,
  0xFF, 0xFC, 0x77, 0xFE, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x00, 0x1F, 0x07, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1,
  0xFB, 0xBF, 0x77, 0xEE, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1C, 0x7F, 0x87,
  0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0x70, 0xE7, 0x04, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x07, 0xFF, 0x7F, 0xF0,
  0x1F, 0x0F, 0xFB, 0xC7, 0x70, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0x0F, 0xFB,
  0x87, 0x20, 0x70, 0x0E, 0x03, 0x87, 0xE0, 0xFC, 0x01, 0xC0, 0x1C, 0x03,
  0xA0, 0x7E, 0x1E, 0xFF, 0x8F, 0xC0, 0x03, 0x80, 0x78, 0x0F, 0x80, 0xD8,
  0x19, 0x83, 0x98, 0x31, 0x87, 0x18, 0xE1, 0x8C, 0x18, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x7F, 0xCF, 0xF9, 0x80, 0x30, 0x06, 0x00,
  0xCF, 0x1B, 0xF3, 0x8F, 0x00, 0xE0, 0x1C, 0x03, 0xB0, 0x7F, 0x1E, 0xFF,
  0x87, 0xC0, 0x07, 0xC1, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xEF, 0x3B, 0xF7,
  0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1E, 0x7F, 0x87, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x1F, 0x8F, 0xF9, 0xC7,
  0xF0, 0x7E, 0x0E, 0xE3, 0x8F, 0xE1, 0xFE, 0x71, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x1E, 0xFF, 0x87, 0xC0, 0x1F, 0x0F, 0xF9, 0xC7, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x8F, 0x7F, 0xE7, 0xD8, 0x07, 0x01, 0xC0, 0x70, 0x1E,
  0x0F, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x77, 0xFE, 0xE0, 0x77, 0xFE,
  0xE0, 0x00, 0x00, 0x7B, 0x9C, 0xEE, 0x73, 0x00, 0x00, 0x80, 0xC1, 0xE3,
  0xE7, 0xC7, 0x83, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x30, 0x08, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x70, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x06, 0x0F, 0x1F, 0x3E, 0x3C, 0x1C, 0x08, 0x00,
  0x1F, 0x1F, 0xF7, 0x1F, 0x87, 0x01, 0xC0, 0x70, 0xF8, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x1F, 0x07, 0xF9, 0xC3, 0x30,
  0x3E, 0x77, 0x9F, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0xE7, 0xFE,
  0x76, 0xC0, 0x1C, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0x63, 0x07, 0x1C, 0x38, 0xE1, 0xFF, 0x0F,
  0xFC, 0xE0, 0xE7, 0x07, 0x38, 0x3F, 0x80, 0xE0, 0xFF, 0x3F, 0xEE, 0x3B,
  0x87, 0xE1, 0xF8, 0xEF, 0xF3, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFF, 0xEF, 0xF0, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x7E, 0x09, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x82, 0x38, 0x77, 0x0E, 0x7F, 0x87, 0xE0,
  0xFE, 0x3F, 0xCC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC3, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0x07, 0xF9,
  0xC7, 0x30, 0x7E, 0x11, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x1F, 0x83,
  0xF0, 0x77, 0x1E, 0xFF, 0xC7, 0xB8, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x38, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x3F, 0xCF, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0xF1,
  0xDF, 0xE3, 0xF0, 0xC1, 0xF8, 0x7B, 0x0E, 0x63, 0x8C, 0xE1, 0x9C, 0x37,
  0x07, 0xF0, 0xFE, 0x1C, 0xE3, 0x9E, 0x61, 0xCC, 0x3D, 0x83, 0xB0, 0x38,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xF0, 0xFE, 0x3F, 0xE7, 0xFD,
  0xFD, 0xB7, 0xBE, 0xFB, 0x9F, 0x73, 0xE6, 0x7C, 0x8F, 0x91, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x18, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xD9,
  0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF, 0x9F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8,
  0x78, 0x1F, 0x07, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1C, 0x7F, 0x87, 0xC0, 0xFF, 0x3F,
  0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFE, 0xFF, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0x07, 0xF9, 0xC7, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1C, 0xFF,
  0x87, 0xC0, 0x70, 0x0E, 0x00, 0xF8, 0x1F, 0x00, 0xFF, 0x3F, 0xEE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFE, 0xFF, 0x39, 0xCE, 0x73, 0x8E, 0xE3,
  0xB8, 0x7E, 0x1C, 0x1F, 0x8F, 0xFD, 0xC3, 0x70, 0x4E, 0x00, 0xE0, 0x1F,
  0x81, 0xFE, 0x03, 0xE0, 0x1C, 0x03, 0xA0, 0x7E, 0x1F, 0xFF, 0x8F, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xB0, 0x77, 0x1C, 0xFF, 0x87, 0xE0, 0xF0, 0x3B, 0x83, 0x9C,
  0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xC0, 0xEE,
  0x07, 0x70, 0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x3F, 0x01,
  0xD8, 0x0E, 0xCE, 0x76, 0x73, 0x33, 0x99, 0x96, 0xCC, 0xB6, 0x6D, 0xB3,
  0x6D, 0x9B, 0x6C, 0xF9, 0x67, 0xCF, 0x3C, 0x79, 0xE3, 0xC0, 0x70, 0x7B,
  0xC3, 0x8E, 0x38, 0x39, 0xC1, 0xDC, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x0F,
  0x80, 0x6E, 0x07, 0x70, 0x71, 0xC3, 0x8E, 0x38, 0x3B, 0xC1, 0xE0, 0xF0,
  0x3B, 0x83, 0x9E, 0x1C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xF0,
  0x0F, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0xFF, 0xF0, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x0E, 0x01, 0xF0, 0x1F,
  0x03, 0xB8, 0x31, 0x87, 0x1C, 0x60, 0xCE, 0x0E, 0xC0, 0x64, 0x05, 0xFF,
  0xFF, 0xFC, 0x4E, 0xE7, 0x20, 0x1F, 0x0F, 0xF1, 0x87, 0x00, 0xE0, 0x1C,
  0x7F, 0x9F, 0xF7, 0x0E, 0xE1, 0xCF, 0xDC, 0xF3, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x33, 0xCD, 0xFB, 0x8F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0xFD, 0xFB, 0x3C, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x46, 0x01,
  0xC0, 0x18, 0x03, 0x84, 0x70, 0xE7, 0xF8, 0x7E, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x79, 0xDF, 0xBF, 0x8F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xE3, 0xDF, 0xB9, 0xE7, 0x1F, 0x07, 0xF9, 0xC7, 0x70,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0x02, 0x70, 0xC7, 0xFC, 0x7E, 0x00, 0x07,
  0xE1, 0xFC, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x1F, 0xFB, 0xFF, 0x00, 0xE0, 0x0E,
  0x1F, 0x87, 0xFC, 0x71, 0xC6, 0x0C, 0x71, 0xC7, 0xFC, 0x3F, 0x02, 0x00,
  0x60, 0x07, 0xFC, 0x3F, 0xEE, 0x07, 0xE0, 0x7F, 0xFE, 0x3F, 0xC0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xCD, 0xFB, 0x8E, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x0E, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x8F, 0xFF, 0xFF, 0x07, 0x0F, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFE, 0xFC, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xB8, 0xE7, 0x38, 0xEE, 0x1F,
  0x83, 0xF8, 0x77, 0x0E, 0x71, 0xC7, 0x38, 0xF7, 0x0F, 0xFC, 0x3F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0xDC, 0xFF, 0xBF, 0x39, 0xE7, 0x3C, 0xE7,
  0x9C, 0xF3, 0x9E, 0x73, 0xCE, 0x79, 0xCF, 0x39, 0x80, 0xCF, 0x37, 0xEE,
  0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1C, 0x1F,
  0x07, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x71, 0xC7,
  0xF8, 0x7C, 0x00, 0xCF, 0x37, 0xEE, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xE3, 0xF7, 0xEC, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3C, 0xEF,
  0xDF, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEF, 0xDC,
  0xF3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xF9, 0xFE, 0xF3, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x3F, 0xEF, 0xF8, 0x1F, 0x8F, 0xF9,
  0xC3, 0xB8, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0x60, 0xFF, 0xF8, 0xFC,
  0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x0F, 0xFF, 0xFF, 0xC7, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1F, 0xC3, 0xF8, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE3, 0xFF, 0x77, 0x9C,
  0xE0, 0xFC, 0x1D, 0xC3, 0x38, 0xE3, 0x1C, 0x73, 0x0E, 0xE0, 0xDC, 0x1F,
  0x03, 0xE0, 0x38, 0x00, 0xE7, 0x1B, 0x39, 0xD9, 0xCE, 0xCB, 0x66, 0x5B,
  0x36, 0xD9, 0xB6, 0xCD, 0xB6, 0x7C, 0xB1, 0xC7, 0x8E, 0x3C, 0xF0, 0xEE,
  0x38, 0xEE, 0x0F, 0xC1, 0xF0, 0x1C, 0x07, 0xC1, 0xDC, 0x3B, 0xCE, 0x3B,
  0x83, 0x80, 0xE0, 0x7E, 0x0E, 0x70, 0xC7, 0x1C, 0x31, 0xC3, 0x98, 0x3B,
  0x81, 0xB0, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x07, 0xC0, 0x78,
  0x00, 0xFF, 0xBF, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xE0, 0x38, 0x0C,
  0x0E, 0x7E, 0x3F, 0x01, 0xC0, 0x60, 0x70, 0x70, 0x30, 0x18, 0x0C, 0x07,
  0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x0F, 0xC7, 0xE7, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x3F, 0x1F, 0x80, 0x38, 0x6F, 0x8F,
  0xB9, 0xE3, 0xEC, 0x38,
};

const GFXglyph IBMPlexMono_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 5, -15 },
  { 9, 7, 7, 13, 3, -16 },
  { 16, 13, 15, 13, 0, -15 },
  { 41, 11, 19, 13, 1, -17 },
  { 68, 13, 15, 13, 0, -15 },
  { 93, 13, 15, 13, 0, -15 },
  { 118, 3, 7, 13, 5, -16 },
  { 121, 7, 20, 13, 4, -17 },
  { 139, 7, 20, 13, 2, -17 },
  { 157, 11, 11, 13, 1, -12 },
  { 173, 11, 10, 13, 1, -12 },
  { 187, 5, 7, 13, 4, -4 },
  { 192, 7, 2, 13, 3, -8 },
  { 194, 5, 4, 13, 4, -4 },
  { 197, 9, 20, 13, 2, -17 },
  { 220, 11, 15, 13, 1, -15 },
  { 241, 12, 15, 13, 1, -15 },
  { 264, 11, 15, 13, 1, -15 },
  { 285, 11, 15, 13, 1, -15 },
  { 306, 12, 15, 13, 1, -15 },
  { 329, 11, 15, 13, 1, -15 },
  { 350, 11, 15, 13, 1, -15 },
  { 371, 11, 15, 13, 1, -15 },
  { 392, 11, 15, 13, 1, -15 },
  { 413, 11, 15, 13, 1, -15 },
  { 434, 5, 12, 13, 4, -12 },
  { 442, 5, 15, 13, 4, -12 },
  { 452, 9, 13, 13, 2, -13 },
  { 467, 11, 7, 13, 1, -10 },
  { 477, 9, 13, 13, 2, -13 },
  { 492, 10, 15, 13, 1, -15 },
  { 511, 11, 17, 13, 1, -15 },
  { 535, 13, 15, 13, 0, -15 },
  { 560, 10, 15, 13, 2, -15 },
  { 579, 11, 15, 13, 1, -15 },
  { 600, 10, 15, 13, 2, -15 },
  { 619, 10, 15, 13, 2, -15 },
  { 638, 10, 15, 13, 2, -15 },
  { 657, 11, 15, 13, 1, -15 },
  { 678, 11, 15, 13, 1, -15 },
  { 699, 9, 15, 13, 2, -15 },
  { 716, 10, 15, 13, 1, -15 },
  { 735, 11, 15, 13, 2, -15 },
  { 756, 10, 15, 13, 2, -15 },
  { 775, 11, 15, 13, 1, -15 },
  { 796, 11, 15, 13, 1, -15 },
  { 817, 11, 15, 13, 1, -15 },
  { 838, 10, 15, 13, 2, -15 },
  { 857, 11, 19, 13, 1, -15 },
  { 884, 10, 15, 13, 2, -15 },
  { 903, 11, 15, 13, 1, -15 },
  { 924, 12, 15, 13, 1, -15 },
  { 947, 11, 15, 13, 1, -15 },
  { 968, 13, 15, 13, 0, -15 },
  { 993, 13, 15, 13, 0, -15 },
  { 1018, 13, 15, 13, 0, -15 },
  { 1043, 13, 15, 13, 0, -15 },
  { 1068, 11, 15, 13, 1, -15 },
  { 1089, 7, 20, 13, 4, -17 },
  { 1107, 9, 20, 13, 2, -17 },
  { 1130, 7, 20, 13, 2, -17 },
  { 1148, 12, 10, 13, 1, -15 },
  { 1163, 11, 2, 13, 1, 2 },
  { 1166, 4, 5, 13, 4, -18 },
  { 1169, 11, 11, 13, 1, -11 },
  { 1185, 10, 16, 13, 2, -16 },
  { 1205, 11, 11, 13, 1, -11 },
  { 1221, 11, 16, 13, 1, -16 },
  { 1243, 11, 11, 13, 1, -11 },
  { 1259, 11, 16, 13, 1, -16 },
  { 1281, 12, 17, 13, 1, -13 },
  { 1307, 10, 16, 13, 2, -16 },
  { 1327, 10, 16, 13, 2, -16 },
  { 1347, 8, 20, 13, 2, -16 },
  { 1367, 11, 16, 13, 2, -16 },
  { 1389, 10, 16, 13, 2, -16 },
  { 1409, 11, 11, 13, 1, -11 },
  { 1425, 10, 11, 13, 2, -11 },
  { 1439, 11, 11, 13, 1, -11 },
  { 1455, 10, 15, 13, 2, -11 },
  { 1474, 11, 15, 13, 1, -11 },
  { 1495, 10, 11, 13, 2, -11 },
  { 1509, 11, 11, 13, 1, -11 },
  { 1525, 11, 15, 13, 1, -15 },
  { 1546, 10, 11, 13, 2, -11 },
  { 1560, 11, 11, 13, 1, -11 },
  { 1576, 13, 11, 13, 0, -11 },
  { 1594, 11, 11, 13, 1, -11 },
  { 1610, 12, 15, 13, 1, -11 },
  { 1633, 10, 11, 13, 2, -11 },
  { 1647, 9, 20, 13, 2, -17 },
  { 1670, 3, 20, 13, 5, -17 },
  { 1678, 9, 20, 13, 2, -17 },
  { 1701, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_SEMIBOLD22PT7B_H_
