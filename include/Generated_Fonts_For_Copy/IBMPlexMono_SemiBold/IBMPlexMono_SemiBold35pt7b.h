#ifndef _IBMPLEXMONO_SEMIBOLD35PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x70, 0xE1, 0xC3,
  0x87, 0x04, 0x00, 0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xDF, 0x3E, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xC7,
  0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F,
  0xC7, 0xF9, 0xFC, 0x7F, 0xC0, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x03, 0xFE, 0x3F, 0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8,
  0xFF, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE,
  0x7E, 0xE7, 0x8F, 0x9C, 0x61, 0xE3, 0x80, 0x3E, 0x70, 0x07, 0xCE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xBF, 0x00, 0x71, 0xF0, 0x0E, 0x3E, 0x41, 0xC7, 0xCE, 0x38, 0xF3,
  0xE7, 0x3E, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x79,
  0xFE, 0x07, 0x9F, 0xF0, 0x38, 0xE3, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71,
  0xE3, 0xC3, 0x8E, 0x0E, 0x1C, 0xF0, 0x71, 0xE7, 0x03, 0xFE, 0x78, 0x0F,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x1E, 0x7F,
  0xC0, 0xE7, 0x8E, 0x0F, 0x38, 0x70, 0x71, 0xC3, 0xC7, 0x8E, 0x1E, 0x38,
  0x70, 0xE3, 0xC3, 0xC7, 0x1C, 0x0F, 0xF9, 0xE0, 0x7F, 0x9E, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x3E,
  0x03, 0xC1, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x7F, 0xC7, 0xE7, 0xFE, 0x7E, 0xF9,
  0xF7, 0x8F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x07, 0xF0, 0xF0, 0x3E, 0x0F,
  0x83, 0xF0, 0xFF, 0xFF, 0x87, 0xFE, 0x7C, 0x3F, 0xE3, 0xE1, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x08, 0x0E, 0x04, 0xE1, 0xC3, 0x9F, 0xBB, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0x7B, 0xC0, 0x1F, 0x7C, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x0C, 0x06, 0x00,
  0x80, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1E, 0xF8,
  0x03, 0xDF, 0x1C, 0x7F, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0x9F, 0x3F, 0xF1,
  0xC7, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x1F, 0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7,
  0x80, 0x7C, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xC0, 0x30, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xF9, 0xC0,
  0x3E, 0x20, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F,
  0x8E, 0x01, 0xF1, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xCC, 0x01, 0xF7, 0x80, 0x7F, 0xF0, 0x7F, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0,
  0x3C, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x78, 0x7C, 0x1E, 0x0F, 0x83,
  0x81, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x79, 0xF8,
  0x1C, 0xFF, 0x87, 0x7F, 0xF1, 0xFF, 0xFC, 0x7C, 0x1F, 0x8E, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xCC, 0x03, 0xE7, 0x80, 0xFB, 0xF0,
  0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0xF8, 0x1E, 0xFF, 0x8F, 0x7F, 0xF3, 0xFF,
  0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x80, 0xF9, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0, 0x7D, 0xE0, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x3C, 0x07, 0x87, 0xC1, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0x83, 0xF3, 0xE0, 0x3E, 0x78, 0x03, 0xDF,
  0x00, 0x7D, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0x78, 0x1F, 0x9E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x70,
  0xF0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0x30,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x03, 0xFC, 0x03,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE1, 0xE7, 0xE1, 0xFB, 0xF1, 0xFF, 0xF8, 0xF1, 0xFC, 0x70,
  0x7E, 0x38, 0x3F, 0x1C, 0x1F, 0x8E, 0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1,
  0xE3, 0xF8, 0xFF, 0xFC, 0x3F, 0x7F, 0x0F, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x80,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1,
  0xFB, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0C, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x06, 0x7C, 0x03, 0xDF, 0x03, 0xEF, 0xC3, 0xF3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0x07, 0xE7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x0F, 0xCF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3E, 0x1F, 0x9F, 0x01, 0xE7, 0xC0, 0x7D, 0xF0, 0x18, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xF7, 0x87, 0xFD, 0xE0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0xC0, 0x7C,
  0xFC, 0x3F, 0x3F, 0xFF, 0xC7, 0xFE, 0xF0, 0xFF, 0x3C, 0x1F, 0x8F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x10, 0x1F, 0xF0, 0x1F, 0xF8,
  0x1E, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xF0,
  0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E,
  0x0F, 0x1F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE3, 0xE0, 0xF0,
  0xFC, 0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x07,
  0xCF, 0x00, 0xFB, 0xC0, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xBC, 0xEF, 0xFE, 0xFF, 0xF7, 0xF7,
  0xFB, 0xFB, 0xFC, 0xF9, 0xFE, 0x7C, 0xFF, 0x3E, 0x7F, 0x8E, 0x3F, 0xC7,
  0x1F, 0xE1, 0x8F, 0xF0, 0x87, 0xF8, 0x43, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xEF,
  0x0F, 0xF7, 0x87, 0xF9, 0xE3, 0xFC, 0xF1, 0xFE, 0x78, 0xFF, 0x1E, 0x7F,
  0x8F, 0x3F, 0xC7, 0x9F, 0xE1, 0xEF, 0xF0, 0xF7, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x03, 0xF7, 0x80, 0xFB, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x0F, 0xDF, 0xFF, 0xEF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x7C,
  0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0,
  0x1F, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0x07,
  0x9F, 0x00, 0xC7, 0xC0, 0x21, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xCC, 0x00, 0xF7, 0x80, 0x7F, 0xF8, 0x3F, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x83, 0xE7, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF1,
  0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x87, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1,
  0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xE7, 0xF9, 0xDC, 0xFF, 0x3B, 0x9E, 0xE7,
  0x73, 0x9C, 0xEE, 0x73, 0x9D, 0xCE, 0x7B, 0x1D, 0xCF, 0xE3, 0xB9, 0xFC,
  0x77, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0x7C,
  0x03, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x01, 0xF1, 0xF0,
  0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0x78,
  0x7C, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xF1,
  0xF0, 0x07, 0x8F, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0x7B, 0xC0, 0x1F, 0x7C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x1E, 0x0F, 0x07,
  0xC1, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xDC,
  0x00, 0x70, 0x80, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0xE3, 0xE3, 0xC7, 0xC7, 0x87, 0x84, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0x3E, 0x0C, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0x7C, 0xF0,
  0x1F, 0x3E, 0x0F, 0xCF, 0xFE, 0xFD, 0xFF, 0xBF, 0x7F, 0xCF, 0xC7, 0xE1,
  0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x7D, 0xFF, 0x3E, 0xFF,
  0xDF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFD, 0xF7, 0xFE, 0xFB, 0xFE, 0x7C, 0x7C, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x71, 0xE0, 0x21,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x87, 0xC0,
  0x63, 0xF0, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x8F, 0x9F, 0xF7, 0xDF, 0xFB, 0xEF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xFF,
  0xFE, 0xFF, 0xDF, 0x3F, 0xEF, 0x87, 0xC7, 0xC0, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x43,
  0xE0, 0x71, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7C, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xF0, 0x7C, 0x7F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF7, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xFC,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF3, 0xFC, 0xF7, 0xFC, 0xFF,
  0xFE, 0xFC, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFC, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xF8, 0x1F,
  0x3C, 0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x9F, 0x03, 0xDF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0x7C, 0x1E, 0x1F, 0x0F, 0x0F, 0x87,
  0x83, 0xE3, 0xC0, 0xF9, 0xE0, 0x7E, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0x87, 0x9E, 0xF9, 0xFB, 0xDF, 0xBF, 0x7F, 0xFF,
  0xFF, 0x9F, 0x3F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1,
  0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF, 0x0E, 0x1F, 0xE1, 0xC3,
  0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3C, 0xF1, 0xF0,
  0xF3, 0xFC, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0xF8, 0xF8, 0x7D, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xFD, 0xF7, 0xFE, 0xFB,
  0xFE, 0x7C, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x9F, 0xF7, 0xDF,
  0xFB, 0xEF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0xFD, 0xFF, 0xFE, 0xFF, 0xDF, 0x3F, 0xEF, 0x87, 0xC7, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xC0, 0xE3, 0xC0, 0x21, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xF2, 0x00, 0xFB, 0xC0, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0x7C, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xCF, 0x0F,
  0x8F, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1F, 0x1F, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0xF8, 0x7B, 0x87,
  0xC3, 0x9C, 0x3E, 0x1C, 0xF1, 0xF0, 0xE7, 0x8F, 0x8F, 0x3C, 0x6E, 0x79,
  0xE7, 0x73, 0xCF, 0x3B, 0x9E, 0x39, 0xDC, 0xE1, 0xCE, 0xE7, 0x0E, 0x63,
  0x38, 0x73, 0x19, 0xC3, 0xF8, 0xEE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x7C, 0x07, 0xC7, 0xC0,
  0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0x80, 0xF9, 0xE0, 0x0F, 0x78, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0xFB, 0xE0, 0x1E, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x7C, 0x7C, 0x07,
  0xDF, 0x00, 0xFC, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03,
  0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x1F, 0x1F,
  0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0x0F, 0x01, 0xC3, 0xF8, 0x3C, 0xFF, 0x07, 0x1F, 0xF0, 0xE7, 0x9F,
  0x3C, 0xE1, 0xFF, 0x1C, 0x1F, 0xE3, 0x83, 0xF8, 0xF0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 24, 21, 7, -24 },
  { 22, 11, 11, 21, 5, -26 },
  { 38, 21, 24, 21, 0, -24 },
  { 101, 19, 32, 21, 1, -28 },
  { 177, 21, 24, 21, 0, -24 },
  { 240, 20, 24, 21, 1, -24 },
  { 300, 5, 11, 21, 8, -26 },
  { 307, 12, 32, 21, 6, -27 },
  { 355, 12, 32, 21, 3, -27 },
  { 403, 19, 18, 21, 1, -19 },
  { 446, 17, 18, 21, 2, -20 },
  { 485, 8, 11, 21, 6, -6 },
  { 496, 11, 4, 21, 5, -13 },
  { 502, 7, 6, 21, 7, -6 },
  { 508, 15, 32, 21, 3, -27 },
  { 568, 19, 24, 21, 1, -24 },
  { 625, 19, 24, 21, 1, -24 },
  { 682, 17, 24, 21, 2, -24 },
  { 733, 18, 24, 21, 1, -24 },
  { 787, 19, 24, 21, 1, -24 },
  { 844, 18, 24, 21, 2, -24 },
  { 898, 18, 24, 21, 2, -24 },
  { 952, 17, 24, 21, 2, -24 },
  { 1003, 19, 24, 21, 1, -24 },
  { 1060, 18, 24, 21, 1, -24 },
  { 1114, 7, 18, 21, 7, -18 },
  { 1130, 8, 23, 21, 6, -18 },
  { 1153, 15, 21, 21, 3, -21 },
  { 1193, 17, 12, 21, 2, -17 },
  { 1219, 15, 21, 21, 3, -21 },
  { 1259, 16, 24, 21, 2, -24 },
  { 1307, 17, 28, 21, 2, -24 },
  { 1367, 21, 24, 21, 0, -24 },
  { 1430, 16, 24, 21, 3, -24 },
  { 1478, 17, 24, 21, 2, -24 },
  { 1529, 17, 24, 21, 3, -24 },
  { 1580, 15, 24, 21, 3, -24 },
  { 1625, 16, 24, 21, 3, -24 },
  { 1673, 18, 24, 21, 1, -24 },
  { 1727, 17, 24, 21, 2, -24 },
  { 1778, 15, 24, 21, 3, -24 },
  { 1823, 16, 24, 21, 2, -24 },
  { 1871, 18, 24, 21, 3, -24 },
  { 1925, 16, 24, 21, 3, -24 },
  { 1973, 17, 24, 21, 2, -24 },
  { 2024, 17, 24, 21, 2, -24 },
  { 2075, 19, 24, 21, 1, -24 },
  { 2132, 16, 24, 21, 3, -24 },
  { 2180, 19, 31, 21, 1, -24 },
  { 2254, 17, 24, 21, 3, -24 },
  { 2305, 18, 24, 21, 1, -24 },
  { 2359, 19, 24, 21, 1, -24 },
  { 2416, 17, 24, 21, 2, -24 },
  { 2467, 19, 24, 21, 1, -24 },
  { 2524, 19, 24, 21, 1, -24 },
  { 2581, 21, 24, 21, 0, -24 },
  { 2644, 21, 24, 21, 0, -24 },
  { 2707, 17, 24, 21, 2, -24 },
  { 2758, 11, 32, 21, 7, -27 },
  { 2802, 15, 32, 21, 3, -27 },
  { 2862, 11, 32, 21, 3, -27 },
  { 2906, 19, 16, 21, 1, -24 },
  { 2944, 17, 4, 21, 2, 3 },
  { 2953, 7, 8, 21, 6, -28 },
  { 2960, 18, 18, 21, 2, -18 },
  { 3001, 17, 26, 21, 2, -26 },
  { 3057, 17, 18, 21, 2, -18 },
  { 3096, 17, 26, 21, 2, -26 },
  { 3152, 17, 18, 21, 2, -18 },
  { 3191, 17, 26, 21, 2, -26 },
  { 3247, 18, 29, 21, 2, -22 },
  { 3313, 16, 26, 21, 3, -26 },
  { 3365, 16, 26, 21, 3, -26 },
  { 3417, 13, 33, 21, 3, -26 },
  { 3471, 17, 26, 21, 3, -26 },
  { 3527, 16, 26, 21, 3, -26 },
  { 3579, 19, 18, 21, 1, -18 },
  { 3622, 16, 18, 21, 3, -18 },
  { 3658, 17, 18, 21, 2, -18 },
  { 3697, 17, 25, 21, 2, -18 },
  { 3751, 17, 25, 21, 2, -18 },
  { 3805, 17, 18, 21, 3, -18 },
  { 3844, 17, 18, 21, 2, -18 },
  { 3883, 18, 24, 21, 1, -24 },
  { 3937, 16, 18, 21, 2, -18 },
  { 3973, 19, 18, 21, 1, -18 },
  { 4016, 21, 18, 21, 0, -18 },
  { 4064, 19, 18, 21, 1, -18 },
  { 4107, 19, 25, 21, 1, -18 },
  { 4167, 15, 18, 21, 3, -18 },
  { 4201, 15, 32, 21, 3, -27 },
  { 4261, 3, 32, 21, 9, -27 },
  { 4273, 15, 32, 21, 3, -27 },
  { 4333, 19, 9, 21, 1, -15 },
};

const GFXfont IBMPlexMono_SemiBold35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_SEMIBOLD35PT7B_H_
