#ifndef _IBMPLEXMONO_SEMIBOLD23PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0x66, 0x64, 0x00, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0x06, 0x70, 0x19, 0x80, 0x66, 0x03, 0x98, 0x0E,
  0x61, 0xF3, 0xF7, 0xCF, 0xC3, 0x30, 0x1C, 0xC3, 0xF3, 0xEF, 0x9F, 0x86,
  0x70, 0x19, 0x80, 0xE6, 0x03, 0x98, 0x0E, 0xE0, 0x06, 0x00, 0x60, 0x1F,
  0xC7, 0xFE, 0x76, 0xFE, 0x64, 0xE6, 0x0E, 0x60, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x6F, 0x06, 0x70, 0x67, 0x46, 0x7E, 0x6E, 0xFF, 0xE3, 0xF8, 0x06,
  0x00, 0x60, 0x3C, 0x1D, 0xF8, 0x6E, 0x63, 0x31, 0x8C, 0xC6, 0x63, 0x99,
  0x87, 0xEC, 0x0F, 0x00, 0x00, 0xF0, 0x77, 0xE1, 0x99, 0x8E, 0xE7, 0x33,
  0x9D, 0xC6, 0x66, 0x1F, 0xB8, 0x3C, 0x0F, 0x00, 0x7F, 0x03, 0x9C, 0x0C,
  0x40, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x1E, 0x3E, 0x79, 0xDD, 0x86,
  0x3E, 0x38, 0x78, 0xE1, 0xE1, 0xC7, 0xC7, 0xF7, 0x07, 0x8F, 0xFF, 0xFC,
  0x0F, 0x1C, 0x18, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0F, 0xE0, 0x30, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x30, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x62, 0xFF, 0xF7,
  0xFE, 0x0F, 0x01, 0xF8, 0x3F, 0x83, 0x9C, 0x70, 0xE2, 0x08, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x7B, 0xDC, 0xE6, 0x73, 0x80, 0xFF, 0xFC, 0xFF, 0xFF, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0x1F, 0x83,
  0xFC, 0x70, 0xE6, 0x0E, 0xE0, 0x7E, 0x07, 0xE6, 0x7E, 0xE7, 0xE6, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x60, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x3B, 0x87, 0x38, 0xE3, 0x86, 0x38, 0x43, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x7F, 0xF7, 0xFF, 0x1F, 0x87,
  0xFC, 0xF1, 0xEE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0x87,
  0xFC, 0xF1, 0xE2, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xF8, 0x0F, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x40, 0xEE, 0x1E, 0x7F, 0xC3, 0xF8, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x1D, 0xC1, 0x9C, 0x39, 0xC7, 0x1C, 0x71, 0xCE,
  0x1C, 0xC1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xE7,
  0xFE, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x67, 0x86, 0xFE, 0x70, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x60, 0xFF, 0x0E, 0x7F, 0xC1, 0xF8, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x77, 0x8E, 0xFE, 0xF0, 0xEE,
  0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFE, 0x0E, 0xE0, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1F, 0x87,
  0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0xE6, 0x0E, 0x70, 0xE1, 0xF8, 0x3F, 0xC7,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E, 0x7F, 0xE1, 0xF8, 0x1F, 0x03,
  0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0x7F, 0xE3,
  0xEE, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0x7B, 0xDC, 0xE6,
  0x73, 0x80, 0x00, 0x40, 0x70, 0x7C, 0x3E, 0x3E, 0x3E, 0x0E, 0x03, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x07, 0xC7, 0xC7, 0xC3, 0xC0, 0xE0, 0x20,
  0x00, 0x3E, 0x3F, 0xEE, 0x3F, 0x07, 0x01, 0xC0, 0xF0, 0x78, 0x7C, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0, 0x70, 0x1F, 0x83, 0xFC,
  0x70, 0xE6, 0x06, 0x60, 0x6E, 0x77, 0xC7, 0xFC, 0xE7, 0xCC, 0x7C, 0xC7,
  0xCC, 0x7C, 0xE7, 0xCF, 0xFE, 0x7F, 0x60, 0x06, 0x00, 0x78, 0x03, 0xF8,
  0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0D, 0xC0, 0x73,
  0x81, 0xCE, 0x06, 0x38, 0x38, 0x60, 0xFF, 0xC3, 0xFF, 0x0C, 0x1C, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0F, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0xEE,
  0x1D, 0xC3, 0xB8, 0x77, 0xF8, 0xFF, 0x9C, 0x3B, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xBF, 0xF7, 0xF8, 0x0F, 0x83, 0xFE, 0x78, 0xE7, 0x07, 0x70, 0x8E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x08, 0x70, 0x77,
  0x8E, 0x3F, 0xE0, 0xF8, 0xFE, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEE, 0x1D, 0xC7, 0xBF,
  0xE7, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1F, 0x87, 0xF9, 0xC7, 0xB8, 0x7E,
  0x09, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x81, 0xF0, 0x37, 0x0E,
  0xE1, 0xCF, 0xD8, 0xF3, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x7E, 0x1C, 0xE3, 0x9F, 0xE0, 0xF8, 0xE0, 0xEE, 0x1C, 0xE3, 0xCE, 0x78,
  0xE7, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x70, 0xE7, 0x8E, 0x38,
  0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0xF7, 0xEF,
  0x7E, 0xF7, 0xE6, 0x7E, 0x67, 0xE4, 0x7E, 0x47, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xF6, 0x3D, 0xCF, 0x73,
  0xCC, 0xF3, 0xBC, 0x6F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0x1F, 0x83,
  0xFC, 0x70, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0xFF, 0x1F,
  0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x77, 0xFE, 0xFF, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x83, 0xFC, 0x70,
  0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0x06, 0x00, 0x60, 0x07,
  0xE0, 0x3E, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x77,
  0xFE, 0xFF, 0x1C, 0xE3, 0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x77, 0x07,
  0x1F, 0x83, 0xFE, 0x70, 0xF7, 0x04, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xF8,
  0x1F, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x40, 0xFF, 0x0E, 0x7F, 0xC3, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x0E, 0xE1, 0xCF, 0xF0, 0xFC, 0xF0, 0x3B,
  0x81, 0xDC, 0x0E, 0xF0, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x9C, 0x1C,
  0xE0, 0xE7, 0x07, 0x38, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF0,
  0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x71, 0xB3, 0xCD, 0x9E, 0x6C,
  0xF7, 0x67, 0xBB, 0xAD, 0xDF, 0x3E, 0xF9, 0xF7, 0xCF, 0xBE, 0x79, 0xF3,
  0xCF, 0x1E, 0x70, 0x3B, 0xC3, 0x8E, 0x1C, 0x39, 0xC1, 0xCE, 0x07, 0xE0,
  0x3F, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x07, 0x70, 0x39, 0xC3, 0x8E, 0x1C,
  0x39, 0xC1, 0xFE, 0x07, 0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x0E, 0x1C, 0x1C,
  0xE0, 0x73, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x81, 0xB8, 0x39, 0xC3, 0x1C, 0x70, 0xE6, 0x0E, 0xE0,
  0x7C, 0x06, 0xFF, 0xFF, 0xFC, 0x6E, 0x77, 0x30, 0x1F, 0x07, 0xFC, 0x61,
  0xC4, 0x0E, 0x00, 0xE3, 0xFE, 0x7F, 0xEF, 0x0E, 0xE0, 0xEF, 0x1E, 0x7F,
  0xF3, 0xC7, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDE, 0x3F, 0xF7,
  0x0E, 0xE1, 0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xB8, 0x77, 0xFE,
  0xEF, 0x00, 0x1F, 0x1F, 0xEF, 0x1F, 0x84, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0xBC, 0x77, 0xFC, 0x7C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x7D, 0xDF, 0xFB, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xDC, 0x3B, 0xFF, 0x3E, 0xE0, 0x1F, 0x03, 0xFC, 0x70, 0xE6, 0x0E, 0xE0,
  0x6F, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x07, 0x04, 0x3F, 0xE1, 0xF8, 0x03,
  0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0xF0, 0x0F, 0x1F, 0x83, 0xFC, 0x71, 0xE7, 0x0E, 0x70, 0xE7,
  0x1C, 0x7F, 0xC3, 0xF0, 0x20, 0x06, 0x00, 0x7F, 0xC3, 0xFF, 0x60, 0x7E,
  0x07, 0xE0, 0x77, 0xFE, 0x3F, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3B, 0xCE, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xC0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x07, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3,
  0xF8, 0xE7, 0x38, 0xEE, 0x1F, 0x83, 0xF8, 0x7F, 0x0E, 0x71, 0xC7, 0x38,
  0xF7, 0x0E, 0xE0, 0xE0, 0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC3, 0xFF,
  0xFF, 0xC0, 0xDC, 0xED, 0xFF, 0xEE, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xEF, 0x3B, 0xEF, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x1F,
  0x83, 0xFC, 0x70, 0xE6, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60,
  0xE7, 0x0E, 0x3F, 0xC1, 0xF8, 0xEF, 0x1F, 0xFB, 0x87, 0x70, 0xEE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xDC, 0x3B, 0xFF, 0x77, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x3E, 0xEF, 0xFD, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x1D, 0xFF, 0x9F, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFC, 0xFF, 0xBC, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x83, 0xFF, 0x7F, 0xE0, 0x1F, 0x87,
  0xFD, 0xC3, 0x38, 0x27, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0x40, 0xEE, 0x1F,
  0xFF, 0x0F, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x0F, 0xFF, 0xFF, 0xC7,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xF8,
  0x3F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFF, 0xFC, 0xF7, 0xE0, 0x7E, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xC3,
  0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xE3, 0x1B,
  0x3C, 0xD9, 0xE6, 0xCF, 0x36, 0x79, 0xB2, 0xCD, 0x92, 0xEF, 0x97, 0x7C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xE0, 0xF0, 0xF7, 0x0E, 0x39, 0xC1, 0xF8,
  0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x3B, 0xC3, 0x9C, 0x70, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x9C, 0x39, 0xC1, 0x98,
  0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x07, 0xC0,
  0x78, 0x00, 0xFF, 0xFF, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0F, 0xFF, 0xFF, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x0E, 0x3F, 0x0F, 0xC0, 0x38, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x18, 0x03, 0xF0,
  0xFC, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x8F, 0xE3, 0xF0,
  0x38, 0x37, 0xE7, 0xEE, 0x6C, 0x7E, 0xC3, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 8, 7, 14, 3, -17 },
  { 16, 14, 16, 14, 0, -16 },
  { 44, 12, 20, 14, 1, -18 },
  { 74, 14, 16, 14, 0, -16 },
  { 102, 14, 16, 14, 0, -16 },
  { 130, 2, 7, 14, 6, -17 },
  { 132, 8, 20, 14, 4, -17 },
  { 152, 8, 20, 14, 2, -17 },
  { 172, 12, 12, 14, 1, -13 },
  { 190, 11, 10, 14, 1, -12 },
  { 204, 5, 7, 14, 4, -4 },
  { 209, 7, 2, 14, 3, -8 },
  { 211, 4, 4, 14, 5, -4 },
  { 213, 10, 20, 14, 2, -17 },
  { 238, 12, 16, 14, 1, -16 },
  { 262, 12, 16, 14, 1, -16 },
  { 286, 12, 16, 14, 1, -16 },
  { 310, 12, 16, 14, 1, -16 },
  { 334, 12, 16, 14, 1, -16 },
  { 358, 12, 16, 14, 1, -16 },
  { 382, 12, 16, 14, 1, -16 },
  { 406, 12, 16, 14, 1, -16 },
  { 430, 12, 16, 14, 1, -16 },
  { 454, 12, 16, 14, 1, -16 },
  { 478, 4, 12, 14, 5, -12 },
  { 484, 5, 15, 14, 4, -12 },
  { 494, 10, 14, 14, 2, -14 },
  { 512, 11, 8, 14, 1, -11 },
  { 523, 10, 14, 14, 2, -14 },
  { 541, 10, 16, 14, 2, -16 },
  { 561, 12, 19, 14, 1, -16 },
  { 590, 14, 16, 14, 0, -16 },
  { 618, 11, 16, 14, 2, -16 },
  { 640, 12, 16, 14, 1, -16 },
  { 664, 11, 16, 14, 2, -16 },
  { 686, 10, 16, 14, 2, -16 },
  { 706, 10, 16, 14, 2, -16 },
  { 726, 11, 16, 14, 1, -16 },
  { 748, 10, 16, 14, 2, -16 },
  { 768, 10, 16, 14, 2, -16 },
  { 788, 11, 16, 14, 1, -16 },
  { 810, 12, 16, 14, 2, -16 },
  { 834, 10, 16, 14, 2, -16 },
  { 854, 12, 16, 14, 1, -16 },
  { 878, 10, 16, 14, 2, -16 },
  { 898, 12, 16, 14, 1, -16 },
  { 922, 11, 16, 14, 2, -16 },
  { 944, 12, 20, 14, 1, -16 },
  { 974, 11, 16, 14, 2, -16 },
  { 996, 12, 16, 14, 1, -16 },
  { 1020, 12, 16, 14, 1, -16 },
  { 1044, 11, 16, 14, 1, -16 },
  { 1066, 13, 16, 14, 0, -16 },
  { 1092, 13, 16, 14, 0, -16 },
  { 1118, 13, 16, 14, 0, -16 },
  { 1144, 14, 16, 14, 0, -16 },
  { 1172, 12, 16, 14, 1, -16 },
  { 1196, 8, 20, 14, 4, -17 },
  { 1216, 10, 20, 14, 2, -17 },
  { 1241, 7, 20, 14, 2, -17 },
  { 1259, 12, 10, 14, 1, -16 },
  { 1274, 11, 2, 14, 1, 2 },
  { 1277, 4, 5, 14, 4, -18 },
  { 1280, 12, 12, 14, 1, -12 },
  { 1298, 11, 17, 14, 2, -17 },
  { 1322, 10, 12, 14, 2, -12 },
  { 1337, 11, 17, 14, 1, -17 },
  { 1361, 12, 12, 14, 1, -12 },
  { 1379, 12, 17, 14, 1, -17 },
  { 1405, 12, 19, 14, 1, -14 },
  { 1434, 10, 17, 14, 2, -17 },
  { 1456, 11, 18, 14, 2, -18 },
  { 1481, 8, 23, 14, 2, -18 },
  { 1504, 11, 17, 14, 2, -17 },
  { 1528, 10, 17, 14, 2, -17 },
  { 1550, 12, 12, 14, 1, -12 },
  { 1568, 10, 12, 14, 2, -12 },
  { 1583, 12, 12, 14, 1, -12 },
  { 1601, 11, 17, 14, 2, -12 },
  { 1625, 11, 17, 14, 1, -12 },
  { 1649, 11, 12, 14, 2, -12 },
  { 1666, 11, 12, 14, 1, -12 },
  { 1683, 11, 16, 14, 1, -16 },
  { 1705, 10, 12, 14, 2, -12 },
  { 1720, 12, 12, 14, 1, -12 },
  { 1738, 13, 12, 14, 0, -12 },
  { 1758, 12, 12, 14, 1, -12 },
  { 1776, 12, 17, 14, 1, -12 },
  { 1802, 10, 12, 14, 2, -12 },
  { 1817, 10, 20, 14, 2, -17 },
  { 1842, 2, 20, 14, 6, -17 },
  { 1847, 10, 20, 14, 2, -17 },
  { 1872, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_SEMIBOLD23PT7B_H_
