#ifndef _IBMPLEXMONO_SEMIBOLD40PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xF1, 0xE0, 0x01, 0xE1,
  0xE0, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xE3,
  0xFF, 0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7,
  0xC0, 0xFF, 0xC7, 0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87,
  0xFC, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x8F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F,
  0x3B, 0xF0, 0xF8, 0xE3, 0x87, 0xC3, 0x84, 0x1F, 0x0E, 0x00, 0x7C, 0x38,
  0x00, 0xF8, 0xE0, 0x03, 0xF3, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3B, 0xF8, 0x00,
  0xE3, 0xE0, 0x03, 0x8F, 0x80, 0x0E, 0x1F, 0x00, 0x38, 0x78, 0x40, 0xE3,
  0xE3, 0xC3, 0x8F, 0x9F, 0xCE, 0x7E, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0x3F, 0xE0, 0x1E, 0x3F, 0xF0,
  0x3C, 0x7F, 0xF0, 0x3C, 0x78, 0xF0, 0x78, 0x70, 0x78, 0x78, 0xF0, 0x78,
  0xF0, 0xF0, 0x78, 0xF0, 0x70, 0x79, 0xE0, 0x78, 0xF1, 0xE0, 0x7F, 0xF3,
  0xC0, 0x3F, 0xF3, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFC, 0x03, 0xCF, 0xFC, 0x03, 0xCF, 0xFE, 0x07, 0x9F,
  0x1E, 0x07, 0x9E, 0x0E, 0x0F, 0x1E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E,
  0x0E, 0x1E, 0x1F, 0x1E, 0x3C, 0x0F, 0xFE, 0x3C, 0x0F, 0xFC, 0x78, 0x07,
  0xFC, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC0, 0xE0, 0x0F, 0x81, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF8, 0x7F, 0x3F,
  0xF8, 0xFE, 0x7C, 0xF9, 0xE1, 0xF1, 0xFB, 0xC3, 0xE1, 0xFF, 0x87, 0xC1,
  0xFE, 0x0F, 0x81, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7F, 0xFB, 0xF0, 0xFF, 0xF3, 0xF0, 0x7F, 0xC3, 0xE0, 0x3E, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x81, 0xE0, 0x47, 0xC7, 0x8F, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFA, 0xFF, 0xFF, 0xD0, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0xC0,
  0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x01, 0x80, 0x60, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x1E, 0x3E, 0xFC, 0x78, 0xFF, 0xF1,
  0xE3, 0xFF, 0xC7, 0x8F, 0xFF, 0x1E, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0x8F,
  0xC0, 0xF8, 0x7E, 0x03, 0x83, 0xF0, 0x0C, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0x7E, 0xF8, 0x07, 0xE1,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x0E, 0x01, 0xF8, 0x20, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF1, 0x00, 0x1F, 0x9C,
  0x00, 0xFD, 0xF0, 0x0F, 0xDF, 0xE0, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x7E, 0x07, 0x9F, 0xF8, 0x7B, 0xFF, 0xC7, 0xBF, 0xFE, 0x7E, 0x0F,
  0xE7, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x10, 0x01, 0xF3, 0x80, 0x3F, 0x7C, 0x03, 0xFF, 0xE0, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x7E,
  0x07, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0x07, 0xEF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7E, 0x0F, 0xEF, 0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0x7F, 0xFD, 0xF3, 0xFF, 0xBF, 0x1F, 0xFB, 0xE0, 0x7E, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x1E, 0x3F,
  0x9F, 0xEF, 0xF7, 0xFB, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE1, 0xF0,
  0xF8, 0x78, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0xFC,
  0x1F, 0xBE, 0x03, 0xF7, 0x00, 0xFC, 0x40, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x0F, 0xF0, 0x3C, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xF1, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF,
  0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xFF, 0xFF, 0x0F, 0xEF,
  0xF0, 0xFE, 0xF7, 0x87, 0xCF, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x1F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F,
  0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0x07, 0xE3, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1E, 0x7C, 0x01, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x10, 0x7C, 0x01, 0xE7, 0xC0, 0x1F,
  0x3E, 0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xEF, 0xC0, 0x3D, 0xF8, 0x02, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFD, 0xF1, 0xFF,
  0xDF, 0x0F, 0xF9, 0xF0, 0x7E, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x38, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xE0, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0,
  0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0,
  0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0x7C, 0x07,
  0xF3, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F,
  0xC3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xFD, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0x79, 0xEF, 0xF7, 0x9E, 0xFF, 0x3D, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x0F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x06, 0x0F, 0xF0, 0x60, 0xFF, 0x06, 0x0F, 0xF0, 0x40,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xF7, 0x83, 0xFD, 0xF0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF3, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0xCF, 0xF0, 0xF3, 0xFC, 0x3C, 0xFF, 0x0F,
  0xBF, 0xC1, 0xEF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0x80, 0xFD, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xCF, 0x80,
  0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0x1F, 0x00, 0x70,
  0xF8, 0x01, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF1, 0x00, 0x0F, 0x8C, 0x00, 0xFC, 0xF0, 0x07, 0xEF, 0xE0, 0x7E, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07,
  0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E,
  0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0xBC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x87,
  0xC3, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xFE, 0x3F, 0x1F, 0x78, 0xFE, 0x79, 0xE7, 0xF9, 0xE7, 0x9C, 0xE7, 0x9E,
  0x73, 0x9E, 0x79, 0xCE, 0x79, 0xE7, 0x39, 0xE7, 0x9C, 0xF7, 0x9E, 0xF3,
  0xDE, 0x7B, 0xCF, 0x79, 0xEE, 0x1D, 0xE7, 0xB8, 0x77, 0x9F, 0xE1, 0xFE,
  0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x8F, 0xC0, 0xFC, 0xFC,
  0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xEF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0x70, 0x40, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08,
  0x1E, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x06, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC1, 0xFC, 0x1C,
  0x03, 0xE0, 0x40, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x1F, 0xC3, 0xFF, 0xDF, 0xDF, 0xFE, 0xFE,
  0x7F, 0xE7, 0xF0, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x0F, 0x83, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF,
  0xFD, 0xFC, 0x3F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0x7D, 0xFF,
  0xCF, 0x9F, 0xF1, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xEF, 0x80, 0x23, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x31, 0xF0, 0x1E, 0x7E, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x7C, 0x7F, 0xCF, 0x9F, 0xFD, 0xF7, 0xFF,
  0xFE, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0x9F, 0xFD,
  0xF1, 0xFF, 0x3E, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF,
  0x80, 0x1E, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x08, 0x3F, 0x03,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF7, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xC1, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x78, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0x0F, 0x9F, 0xF3,
  0xE7, 0xFE, 0xFB, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8,
  0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFE, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xE1, 0xE7,
  0xDF, 0x9F, 0xBE, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xC7, 0xFC, 0x3C,
  0x3F, 0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE,
  0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1, 0xE1,
  0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0,
  0xF0, 0xFF, 0x87, 0x87, 0x80, 0xF8, 0x7C, 0x3E, 0x7F, 0xCF, 0x9F, 0xFB,
  0xEF, 0xFE, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7F, 0x0F, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x7C,
  0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xE1, 0xFD, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x1F, 0xDF, 0xFF, 0xFB, 0xEF, 0xFE, 0x7C, 0xFF, 0x8F, 0x8F, 0xC1,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE3, 0xFE, 0x7C,
  0xFF, 0xEF, 0xBF, 0xFF, 0xF7, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7F, 0x0F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xF9, 0xF0, 0x7E, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xF0, 0x7D, 0x80, 0x0F, 0xA0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xF3, 0xE0, 0x7C, 0xF8, 0x03, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x0F, 0xC8, 0x00, 0xF9, 0x80, 0x1F, 0x7E, 0x07, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0xFD, 0xF7, 0xFF, 0x7C, 0xFF, 0x9F,
  0x0F, 0x87, 0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x9F, 0x00,
  0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x7C, 0x3F, 0xC3,
  0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0,
  0xFF, 0x8F, 0xC3, 0xDE, 0x3B, 0x8F, 0x79, 0xCE, 0x79, 0xE7, 0x39, 0xE7,
  0x9C, 0xE7, 0x9E, 0x73, 0x9E, 0x79, 0xCE, 0x79, 0xE7, 0x3D, 0xE7, 0xB8,
  0x77, 0x8E, 0xE1, 0xDE, 0x3F, 0x87, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80,
  0x7E, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x0F,
  0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0x00, 0x63, 0xFC, 0x0F, 0x3F,
  0xE0, 0xF7, 0xFE, 0x0F, 0x79, 0xF0, 0xFF, 0x0F, 0x9E, 0xF0, 0x7F, 0xEF,
  0x07, 0xFC, 0xF0, 0x3F, 0x86, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 28, 24, 8, -28 },
  { 29, 13, 12, 24, 6, -30 },
  { 49, 24, 28, 24, 0, -28 },
  { 133, 22, 36, 24, 1, -32 },
  { 232, 24, 28, 24, 0, -28 },
  { 316, 23, 28, 24, 1, -28 },
  { 397, 4, 12, 24, 10, -30 },
  { 403, 14, 36, 24, 7, -30 },
  { 466, 14, 36, 24, 3, -30 },
  { 529, 22, 20, 24, 1, -22 },
  { 584, 20, 20, 24, 2, -22 },
  { 634, 9, 13, 24, 7, -7 },
  { 649, 12, 4, 24, 6, -14 },
  { 655, 8, 7, 24, 8, -7 },
  { 662, 18, 36, 24, 3, -30 },
  { 743, 22, 28, 24, 1, -28 },
  { 820, 21, 28, 24, 2, -28 },
  { 894, 20, 28, 24, 2, -28 },
  { 964, 21, 28, 24, 1, -28 },
  { 1038, 22, 28, 24, 1, -28 },
  { 1115, 20, 28, 24, 2, -28 },
  { 1185, 20, 28, 24, 2, -28 },
  { 1255, 20, 28, 24, 2, -28 },
  { 1325, 20, 28, 24, 2, -28 },
  { 1395, 20, 28, 24, 2, -28 },
  { 1465, 8, 21, 24, 8, -21 },
  { 1486, 9, 27, 24, 7, -21 },
  { 1517, 18, 24, 24, 3, -24 },
  { 1571, 20, 13, 24, 2, -19 },
  { 1604, 18, 24, 24, 3, -24 },
  { 1658, 18, 28, 24, 3, -28 },
  { 1721, 20, 32, 24, 2, -28 },
  { 1801, 23, 28, 24, 1, -28 },
  { 1882, 19, 28, 24, 3, -28 },
  { 1949, 20, 28, 24, 2, -28 },
  { 2019, 19, 28, 24, 3, -28 },
  { 2086, 18, 28, 24, 3, -28 },
  { 2149, 19, 28, 24, 3, -28 },
  { 2216, 20, 28, 24, 2, -28 },
  { 2286, 18, 28, 24, 3, -28 },
  { 2349, 18, 28, 24, 3, -28 },
  { 2412, 18, 28, 24, 2, -28 },
  { 2475, 21, 28, 24, 3, -28 },
  { 2549, 18, 28, 24, 4, -28 },
  { 2612, 20, 28, 24, 2, -28 },
  { 2682, 18, 28, 24, 3, -28 },
  { 2745, 22, 28, 24, 1, -28 },
  { 2822, 19, 28, 24, 3, -28 },
  { 2889, 22, 35, 24, 1, -28 },
  { 2986, 20, 28, 24, 3, -28 },
  { 3056, 21, 28, 24, 1, -28 },
  { 3130, 22, 28, 24, 1, -28 },
  { 3207, 20, 28, 24, 2, -28 },
  { 3277, 22, 28, 24, 1, -28 },
  { 3354, 22, 28, 24, 1, -28 },
  { 3431, 22, 28, 24, 1, -28 },
  { 3508, 24, 28, 24, 0, -28 },
  { 3592, 20, 28, 24, 2, -28 },
  { 3662, 12, 36, 24, 8, -30 },
  { 3716, 18, 36, 24, 3, -30 },
  { 3797, 12, 36, 24, 4, -30 },
  { 3851, 22, 18, 24, 1, -28 },
  { 3901, 20, 4, 24, 2, 3 },
  { 3911, 9, 9, 24, 6, -32 },
  { 3922, 21, 21, 24, 2, -21 },
  { 3978, 19, 30, 24, 3, -30 },
  { 4050, 18, 21, 24, 3, -21 },
  { 4098, 19, 30, 24, 2, -30 },
  { 4170, 20, 21, 24, 2, -21 },
  { 4223, 19, 30, 24, 3, -30 },
  { 4295, 21, 32, 24, 2, -24 },
  { 4379, 18, 30, 24, 3, -30 },
  { 4447, 18, 30, 24, 4, -30 },
  { 4515, 14, 38, 24, 4, -30 },
  { 4582, 20, 30, 24, 3, -30 },
  { 4657, 18, 30, 24, 3, -30 },
  { 4725, 21, 21, 24, 1, -21 },
  { 4781, 18, 21, 24, 3, -21 },
  { 4829, 20, 21, 24, 2, -21 },
  { 4882, 19, 29, 24, 3, -21 },
  { 4951, 19, 29, 24, 2, -21 },
  { 5020, 19, 21, 24, 3, -21 },
  { 5070, 19, 21, 24, 2, -21 },
  { 5120, 19, 28, 24, 2, -28 },
  { 5187, 18, 21, 24, 3, -21 },
  { 5235, 20, 21, 24, 2, -21 },
  { 5288, 22, 21, 24, 1, -21 },
  { 5346, 22, 21, 24, 1, -21 },
  { 5404, 22, 29, 24, 1, -21 },
  { 5484, 18, 21, 24, 3, -21 },
  { 5532, 16, 36, 24, 4, -30 },
  { 5604, 4, 36, 24, 10, -30 },
  { 5622, 16, 36, 24, 4, -30 },
  { 5694, 20, 10, 24, 2, -17 },
};

const GFXfont IBMPlexMono_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_SEMIBOLD40PT7B_H_
