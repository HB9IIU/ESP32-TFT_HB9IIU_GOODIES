#ifndef _IBMPLEXMONO_SEMIBOLD16PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x90, 0x7D, 0x80, 0xCE, 0x73, 0x9C, 0x80, 0x1B, 0x0D,
  0x86, 0xCE, 0x77, 0x39, 0xB3, 0xDF, 0xEF, 0x36, 0x12, 0x19, 0x00, 0x18,
  0x18, 0x7C, 0xFF, 0xDA, 0xD8, 0xF8, 0x7E, 0x1F, 0x1B, 0xDB, 0xFE, 0x7C,
  0x18, 0x18, 0x70, 0xFC, 0xF2, 0xD9, 0x4F, 0xC3, 0xB8, 0x1E, 0x69, 0x2C,
  0xB3, 0xF1, 0xC0, 0x3C, 0x3F, 0x19, 0x8C, 0x03, 0x1B, 0xDD, 0xFD, 0x9E,
  0xC7, 0x3F, 0x8E, 0x60, 0xFF, 0xC0, 0x19, 0x98, 0x8C, 0x63, 0x18, 0xC6,
  0x10, 0xC3, 0x0C, 0xE0, 0xC1, 0x86, 0x08, 0x30, 0xC3, 0x0C, 0x21, 0x86,
  0x33, 0x80, 0x18, 0x18, 0x9B, 0xFF, 0x3C, 0x3C, 0x6E, 0x44, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x76, 0xCC, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x06,
  0x18, 0x00, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC7, 0x7E,
  0x3C, 0x3C, 0x7C, 0xEC, 0xCC, 0xCC, 0x0C, 0x0C, 0x0C, 0x0C, 0xFF, 0xFF,
  0x3C, 0x7E, 0xC6, 0x47, 0x06, 0x0E, 0x1C, 0x38, 0x60, 0xFF, 0xFF, 0x1E,
  0x3F, 0x98, 0xC0, 0x71, 0xE0, 0xF8, 0x0C, 0x83, 0x63, 0xFF, 0x8F, 0x80,
  0x07, 0x07, 0x86, 0xC3, 0x63, 0x31, 0x19, 0x0D, 0xFF, 0xFF, 0x81, 0x80,
  0xC0, 0x7E, 0x7E, 0xC0, 0xDC, 0xFE, 0xC7, 0x03, 0x83, 0xC7, 0xFE, 0x3C,
  0x1E, 0x30, 0x60, 0x7C, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C, 0xFF,
  0xFF, 0xC6, 0xC6, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x7C, 0xFE,
  0xC7, 0xC6, 0x7C, 0x7E, 0xC7, 0xC3, 0xC7, 0xFE, 0x7C, 0x3C, 0xFE, 0xC7,
  0xC3, 0xC3, 0xC7, 0xFA, 0x7E, 0x0C, 0x1C, 0x78, 0xFF, 0x80, 0x3F, 0xE0,
  0xEE, 0xE0, 0x00, 0x76, 0xCC, 0xC0, 0x02, 0x1C, 0xF3, 0x8C, 0x0E, 0x0F,
  0x07, 0x02, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xC0, 0xE0, 0x70,
  0x61, 0xCE, 0x70, 0x80, 0x3C, 0xFF, 0x1A, 0x30, 0x67, 0x8C, 0x00, 0x38,
  0x70, 0xE0, 0x3C, 0x7E, 0xC3, 0xDF, 0x9F, 0x93, 0xB3, 0x93, 0x9F, 0xDF,
  0xC0, 0x7C, 0x3C, 0x1C, 0x0F, 0x07, 0x86, 0xC3, 0x71, 0x99, 0xCC, 0xFE,
  0x7F, 0xB0, 0xF8, 0x60, 0xFC, 0xFE, 0xC6, 0xC6, 0xFC, 0xFE, 0xC7, 0xC3,
  0xC7, 0xFE, 0xFC, 0x3C, 0x7E, 0xE7, 0xC2, 0xC0, 0xC0, 0xC0, 0xC2, 0xE7,
  0x7E, 0x3C, 0xFC, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE,
  0xFC, 0xFF, 0xFF, 0x06, 0x0F, 0xFF, 0xF0, 0x60, 0xC1, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E,
  0xC6, 0xC3, 0xC0, 0xCF, 0xCF, 0xC3, 0xE7, 0xFF, 0x7B, 0xC7, 0xC7, 0xC7,
  0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFC, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8, 0x7E, 0xFC, 0x18, 0x30, 0x60, 0xC1,
  0xA3, 0xC7, 0xFD, 0xF0, 0xC3, 0x63, 0x33, 0x1B, 0x8D, 0x87, 0xC3, 0xB1,
  0x9C, 0xC6, 0x63, 0xB0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0xFF, 0xF8, 0xC7, 0xE7, 0xEF, 0xFF, 0xFB, 0xDB, 0xD3, 0xD3, 0xC3,
  0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xD3, 0xDB, 0xDB, 0xCB, 0xCF, 0xCF,
  0xC7, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C,
  0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C,
  0x7E, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x3C, 0x18, 0x1E,
  0x0E, 0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7,
  0x3C, 0xFE, 0xC3, 0xC0, 0xF8, 0x7E, 0x0F, 0x03, 0xC7, 0xFE, 0x7C, 0xFF,
  0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0x7C, 0xE1,
  0xB0, 0xD8, 0x6C, 0x63, 0x31, 0x98, 0xCC, 0x6C, 0x1E, 0x0F, 0x07, 0x00,
  0xC0, 0xE0, 0xF0, 0x69, 0xB4, 0xDA, 0xED, 0x76, 0xEF, 0x77, 0xB9, 0xDC,
  0xE0, 0xE1, 0xB9, 0x8C, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x6C, 0x33, 0x31,
  0xF8, 0x60, 0xE1, 0xB1, 0xDC, 0xC6, 0x63, 0xE0, 0xF0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xC0,
  0xC1, 0x81, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0,
  0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0xFC, 0x38, 0x3C, 0x6C,
  0x66, 0xC6, 0xC3, 0x83, 0xFF, 0xFF, 0x9B, 0x30, 0x3C, 0xFE, 0x46, 0x7E,
  0xC6, 0xC6, 0xFF, 0x73, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xC7, 0xC3,
  0xC3, 0xC7, 0xFE, 0xDC, 0x3C, 0x7E, 0xE6, 0xC0, 0xC0, 0xE2, 0x7F, 0x3C,
  0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0x7F,
  0x3C, 0x7E, 0xC3, 0xFF, 0xC0, 0xC2, 0x7E, 0x3C, 0x1F, 0x1F, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0xFE, 0xFE, 0x03, 0x07, 0x3C, 0x7E,
  0xC6, 0xFE, 0x7C, 0x40, 0xFE, 0x7F, 0xC3, 0xFF, 0x7E, 0xC1, 0x83, 0x06,
  0x0D, 0xDB, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0x38, 0x70, 0x07, 0x8F,
  0x06, 0x0C, 0x18, 0x31, 0xFF, 0xF8, 0x0C, 0x30, 0x3F, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x7D, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xCC, 0xD8,
  0xF8, 0xFC, 0xCC, 0xC6, 0xC3, 0xF9, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x33, 0xFF, 0xF0, 0xB6, 0xB7, 0xDB, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B,
  0xDD, 0xBF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0x3C, 0xFE, 0xC7, 0xC3, 0xC3,
  0xC7, 0xFE, 0x3C, 0xDC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xDC, 0xC0,
  0xC0, 0xC0, 0x7F, 0xFF, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0x7F, 0x07, 0x07,
  0x07, 0xF3, 0xF7, 0x38, 0x30, 0x30, 0x30, 0xFE, 0xFE, 0x3C, 0x7E, 0xC4,
  0xFC, 0x7E, 0x87, 0xFE, 0x7C, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18,
  0x30, 0x7C, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xBB, 0xC3, 0xC6,
  0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x38, 0xCC, 0xE6, 0x53, 0x6B, 0xB5, 0x5A,
  0xBD, 0xCE, 0xE6, 0xC7, 0x66, 0x3C, 0x38, 0x38, 0x6C, 0x66, 0xC7, 0xE1,
  0xB1, 0xCC, 0xC6, 0x63, 0x60, 0xF0, 0x70, 0x18, 0x1C, 0x3C, 0x1C, 0x00,
  0xFF, 0xFC, 0x38, 0xE3, 0x0C, 0x3F, 0xFF, 0x3D, 0xF6, 0x08, 0x10, 0x4F,
  0x3C, 0x10, 0x42, 0x18, 0x7C, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xC1,
  0x0C, 0x21, 0x83, 0xCF, 0x60, 0x83, 0x04, 0xF3, 0xC0, 0x73, 0xFB, 0xDE,
  0x8E,
};

const GFXglyph IBMPlexMono_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 11, 10, 3, -11 },
  { 6, 5, 5, 10, 2, -12 },
  { 10, 9, 11, 10, 0, -11 },
  { 23, 8, 15, 10, 1, -13 },
  { 38, 9, 11, 10, 0, -11 },
  { 51, 9, 11, 10, 0, -11 },
  { 64, 2, 5, 10, 4, -12 },
  { 66, 5, 14, 10, 3, -12 },
  { 75, 6, 14, 10, 1, -12 },
  { 86, 8, 8, 10, 1, -9 },
  { 94, 8, 8, 10, 1, -9 },
  { 102, 4, 5, 10, 3, -3 },
  { 105, 5, 2, 10, 2, -6 },
  { 107, 3, 3, 10, 3, -3 },
  { 109, 7, 14, 10, 1, -12 },
  { 122, 8, 11, 10, 1, -11 },
  { 133, 8, 11, 10, 1, -11 },
  { 144, 8, 11, 10, 1, -11 },
  { 155, 9, 11, 10, 0, -11 },
  { 168, 9, 11, 10, 0, -11 },
  { 181, 8, 11, 10, 1, -11 },
  { 192, 8, 11, 10, 1, -11 },
  { 203, 8, 11, 10, 1, -11 },
  { 214, 8, 11, 10, 1, -11 },
  { 225, 8, 11, 10, 1, -11 },
  { 236, 3, 9, 10, 3, -9 },
  { 240, 4, 11, 10, 3, -9 },
  { 246, 7, 9, 10, 1, -9 },
  { 254, 8, 6, 10, 1, -8 },
  { 260, 7, 9, 10, 1, -9 },
  { 268, 7, 11, 10, 1, -11 },
  { 278, 8, 13, 10, 1, -11 },
  { 291, 9, 11, 10, 0, -11 },
  { 304, 8, 11, 10, 1, -11 },
  { 315, 8, 11, 10, 1, -11 },
  { 326, 8, 11, 10, 1, -11 },
  { 337, 7, 11, 10, 1, -11 },
  { 347, 8, 11, 10, 1, -11 },
  { 358, 8, 11, 10, 1, -11 },
  { 369, 8, 11, 10, 1, -11 },
  { 380, 7, 11, 10, 1, -11 },
  { 390, 7, 11, 10, 1, -11 },
  { 400, 9, 11, 10, 1, -11 },
  { 413, 7, 11, 10, 2, -11 },
  { 423, 8, 11, 10, 1, -11 },
  { 434, 8, 11, 10, 1, -11 },
  { 445, 8, 11, 10, 1, -11 },
  { 456, 8, 11, 10, 1, -11 },
  { 467, 8, 14, 10, 1, -11 },
  { 481, 8, 11, 10, 1, -11 },
  { 492, 8, 11, 10, 1, -11 },
  { 503, 9, 11, 10, 0, -11 },
  { 516, 8, 11, 10, 1, -11 },
  { 527, 9, 11, 10, 0, -11 },
  { 540, 9, 11, 10, 0, -11 },
  { 553, 9, 11, 10, 0, -11 },
  { 566, 9, 11, 10, 0, -11 },
  { 579, 8, 11, 10, 1, -11 },
  { 590, 5, 14, 10, 3, -12 },
  { 599, 7, 14, 10, 1, -12 },
  { 612, 5, 14, 10, 1, -12 },
  { 621, 8, 7, 10, 1, -11 },
  { 628, 8, 2, 10, 1, 1 },
  { 630, 3, 4, 10, 3, -13 },
  { 632, 8, 8, 10, 1, -8 },
  { 640, 8, 12, 10, 1, -12 },
  { 652, 8, 8, 10, 1, -8 },
  { 660, 8, 12, 10, 1, -12 },
  { 672, 8, 8, 10, 1, -8 },
  { 680, 8, 12, 10, 1, -12 },
  { 692, 8, 13, 10, 1, -10 },
  { 705, 7, 12, 10, 1, -12 },
  { 716, 7, 11, 10, 2, -11 },
  { 726, 6, 14, 10, 1, -11 },
  { 737, 8, 12, 10, 1, -12 },
  { 749, 7, 12, 10, 1, -12 },
  { 760, 8, 8, 10, 1, -8 },
  { 768, 7, 8, 10, 1, -8 },
  { 775, 8, 8, 10, 1, -8 },
  { 783, 8, 11, 10, 1, -8 },
  { 794, 8, 11, 10, 1, -8 },
  { 805, 8, 8, 10, 1, -8 },
  { 813, 8, 8, 10, 1, -8 },
  { 821, 7, 11, 10, 1, -11 },
  { 831, 7, 8, 10, 1, -8 },
  { 838, 8, 8, 10, 1, -8 },
  { 846, 9, 8, 10, 0, -8 },
  { 855, 8, 8, 10, 1, -8 },
  { 863, 9, 11, 10, 0, -8 },
  { 876, 7, 8, 10, 1, -8 },
  { 883, 6, 14, 10, 2, -12 },
  { 894, 2, 14, 10, 4, -12 },
  { 898, 6, 14, 10, 2, -12 },
  { 909, 8, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_SEMIBOLD16PT7B_H_
