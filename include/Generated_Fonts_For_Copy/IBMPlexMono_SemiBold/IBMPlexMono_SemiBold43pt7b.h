#ifndef _IBMPLEXMONO_SEMIBOLD43PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x1F, 0xF8,
  0x7F, 0xCF, 0xFC, 0x3F, 0xE7, 0xFE, 0x3F, 0xF3, 0xFE, 0x1F, 0xF8, 0x0F,
  0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x7F,
  0xF1, 0xFF, 0xBF, 0xF0, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xF0,
  0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFC, 0xE7, 0xE7, 0xC3, 0x87, 0x1F, 0x0E,
  0x08, 0x7C, 0x38, 0x01, 0xF0, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0xEE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0x9F, 0xC0, 0x0E, 0x1F, 0x00, 0x38,
  0x7C, 0x80, 0xE1, 0xF3, 0x03, 0x87, 0xDE, 0x0E, 0x3F, 0xFE, 0x39, 0xFB,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x07, 0xC7, 0xFC, 0x03, 0xE3, 0xFF, 0x00, 0xF1, 0xFF,
  0xE0, 0x7C, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xC1,
  0xE0, 0xF1, 0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x3E, 0x07, 0x87, 0x8F,
  0x01, 0xFF, 0xE7, 0xC0, 0x3F, 0xF1, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x79, 0xFF, 0xC0,
  0x3C, 0x7F, 0xF8, 0x0F, 0x3E, 0x3E, 0x07, 0x8F, 0x07, 0x81, 0xE3, 0xC1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83,
  0xE3, 0xE3, 0xC0, 0x7F, 0xF0, 0xF0, 0x1F, 0xFC, 0x78, 0x03, 0xFE, 0x3E,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x03, 0x80, 0x3E, 0x02, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x3F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0x7C, 0xFC, 0xF8, 0xFC, 0x7E, 0xF0,
  0xF8, 0x3E, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x1F, 0xF0, 0xF8, 0x0F, 0xE0,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0xFC,
  0x3F, 0xFC, 0x7C, 0x1F, 0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x08, 0x0F, 0x80, 0x8E, 0x1F,
  0x07, 0x3F, 0xBE, 0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x70, 0x0E, 0x00, 0x40, 0x10, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F,
  0xCF, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0,
  0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xE1, 0xFF, 0x8F, 0x87, 0xFE,
  0x3F, 0x1F, 0xF8, 0xF8, 0x7F, 0xE1, 0xE1, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E,
  0x7F, 0x03, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xE0, 0xFC,
  0x01, 0x81, 0xF8, 0x01, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xCF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFE, 0x0F, 0xF1,
  0xE0, 0x1F, 0xC3, 0x00, 0x3F, 0x08, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x20, 0x03, 0xF3, 0xC0, 0x0F, 0xDF, 0x80,
  0x3F, 0xFF, 0x03, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x78, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC3, 0xF0, 0x0F, 0x3F, 0xF0, 0x7D, 0xFF, 0xE1,
  0xF7, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xC1, 0xFE, 0x7E, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x60, 0x03,
  0xF3, 0x80, 0x0F, 0xDF, 0x00, 0x7E, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x1F, 0xBF, 0xF0, 0x7D, 0xFF, 0xE1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x0F,
  0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x1F, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFE,
  0x3F, 0xFE, 0xF8, 0xFF, 0xFB, 0xE0, 0xFF, 0xDF, 0x01, 0xFC, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0x3E, 0x1F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x8F,
  0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFB, 0xC0,
  0x1F, 0x18, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0x1F, 0x00, 0x7D, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x1E, 0x7B, 0xC3, 0xFB, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0x8F, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x3E, 0x0F,
  0xF1, 0xF0, 0x7F, 0x8F, 0x83, 0xFC, 0x7C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F,
  0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x7B,
  0xC1, 0xFB, 0xDE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x03,
  0xEF, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F,
  0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF8, 0x0F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x01, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x41, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x83, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x04, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x3F,
  0x7F, 0x83, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xBE, 0x3F, 0xFD, 0xF0, 0xFF,
  0xCF, 0x81, 0xF8, 0x7C, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF7,
  0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xFC, 0x01,
  0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0xFE, 0x03, 0xFC, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0x7F, 0xEF, 0x3D, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFE,
  0x7F, 0xE7, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0xF8, 0x7F,
  0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x0C, 0x1F, 0xF8, 0x30, 0x7F, 0xE0,
  0x81, 0xFF, 0x82, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFB, 0xE1, 0xFF, 0xBE, 0x1F, 0xF9, 0xE1, 0xFF, 0x9F, 0x1F, 0xF9,
  0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0x7D, 0xFF,
  0x87, 0xDF, 0xF8, 0x3D, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00,
  0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F, 0x07, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC,
  0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x1E, 0x1F, 0x00, 0x18, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE2, 0x00,
  0x0F, 0xC6, 0x00, 0x1F, 0x9F, 0x00, 0x7E, 0x7F, 0x81, 0xFD, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1E, 0xF8, 0x7E, 0x1E, 0xF8, 0x7E,
  0x1E, 0x78, 0x7E, 0x1E, 0x78, 0xFF, 0x1E, 0x78, 0xFF, 0x1E, 0x78, 0xFF,
  0x1E, 0x78, 0xEF, 0x3E, 0x7C, 0xE7, 0x3E, 0x7C, 0xE7, 0x3E, 0x7D, 0xE7,
  0xBE, 0x7D, 0xE7, 0xBE, 0x7D, 0xE7, 0xBE, 0x7D, 0xC7, 0xBE, 0x7D, 0xC3,
  0xBE, 0x7D, 0xC3, 0xBC, 0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFC, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xE7,
  0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0xF0, 0x00, 0x7C, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x1C, 0x3F, 0x0F, 0x87,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x82, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x0F, 0xE0, 0xF0, 0x0F, 0x80,
  0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x3F, 0xC7, 0xFF, 0xDF, 0xCF,
  0xFF, 0x7F, 0x1F, 0xF8, 0xFC, 0x3F, 0x81, 0xF0, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x81, 0xF1, 0xFF, 0x0F, 0x9F, 0xFC, 0x7D, 0xFF, 0xF3, 0xFC, 0x3F, 0xDF,
  0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xFE, 0x1F, 0xEF, 0xBF, 0xFE,
  0x7C, 0xFF, 0xE3, 0xE3, 0xFE, 0x1F, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x07, 0xE7, 0xE0, 0x3D, 0x7C,
  0x01, 0x8F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x18,
  0x7E, 0x01, 0xE3, 0xF0, 0x7F, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF3, 0xF3, 0xFF,
  0xDF, 0x9F, 0xFF, 0xFD, 0xFC, 0x1F, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0x9F, 0xFE, 0xFC, 0x7F, 0xE7,
  0xE0, 0xFC, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xF0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x08, 0x7E, 0x00, 0xE1,
  0xFC, 0x1F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xD8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0x07, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x0F, 0xCF, 0xF8,
  0xFD, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F, 0xC3,
  0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1, 0xF3, 0xCF,
  0xCF, 0xEF, 0x7F, 0x7F, 0xBD, 0xFD, 0xFF, 0xF8, 0xFC, 0x7F, 0xC3, 0xE1,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xFC, 0x3E, 0x0F,
  0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E,
  0x7E, 0x01, 0xF8, 0xFC, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0xF8, 0x7E, 0x07, 0xC7, 0xFC, 0x3E, 0x7F,
  0xF1, 0xF7, 0xFF, 0xCF, 0xF0, 0xFF, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0xFC,
  0x03, 0xF7, 0xF8, 0x7F, 0xBE, 0xFF, 0xF9, 0xF3, 0xFF, 0x8F, 0x8F, 0xF8,
  0x7C, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x7F, 0xCF, 0xCF, 0xFF, 0x7E, 0x7F,
  0xFF, 0xF7, 0xF0, 0x7F, 0xBF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xFB,
  0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFB, 0xF1, 0xFF, 0x9F, 0x83, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0,
  0x3E, 0xFF, 0x81, 0xF6, 0x00, 0x0F, 0xA0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF0, 0x1E,
  0x1F, 0x00, 0x20, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xE2, 0x00, 0x3F, 0x38, 0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFC, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x01,
  0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0xFF, 0x1E, 0x78, 0xEF, 0x1E,
  0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xE7, 0x1E,
  0x7D, 0xE7, 0xBE, 0x7D, 0xE7, 0xBC, 0x7D, 0xC7, 0xBC, 0x3D, 0xC3, 0xBC,
  0x3D, 0xC3, 0xBC, 0x3D, 0xC3, 0xBC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x7E, 0x7E, 0x01, 0xF8,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x00,
  0xFD, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFB,
  0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x07, 0xE0, 0x7E, 0x07,
  0xE1, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC1, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x83, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x38, 0x7F, 0x80, 0xF3,
  0xFF, 0x03, 0xDF, 0xFC, 0x1E, 0x78, 0xF8, 0x79, 0xE1, 0xF3, 0xEF, 0x87,
  0xFF, 0x3C, 0x0F, 0xFC, 0xF0, 0x1F, 0xE1, 0xC0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 30, 26, 9, -30 },
  { 31, 14, 13, 26, 6, -32 },
  { 54, 25, 30, 26, 0, -30 },
  { 148, 22, 38, 26, 2, -34 },
  { 253, 26, 30, 26, 0, -30 },
  { 351, 24, 30, 26, 1, -30 },
  { 441, 5, 13, 26, 10, -32 },
  { 450, 14, 39, 26, 8, -33 },
  { 519, 15, 39, 26, 3, -33 },
  { 593, 23, 22, 26, 1, -24 },
  { 657, 20, 20, 26, 3, -23 },
  { 707, 10, 13, 26, 8, -7 },
  { 724, 14, 5, 26, 6, -16 },
  { 733, 8, 8, 26, 9, -7 },
  { 741, 19, 39, 26, 3, -33 },
  { 834, 22, 30, 26, 2, -30 },
  { 917, 23, 30, 26, 2, -30 },
  { 1004, 22, 30, 26, 2, -30 },
  { 1087, 22, 30, 26, 1, -30 },
  { 1170, 24, 30, 26, 1, -30 },
  { 1260, 22, 30, 26, 2, -30 },
  { 1343, 22, 30, 26, 2, -30 },
  { 1426, 21, 30, 26, 2, -30 },
  { 1505, 22, 30, 26, 2, -30 },
  { 1588, 22, 30, 26, 2, -30 },
  { 1671, 8, 23, 26, 9, -22 },
  { 1694, 10, 28, 26, 8, -22 },
  { 1729, 18, 25, 26, 4, -26 },
  { 1786, 20, 14, 26, 3, -20 },
  { 1821, 18, 25, 26, 4, -26 },
  { 1878, 19, 30, 26, 3, -30 },
  { 1950, 21, 35, 26, 2, -30 },
  { 2042, 24, 30, 26, 1, -30 },
  { 2132, 21, 30, 26, 3, -30 },
  { 2211, 22, 30, 26, 2, -30 },
  { 2294, 21, 30, 26, 3, -30 },
  { 2373, 19, 30, 26, 4, -30 },
  { 2445, 19, 30, 26, 4, -30 },
  { 2517, 21, 30, 26, 2, -30 },
  { 2596, 20, 30, 26, 3, -30 },
  { 2671, 19, 30, 26, 3, -30 },
  { 2743, 20, 30, 26, 2, -30 },
  { 2818, 23, 30, 26, 3, -30 },
  { 2905, 19, 30, 26, 4, -30 },
  { 2977, 22, 30, 26, 2, -30 },
  { 3060, 20, 30, 26, 3, -30 },
  { 3135, 22, 30, 26, 2, -30 },
  { 3218, 21, 30, 26, 3, -30 },
  { 3297, 22, 37, 26, 2, -30 },
  { 3399, 21, 30, 26, 3, -30 },
  { 3478, 23, 30, 26, 1, -30 },
  { 3565, 24, 30, 26, 1, -30 },
  { 3655, 20, 30, 26, 3, -30 },
  { 3730, 24, 30, 26, 1, -30 },
  { 3820, 24, 30, 26, 1, -30 },
  { 3910, 24, 30, 26, 1, -30 },
  { 4000, 25, 30, 26, 0, -30 },
  { 4094, 22, 30, 26, 2, -30 },
  { 4177, 14, 39, 26, 8, -33 },
  { 4246, 19, 39, 26, 3, -33 },
  { 4339, 13, 39, 26, 4, -33 },
  { 4403, 23, 19, 26, 1, -30 },
  { 4458, 20, 5, 26, 3, 3 },
  { 4471, 9, 10, 26, 7, -35 },
  { 4483, 22, 22, 26, 2, -22 },
  { 4544, 21, 32, 26, 3, -32 },
  { 4628, 20, 22, 26, 3, -22 },
  { 4683, 21, 32, 26, 2, -32 },
  { 4767, 21, 22, 26, 2, -22 },
  { 4825, 21, 32, 26, 3, -32 },
  { 4909, 23, 35, 26, 2, -26 },
  { 5010, 20, 32, 26, 3, -32 },
  { 5090, 20, 32, 26, 4, -32 },
  { 5170, 16, 41, 26, 4, -32 },
  { 5252, 22, 32, 26, 3, -32 },
  { 5340, 20, 32, 26, 3, -32 },
  { 5420, 22, 22, 26, 2, -22 },
  { 5481, 20, 22, 26, 3, -22 },
  { 5536, 22, 22, 26, 2, -22 },
  { 5597, 21, 31, 26, 3, -22 },
  { 5679, 21, 31, 26, 2, -22 },
  { 5761, 21, 22, 26, 3, -22 },
  { 5819, 21, 22, 26, 2, -22 },
  { 5877, 21, 30, 26, 2, -30 },
  { 5956, 20, 22, 26, 3, -22 },
  { 6011, 22, 22, 26, 2, -22 },
  { 6072, 24, 22, 26, 1, -22 },
  { 6138, 23, 22, 26, 1, -22 },
  { 6202, 24, 31, 26, 1, -22 },
  { 6295, 20, 22, 26, 3, -22 },
  { 6350, 18, 39, 26, 4, -33 },
  { 6438, 4, 39, 26, 11, -33 },
  { 6458, 18, 39, 26, 4, -33 },
  { 6546, 22, 10, 26, 2, -18 },
};

const GFXfont IBMPlexMono_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_SEMIBOLD43PT7B_H_
