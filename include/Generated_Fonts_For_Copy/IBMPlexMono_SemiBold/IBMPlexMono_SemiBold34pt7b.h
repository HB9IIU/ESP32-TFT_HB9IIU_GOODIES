#ifndef _IBMPLEXMONO_SEMIBOLD34PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79, 0xE3, 0x8E, 0x30, 0xC3,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0x01,
  0xE3, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80,
  0x3C, 0x70, 0x03, 0xC7, 0x03, 0xFC, 0xFF, 0x3F, 0x8F, 0xF3, 0xF8, 0xFF,
  0x07, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0x71, 0xE0, 0xFF, 0x1F,
  0xEF, 0xF1, 0xFE, 0xFF, 0x1F, 0xE0, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3,
  0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF,
  0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x7C, 0xEF, 0x9E, 0x38, 0xC7, 0x8E, 0x01,
  0xE3, 0x80, 0x7C, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x0E, 0xFC, 0x03, 0x8F, 0x00, 0xE3, 0xC8, 0x38,
  0xF3, 0x0E, 0x3D, 0xF3, 0xBF, 0xFF, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0xF3,
  0xF8, 0x0E, 0x7F, 0xC1, 0xE7, 0x1E, 0x1C, 0xF0, 0xE3, 0xCF, 0x0E, 0x38,
  0xF0, 0xE7, 0x87, 0x0E, 0x70, 0x71, 0xEF, 0x07, 0xFC, 0xE0, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x07, 0xBF, 0xE0, 0x73,
  0x8F, 0x0F, 0x38, 0x70, 0xE3, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x87, 0x3C,
  0x38, 0xF3, 0x83, 0xFE, 0x70, 0x1F, 0xEF, 0x00, 0xF8, 0x07, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC3, 0xF3, 0xF8, 0x7E, 0xF7, 0x8F, 0xFC, 0x79, 0xC7, 0x8F, 0xB8, 0xF0,
  0xFF, 0x1E, 0x0F, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x86, 0xF0, 0xFF,
  0xDF, 0x0F, 0xF1, 0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0xF8,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x41, 0xE0, 0x9E, 0x78, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xBC, 0x07,
  0xCF, 0x81, 0xE1, 0xF0, 0xF8, 0x3C, 0x0C, 0x04, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3E, 0x1F, 0x9F, 0x01, 0xE7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x38, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x38, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF8, 0x7E,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x78, 0x0F, 0x9E, 0x07, 0xC7,
  0x83, 0xE1, 0xE0, 0x38, 0x78, 0x04, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF,
  0xC3, 0xF7, 0x80, 0xF9, 0xC0, 0x7C, 0x40, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7C, 0x1F, 0x8E, 0x03, 0xE1, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x8C, 0x01, 0xF7, 0x80,
  0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x81, 0xE1,
  0xE0, 0xF0, 0x78, 0x38, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x71,
  0xF0, 0x39, 0xFE, 0x1D, 0xFF, 0x8F, 0xFF, 0xE7, 0xC3, 0xF1, 0x80, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x90, 0x07, 0xDC, 0x03, 0xFF, 0x87,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x79, 0xF8, 0x7D, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC1,
  0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xEF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF7, 0x80,
  0xFB, 0xC0, 0x7D, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7E, 0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x07, 0x8F,
  0x83, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC7, 0xE0,
  0xF9, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF8, 0x3F,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x01, 0xE7, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x7F,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0x78, 0x1F, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x3C, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0x70, 0xF0, 0xF0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x01,
  0xE0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0x30, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x8F, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1D, 0xC1, 0xEF, 0xE1,
  0xFF, 0xF1, 0xFF, 0xF8, 0xF1, 0xFC, 0x70, 0xFE, 0x78, 0x7F, 0x3C, 0x3F,
  0x9E, 0x1F, 0xCF, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x1F, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0x9F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8,
  0x0F, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3C, 0x03, 0xC3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x08, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x04, 0x7C, 0x07, 0xDF, 0x03, 0xEF, 0xC3,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xBE,
  0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0C, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFE, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xE7, 0xC1,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xDE, 0x0F, 0x8F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xF7, 0xFF, 0xCF, 0xFF, 0x87,
  0xFE, 0x07, 0xF0, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xEF,
  0x83, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xB9, 0xFF, 0xDE, 0xEF, 0xE7,
  0x77, 0xF3, 0xF3, 0xF9, 0xF9, 0xFC, 0x7C, 0xFF, 0x3C, 0x7F, 0x8E, 0x3F,
  0xC7, 0x1F, 0xE3, 0x0F, 0xF0, 0x87, 0xF8, 0x83, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xF7,
  0x0F, 0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1,
  0xEF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0,
  0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDE,
  0x01, 0xF7, 0xC0, 0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0,
  0x3E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x79, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xF8, 0xF8, 0x7E,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x00,
  0xC7, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC8, 0x01, 0xF7, 0x00, 0x7F, 0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC,
  0x07, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x0F, 0x3C, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x01, 0xE1, 0xE0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x0F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07,
  0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1D, 0xE0,
  0x03, 0xBC, 0x78, 0x77, 0x8F, 0x8E, 0xF1, 0xF1, 0xDE, 0x3E, 0x3B, 0xCF,
  0xCF, 0x79, 0xF9, 0xEF, 0x3B, 0x3C, 0xE7, 0x77, 0x9C, 0xCE, 0xF3, 0x99,
  0xDE, 0x77, 0x3B, 0xCE, 0xE7, 0x79, 0xDC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x01, 0xF3, 0xE0,
  0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xF8, 0xF0, 0x07,
  0x9F, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07,
  0xC3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0,
  0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x1F,
  0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x79, 0xE0, 0x1E, 0x78,
  0x03, 0xFC, 0x00, 0xF3, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x10, 0x73, 0xE3, 0xE3, 0xC3, 0xC3, 0x86, 0x0F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFF, 0x1F, 0x0F, 0xC3, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xE0, 0xF9, 0xFF, 0xFF, 0x7F, 0xCF, 0x8F, 0x83, 0xC0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF1, 0xF0, 0xFB, 0xFC, 0x7F, 0xFF, 0x3F, 0x0F, 0xDF,
  0x03, 0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xE1, 0xFB, 0xFF,
  0xF9, 0xF7, 0xF8, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE,
  0x3E, 0x1F, 0x7C, 0x0C, 0x78, 0x08, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x08, 0x7C, 0x0E, 0x3E, 0x1F,
  0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x3F, 0xCF,
  0x7F, 0xEF, 0x7C, 0x2F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x7C, 0x2F, 0x7F, 0xEF, 0x3F, 0xCF, 0x0F, 0x8F, 0x07, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x43,
  0xC0, 0x71, 0xF0, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x7F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xFC, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0xC3, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x70, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x3E, 0xFF,
  0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0xF8, 0xF3, 0xF9, 0xEF,
  0xFB, 0xE1, 0xF7, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0xC0, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x3E, 0xF0, 0x3E, 0x78, 0x3E, 0x3C, 0x3E, 0x1E, 0x3E,
  0x0F, 0x3E, 0x07, 0xBE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7C,
  0xF8, 0x3C, 0x7C, 0x1E, 0x1F, 0x0F, 0x07, 0xC7, 0x83, 0xE3, 0xC0, 0xF9,
  0xE0, 0x3E, 0xF0, 0x1F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x8F, 0x3D, 0xF7, 0xEF,
  0xFD, 0xFF, 0xC7, 0xCF, 0xF1, 0xE3, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xC7,
  0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0xF1, 0xE1,
  0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xC7, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x70,
  0xF1, 0xF1, 0xE7, 0xF3, 0xDF, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0x87, 0xC7, 0x81, 0xF7, 0x80, 0x7B, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0xF8, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F, 0x87, 0xEF, 0x81, 0xF7,
  0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xF0, 0xFD, 0xFF, 0xFC, 0xFB,
  0xFC, 0x7C, 0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x3F, 0xCF, 0x7F,
  0xEF, 0x7C, 0x2F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C,
  0x2F, 0x7F, 0xEF, 0x3F, 0xCF, 0x0F, 0x8F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0x0F, 0x7F, 0x0F, 0x40, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFF, 0x7C, 0x1E, 0x78, 0x04, 0x78, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x40, 0x0F, 0x60,
  0x0F, 0xF8, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F,
  0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1,
  0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF0, 0xF0, 0xF7, 0x0F, 0x8F, 0x70, 0xF8,
  0xF7, 0x0F, 0x8F, 0x78, 0xF8, 0xE7, 0x9D, 0x8E, 0x79, 0xD8, 0xE7, 0x9D,
  0x8E, 0x39, 0x9C, 0xE3, 0x99, 0xDE, 0x39, 0x9D, 0xE3, 0xB9, 0xDE, 0x3B,
  0x8D, 0xC3, 0xB8, 0xDC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF0, 0xFC, 0x7C, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF0, 0x7C, 0x78, 0x0F,
  0xBE, 0x03, 0xEF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xE1, 0xF0,
  0xF8, 0x3E, 0x7C, 0x0F, 0xBE, 0x01, 0xF0, 0xF8, 0x03, 0xDE, 0x01, 0xF7,
  0xC0, 0x79, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xB8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0x07, 0xFC, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0x01,
  0xC7, 0xE0, 0x73, 0xFC, 0x3D, 0xE7, 0x8E, 0x70, 0xF3, 0x9C, 0x3F, 0xE7,
  0x07, 0xF3, 0xC0, 0xF8,
};

const GFXglyph IBMPlexMono_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 11, 11, 20, 5, -25 },
  { 35, 20, 24, 20, 0, -24 },
  { 95, 18, 31, 20, 1, -28 },
  { 165, 20, 24, 20, 0, -24 },
  { 225, 19, 24, 20, 1, -24 },
  { 282, 4, 11, 20, 8, -25 },
  { 288, 12, 31, 20, 6, -26 },
  { 335, 11, 31, 20, 3, -26 },
  { 378, 18, 17, 20, 1, -19 },
  { 417, 16, 17, 20, 2, -19 },
  { 451, 8, 11, 20, 6, -6 },
  { 462, 10, 4, 20, 5, -12 },
  { 467, 6, 6, 20, 7, -6 },
  { 472, 15, 31, 20, 3, -26 },
  { 531, 18, 24, 20, 1, -24 },
  { 585, 18, 24, 20, 1, -24 },
  { 639, 17, 24, 20, 2, -24 },
  { 690, 18, 24, 20, 1, -24 },
  { 744, 18, 24, 20, 1, -24 },
  { 798, 17, 24, 20, 2, -24 },
  { 849, 17, 24, 20, 2, -24 },
  { 900, 17, 24, 20, 2, -24 },
  { 951, 18, 24, 20, 1, -24 },
  { 1005, 18, 24, 20, 1, -24 },
  { 1059, 6, 18, 20, 7, -18 },
  { 1073, 8, 23, 20, 6, -18 },
  { 1096, 15, 20, 20, 3, -20 },
  { 1134, 16, 11, 20, 2, -16 },
  { 1156, 15, 20, 20, 3, -20 },
  { 1194, 16, 24, 20, 2, -24 },
  { 1242, 17, 28, 20, 2, -24 },
  { 1302, 20, 24, 20, 0, -24 },
  { 1362, 16, 24, 20, 3, -24 },
  { 1410, 17, 24, 20, 2, -24 },
  { 1461, 17, 24, 20, 2, -24 },
  { 1512, 15, 24, 20, 3, -24 },
  { 1557, 15, 24, 20, 3, -24 },
  { 1602, 17, 24, 20, 1, -24 },
  { 1653, 16, 24, 20, 2, -24 },
  { 1701, 15, 24, 20, 3, -24 },
  { 1746, 15, 24, 20, 2, -24 },
  { 1791, 18, 24, 20, 2, -24 },
  { 1845, 15, 24, 20, 3, -24 },
  { 1890, 17, 24, 20, 2, -24 },
  { 1941, 16, 24, 20, 2, -24 },
  { 1989, 18, 24, 20, 1, -24 },
  { 2043, 16, 24, 20, 3, -24 },
  { 2091, 18, 30, 20, 1, -24 },
  { 2159, 16, 24, 20, 3, -24 },
  { 2207, 18, 24, 20, 1, -24 },
  { 2261, 19, 24, 20, 1, -24 },
  { 2318, 16, 24, 20, 2, -24 },
  { 2366, 19, 24, 20, 1, -24 },
  { 2423, 19, 24, 20, 1, -24 },
  { 2480, 20, 24, 20, 0, -24 },
  { 2540, 20, 24, 20, 0, -24 },
  { 2600, 17, 24, 20, 2, -24 },
  { 2651, 10, 31, 20, 7, -26 },
  { 2690, 15, 31, 20, 3, -26 },
  { 2749, 11, 31, 20, 3, -26 },
  { 2792, 18, 15, 20, 1, -24 },
  { 2826, 16, 4, 20, 2, 2 },
  { 2834, 7, 8, 20, 5, -28 },
  { 2841, 17, 18, 20, 2, -18 },
  { 2880, 17, 25, 20, 2, -25 },
  { 2934, 16, 18, 20, 2, -18 },
  { 2970, 16, 25, 20, 2, -25 },
  { 3020, 17, 18, 20, 2, -18 },
  { 3059, 17, 25, 20, 2, -25 },
  { 3113, 18, 27, 20, 2, -20 },
  { 3174, 15, 25, 20, 3, -25 },
  { 3221, 16, 26, 20, 3, -26 },
  { 3273, 12, 33, 20, 3, -26 },
  { 3323, 17, 25, 20, 3, -25 },
  { 3377, 16, 25, 20, 2, -25 },
  { 3427, 18, 18, 20, 1, -18 },
  { 3468, 15, 18, 20, 3, -18 },
  { 3502, 17, 18, 20, 2, -18 },
  { 3541, 17, 25, 20, 2, -18 },
  { 3595, 16, 25, 20, 2, -18 },
  { 3645, 16, 18, 20, 3, -18 },
  { 3681, 16, 18, 20, 2, -18 },
  { 3717, 17, 24, 20, 1, -24 },
  { 3768, 16, 18, 20, 2, -18 },
  { 3804, 18, 18, 20, 1, -18 },
  { 3845, 20, 18, 20, 0, -18 },
  { 3890, 18, 18, 20, 1, -18 },
  { 3931, 18, 25, 20, 1, -18 },
  { 3988, 16, 18, 20, 2, -18 },
  { 4024, 14, 31, 20, 3, -26 },
  { 4079, 4, 31, 20, 8, -26 },
  { 4095, 14, 31, 20, 3, -26 },
  { 4150, 18, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_SEMIBOLD34PT7B_H_
