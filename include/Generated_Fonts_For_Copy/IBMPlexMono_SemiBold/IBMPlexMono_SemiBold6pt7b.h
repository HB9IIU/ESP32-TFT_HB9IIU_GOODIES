#ifndef _IBMPLEXMONO_SEMIBOLD6PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xAC, 0x57, 0x3E, 0x80, 0xFE, 0xEF, 0xE8, 0xEF,
  0x80, 0x6A, 0x90, 0x89, 0x35, 0x80, 0xEA, 0x80, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x25, 0x25, 0x00, 0xF7, 0xB0, 0x59, 0x30, 0xE5, 0x70, 0xEC, 0xF0,
  0x76, 0xB0, 0xFC, 0xF0, 0x77, 0xB0, 0xE5, 0x20, 0xF7, 0xF0, 0xF5, 0xA0,
  0xA0, 0xB0, 0x69, 0xFC, 0xB6, 0xE5, 0x20, 0xFF, 0xE6, 0x66, 0xEB, 0xF7,
  0xF0, 0xF2, 0x30, 0xF6, 0xF0, 0xF3, 0xF0, 0xF3, 0xC0, 0xF2, 0xB0, 0xB7,
  0xD0, 0xE9, 0x70, 0x64, 0xF0, 0xBC, 0xAB, 0xAB, 0xBF, 0xD0, 0xFF, 0xD0,
  0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB6, 0xF7, 0xD0, 0xF8, 0xF0, 0xE9, 0x20,
  0xB6, 0xB0, 0xBA, 0x64, 0xBF, 0xD0, 0xA6, 0x6B, 0xB6, 0x44, 0xE5, 0x70,
  0xEA, 0xB0, 0x89, 0x22, 0x40, 0xFC, 0x74, 0xE0, 0xC0, 0xEF, 0x80, 0x9E,
  0xF0, 0x71, 0x80, 0x3E, 0xF0, 0xFD, 0x80, 0x7D, 0x70, 0x3D, 0xFE, 0x9E,
  0xD0, 0x8A, 0xC0, 0x9D, 0x70, 0x8A, 0xCB, 0xC9, 0x70, 0xFF, 0x80, 0xF6,
  0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xEB, 0x80, 0xEF, 0x80, 0x5D,
  0x30, 0xB5, 0x80, 0xAD, 0x00, 0xFE, 0xA0, 0xEA, 0x80, 0xAD, 0x60, 0xEB,
  0x80, 0x6A, 0xB0, 0xFC, 0xAB, 0xA0, 0x74,
};

const GFXglyph IBMPlexMono_SemiBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 3, 3, 4, 0, -3 },
  { 22, 1, 2, 4, 1, -1 },
  { 23, 2, 1, 4, 1, -2 },
  { 24, 1, 1, 4, 1, -1 },
  { 25, 3, 6, 4, 0, -5 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 3, 4, 4, 0, -4 },
  { 46, 3, 4, 4, 0, -4 },
  { 48, 1, 3, 4, 1, -3 },
  { 49, 1, 4, 4, 1, -3 },
  { 50, 2, 4, 4, 1, -4 },
  { 51, 3, 2, 4, 0, -3 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 3, 5, 4, 0, -4 },
  { 57, 4, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 2, 4, 4, 1, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 5, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 0, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 3, 4, 4, 0, -4 },
  { 108, 2, 6, 4, 1, -5 },
  { 110, 3, 6, 4, 0, -5 },
  { 113, 1, 6, 4, 1, -5 },
  { 114, 3, 2, 4, 0, -4 },
  { 115, 3, 1, 4, 0, 0 },
  { 116, 1, 2, 4, 1, -5 },
  { 117, 3, 3, 4, 0, -3 },
  { 119, 3, 4, 4, 0, -4 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 3, 4, 4, 0, -4 },
  { 129, 3, 5, 4, 0, -4 },
  { 131, 3, 4, 4, 0, -4 },
  { 133, 2, 5, 4, 1, -5 },
  { 135, 2, 6, 4, 1, -5 },
  { 137, 4, 4, 4, 0, -4 },
  { 139, 3, 4, 4, 0, -4 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -3 },
  { 149, 3, 4, 4, 0, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 3, 4, 0, -3 },
  { 155, 3, 4, 4, 0, -4 },
  { 157, 3, 3, 4, 0, -3 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 4, 3, 4, 0, -3 },
  { 163, 3, 3, 4, 0, -3 },
  { 165, 3, 4, 4, 0, -3 },
  { 167, 3, 3, 4, 0, -3 },
  { 169, 2, 6, 4, 1, -5 },
  { 171, 1, 6, 4, 1, -5 },
  { 172, 2, 6, 4, 1, -5 },
  { 174, 3, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_SemiBold6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_SEMIBOLD6PT7B_H_
