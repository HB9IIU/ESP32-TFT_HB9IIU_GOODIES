#ifndef _IBMPLEXMONO_SEMIBOLD31PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x0C, 0x10, 0x00,
  0x00, 0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x01, 0xCF, 0x00, 0xF3, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x83, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x1F, 0xC1, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C,
  0x3F, 0xCF, 0xEF, 0xE3, 0xFB, 0xF8, 0xFE, 0x0E, 0x38, 0x03, 0x8E, 0x01,
  0xE7, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x7D, 0xDE, 0x79,
  0xC4, 0x79, 0xC0, 0x79, 0xC0, 0x79, 0xC0, 0x7D, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xCF, 0x01, 0xCF, 0x01, 0xC7, 0x21,
  0xC7, 0x71, 0xCF, 0x79, 0xDF, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x01, 0xCF, 0xE0, 0x77, 0xF8, 0x39,
  0xC7, 0x0E, 0xE1, 0xC7, 0x38, 0x71, 0xCE, 0x1C, 0xE1, 0xC7, 0x38, 0x7F,
  0x9C, 0x0F, 0xE7, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x3F, 0x83, 0x9F,
  0xF0, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x1C, 0x73, 0x87, 0x1D,
  0xE1, 0xFF, 0x70, 0x3F, 0xBC, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x07, 0x8F, 0x07, 0x82, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC3, 0xEF, 0xF1, 0xFF, 0x78, 0xFF, 0x9E,
  0xE3, 0x87, 0xF1, 0xC1, 0xF8, 0xE0, 0x7C, 0x78, 0x3E, 0x3E, 0x3F, 0x8F,
  0xFB, 0xC7, 0xF8, 0xF0, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC3, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1F, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x06, 0x1C, 0x33, 0xEE, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFD, 0x0F, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x01, 0xE3,
  0xC1, 0xE1, 0xE0, 0x70, 0x78, 0x10, 0x20, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x7E, 0xF9, 0xF3, 0xC7, 0x9E, 0x3C, 0x78, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF1, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x03,
  0xCF, 0x03, 0xE7, 0x83, 0xE3, 0xC0, 0xE1, 0xE0, 0x30, 0xF0, 0x10, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0xB0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0,
  0x1F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0x30, 0x1E, 0x20, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x20, 0x1F, 0x70, 0x1F, 0xF8, 0x3E,
  0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x1E,
  0x3C, 0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3,
  0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x73, 0xE1, 0xEF, 0xF3,
  0xFF, 0xF7, 0xC3, 0xF1, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x20,
  0x1E, 0xE0, 0x7F, 0xE1, 0xF7, 0xFF, 0xE3, 0xFF, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x79, 0xF8, 0x7B, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x3C,
  0x1E, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7C, 0x1E, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xEF, 0x3F, 0xEF, 0x0F,
  0x9E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0x79, 0xFB, 0xF7, 0xEF, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF7, 0xCF, 0x9E, 0x3C, 0xF1, 0xE3, 0xC7, 0x0E,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC,
  0x1F, 0x80, 0xF0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x78, 0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x1E, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE,
  0x1F, 0xF0, 0x3C, 0xC0, 0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x1F, 0xC0,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x07, 0xE0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x07, 0x70, 0xF7, 0x71,
  0xF7, 0x73, 0xFF, 0xF3, 0xCF, 0xF3, 0x87, 0xF3, 0x87, 0xF3, 0x87, 0xF3,
  0x87, 0xF3, 0x87, 0x73, 0x87, 0x73, 0xFF, 0x71, 0xF7, 0x71, 0xF7, 0x78,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xEF,
  0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x1C, 0x03, 0xC7, 0x80, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x0F, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C,
  0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1F, 0x78, 0x03, 0xFE, 0x00,
  0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF,
  0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xE1, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x04, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x08, 0xF0, 0x1E, 0xF0, 0x3D, 0xF0, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x10,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3E, 0x3F,
  0x3F, 0xEF, 0x1F, 0xEF, 0x0F, 0x8F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0xEF, 0x8F,
  0x9F, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0,
  0xF7, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xE0, 0xFD, 0xF0, 0xF8, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x37, 0xF7, 0x77, 0xF7, 0x77, 0xF7, 0xE7, 0xF3,
  0xE7, 0xF3, 0xE7, 0xF3, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0x87, 0xF0,
  0x87, 0xF1, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x8F, 0xF7, 0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF,
  0x3D, 0xFE, 0x3B, 0xFC, 0x77, 0xF8, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC1, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF9, 0xE0, 0xF8, 0xF0, 0xF8,
  0xF0, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8,
  0x1F, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0x7C, 0x1E, 0x78, 0x04, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x20, 0x0F, 0x70,
  0x0F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3D, 0xE0, 0x79, 0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x81,
  0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xDF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xF9, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x1E, 0x3F, 0x8F, 0x9F, 0xC7, 0xCF, 0xF3, 0xE7, 0x79, 0xF3, 0xBC, 0xD9,
  0xDE, 0xEC, 0xEF, 0x77, 0x77, 0xBB, 0xB9, 0xD9, 0xDC, 0xEC, 0xEE, 0x76,
  0x37, 0x3F, 0x1B, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xF3, 0xE1, 0xF8,
  0x7C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x1E, 0x03,
  0xC7, 0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x3C, 0xF8,
  0x1F, 0x1E, 0x07, 0x87, 0xC3, 0xE0, 0xF0, 0xF0, 0x3E, 0x7C, 0x07, 0xBE,
  0x01, 0xF0, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x3E, 0x3E,
  0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0xBC, 0x01, 0xEF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0xF3, 0xC0,
  0x78, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xDE, 0x01,
  0xEF, 0x00, 0x79, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x33,
  0xC7, 0x9E, 0x3C, 0x70, 0x80, 0x0F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8, 0xF0,
  0x78, 0x20, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFC, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF, 0xFF, 0x7F, 0xBF, 0x3F,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0xF8, 0xF7, 0xF9, 0xEF, 0xFB, 0xE1, 0xF7, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xC3, 0xEF, 0x7F, 0xDE, 0xFF, 0x3C, 0x7C, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xC7, 0xC3, 0xE7, 0xFF, 0x87,
  0xFE, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x87, 0xCF, 0x1F, 0xDE, 0x7F, 0xFD, 0xF0, 0xFB,
  0xC0, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xE1, 0xF3, 0xFF, 0xE7, 0xFB, 0xC3, 0xE7, 0x80, 0x0F,
  0xC0, 0x3F, 0xE1, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xDE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x47, 0x83, 0xCF,
  0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x78, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFE, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFC, 0x1F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x7C, 0xF3, 0xFB, 0xDF, 0xFF, 0x47, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x7F, 0xEF, 0xFD, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E,
  0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C,
  0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7,
  0x1E, 0xEF, 0xBF, 0xEF, 0xBF, 0xF3, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1,
  0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xF1, 0xF3, 0xCF, 0xEF, 0x7F,
  0xFD, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF1, 0xF1, 0xEF, 0xF3, 0xDF,
  0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x87, 0xDE, 0xFF, 0xBD, 0xFE, 0x78,
  0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xEF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7,
  0xC3, 0xE7, 0xFF, 0xCF, 0xF7, 0x87, 0xCF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0x1F, 0xFE, 0x7F, 0xFD,
  0xF8, 0x7A, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDE, 0x0E, 0x70, 0x11, 0xE0, 0x07,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xD8, 0x07, 0xF0, 0x3F,
  0xFF, 0xF7, 0xFF, 0x83, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xF3,
  0xFB, 0xC7, 0xCF, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F,
  0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0xF1,
  0xE1, 0xDC, 0x78, 0x77, 0x1F, 0x1D, 0xC7, 0xC7, 0x71, 0xF3, 0xDC, 0x6C,
  0xE7, 0x3B, 0x39, 0xEE, 0xCE, 0x3B, 0x3B, 0x8E, 0xCE, 0xE3, 0xB3, 0xB8,
  0xEC, 0x6E, 0x3F, 0x1B, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0xF8,
  0x0F, 0x3E, 0x0F, 0x0F, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80, 0x7F, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xCF,
  0x01, 0xE3, 0xC1, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x1F, 0xF0, 0x0F, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x38, 0x07, 0xBC, 0x03, 0xDC, 0x00, 0xEE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x0F, 0xF8, 0x7E, 0x03, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0xFC, 0x3F, 0xE3, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0x1E, 0x07, 0x3F, 0x87, 0x7F,
  0xC7, 0x73, 0xCF, 0x71, 0xFE, 0xE0, 0xFE, 0xE0, 0x78,
};

const GFXglyph IBMPlexMono_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 6, 22, 19, 6, -22 },
  { 18, 10, 10, 19, 4, -23 },
  { 31, 18, 22, 19, 0, -22 },
  { 81, 16, 28, 19, 1, -25 },
  { 137, 18, 22, 19, 0, -22 },
  { 187, 17, 22, 19, 1, -22 },
  { 234, 4, 10, 19, 7, -23 },
  { 239, 10, 28, 19, 6, -24 },
  { 274, 10, 28, 19, 3, -24 },
  { 309, 17, 16, 19, 1, -17 },
  { 343, 15, 15, 19, 2, -17 },
  { 372, 7, 10, 19, 6, -5 },
  { 381, 10, 3, 19, 4, -11 },
  { 385, 6, 6, 19, 6, -5 },
  { 390, 14, 28, 19, 2, -24 },
  { 439, 16, 22, 19, 1, -22 },
  { 483, 17, 22, 19, 1, -22 },
  { 530, 16, 22, 19, 1, -22 },
  { 574, 16, 22, 19, 1, -22 },
  { 618, 17, 22, 19, 1, -22 },
  { 665, 15, 22, 19, 2, -22 },
  { 707, 16, 22, 19, 1, -22 },
  { 751, 15, 22, 19, 2, -22 },
  { 793, 16, 22, 19, 1, -22 },
  { 837, 16, 22, 19, 1, -22 },
  { 881, 6, 17, 19, 6, -16 },
  { 894, 7, 21, 19, 6, -16 },
  { 913, 13, 18, 19, 3, -18 },
  { 943, 15, 9, 19, 2, -14 },
  { 960, 13, 18, 19, 3, -18 },
  { 990, 14, 22, 19, 2, -22 },
  { 1029, 16, 25, 19, 1, -22 },
  { 1079, 18, 22, 19, 0, -22 },
  { 1129, 15, 22, 19, 2, -22 },
  { 1171, 15, 22, 19, 2, -22 },
  { 1213, 15, 22, 19, 2, -22 },
  { 1255, 13, 22, 19, 3, -22 },
  { 1291, 14, 22, 19, 3, -22 },
  { 1330, 16, 22, 19, 1, -22 },
  { 1374, 15, 22, 19, 2, -22 },
  { 1416, 14, 22, 19, 2, -22 },
  { 1455, 14, 22, 19, 2, -22 },
  { 1494, 16, 22, 19, 2, -22 },
  { 1538, 14, 22, 19, 3, -22 },
  { 1577, 16, 22, 19, 1, -22 },
  { 1621, 15, 22, 19, 2, -22 },
  { 1663, 16, 22, 19, 1, -22 },
  { 1707, 15, 22, 19, 2, -22 },
  { 1749, 16, 28, 19, 1, -22 },
  { 1805, 16, 22, 19, 2, -22 },
  { 1849, 16, 22, 19, 1, -22 },
  { 1893, 17, 22, 19, 1, -22 },
  { 1940, 15, 22, 19, 2, -22 },
  { 1982, 17, 22, 19, 1, -22 },
  { 2029, 17, 22, 19, 1, -22 },
  { 2076, 18, 22, 19, 0, -22 },
  { 2126, 18, 22, 19, 0, -22 },
  { 2176, 16, 22, 19, 1, -22 },
  { 2220, 10, 28, 19, 6, -24 },
  { 2255, 14, 28, 19, 2, -24 },
  { 2304, 10, 28, 19, 3, -24 },
  { 2339, 17, 14, 19, 1, -22 },
  { 2369, 15, 3, 19, 2, 3 },
  { 2375, 6, 7, 19, 5, -25 },
  { 2381, 16, 16, 19, 2, -16 },
  { 2413, 15, 23, 19, 2, -23 },
  { 2457, 15, 16, 19, 2, -16 },
  { 2487, 15, 23, 19, 1, -23 },
  { 2531, 15, 16, 19, 2, -16 },
  { 2561, 15, 23, 19, 2, -23 },
  { 2605, 16, 25, 19, 2, -19 },
  { 2655, 14, 23, 19, 2, -23 },
  { 2696, 14, 24, 19, 3, -24 },
  { 2738, 11, 30, 19, 3, -24 },
  { 2780, 16, 23, 19, 2, -23 },
  { 2826, 14, 23, 19, 2, -23 },
  { 2867, 16, 16, 19, 1, -16 },
  { 2899, 14, 16, 19, 2, -16 },
  { 2927, 16, 16, 19, 1, -16 },
  { 2959, 15, 22, 19, 2, -16 },
  { 3001, 15, 22, 19, 1, -16 },
  { 3043, 15, 16, 19, 2, -16 },
  { 3073, 14, 16, 19, 2, -16 },
  { 3101, 15, 22, 19, 1, -22 },
  { 3143, 14, 16, 19, 2, -16 },
  { 3171, 16, 16, 19, 1, -16 },
  { 3203, 18, 16, 19, 0, -16 },
  { 3239, 17, 16, 19, 1, -16 },
  { 3273, 17, 22, 19, 1, -16 },
  { 3320, 14, 16, 19, 2, -16 },
  { 3348, 13, 28, 19, 3, -24 },
  { 3394, 3, 28, 19, 8, -24 },
  { 3405, 13, 28, 19, 3, -24 },
  { 3451, 16, 7, 19, 1, -13 },
};

const GFXfont IBMPlexMono_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_SEMIBOLD31PT7B_H_
