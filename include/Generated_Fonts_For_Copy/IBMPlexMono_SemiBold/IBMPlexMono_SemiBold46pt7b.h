#ifndef _IBMPLEXMONO_SEMIBOLD46PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x07, 0xFF, 0x0F, 0xFC, 0xFF,
  0xE1, 0xFF, 0x9F, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xFE, 0x7F, 0xE1, 0xFF,
  0xC0, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x1E, 0x03, 0xFF, 0x87, 0xFE, 0x7F, 0xF0, 0xFF, 0xCF, 0xFE, 0x1F, 0xF9,
  0xFF, 0xC3, 0xFF, 0x3F, 0xF8, 0x7F, 0xE0, 0x1E, 0x1F, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xBC, 0xFC, 0x7E, 0x3C,
  0x38, 0x7E, 0x3C, 0x10, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C,
  0x00, 0x7E, 0x3C, 0x00, 0x7F, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0xFE, 0x00, 0x3C, 0x3F, 0x00, 0x3C,
  0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x10, 0x3C, 0x3F, 0x38, 0x3C,
  0x3F, 0x7C, 0x3C, 0x7E, 0xFF, 0x3C, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0xFF, 0xE0, 0x0F, 0x9F,
  0xFE, 0x03, 0xE7, 0xC7, 0xC0, 0x7C, 0xF0, 0x78, 0x1F, 0x1E, 0x0F, 0x83,
  0xE3, 0xC1, 0xF0, 0xF8, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0xC7, 0xC1, 0xE0,
  0xF8, 0xF0, 0x3C, 0x1E, 0x3E, 0x07, 0xC7, 0xC7, 0x80, 0x7F, 0xF9, 0xF0,
  0x0F, 0xFE, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0xFF, 0xC0, 0x1E, 0x3F, 0xFC,
  0x07, 0xCF, 0x87, 0x80, 0xF1, 0xF0, 0xF8, 0x3E, 0x3C, 0x0F, 0x07, 0x87,
  0x81, 0xE1, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x8F, 0x83, 0xC0, 0xF1,
  0xE0, 0x7C, 0x3E, 0x7C, 0x0F, 0x87, 0x8F, 0x00, 0xFF, 0xF3, 0xE0, 0x0F,
  0xFC, 0x78, 0x01, 0xFF, 0x10, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x06, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF8, 0x3F, 0x87, 0xFE, 0x0F, 0xE3, 0xFF, 0xC3, 0xF9, 0xFB, 0xF9,
  0xF0, 0x7C, 0x7F, 0x7C, 0x3F, 0x0F, 0xDF, 0x0F, 0xC1, 0xFF, 0x83, 0xE0,
  0x3F, 0xE0, 0xF8, 0x0F, 0xF8, 0x3E, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xDF, 0x87, 0xFF, 0xE3,
  0xF0, 0xFF, 0xF8, 0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x7C, 0x06, 0x7C, 0x7C, 0x3E, 0xFF,
  0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x3F,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x83,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xDF, 0x80, 0x3F, 0x9F,
  0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x78, 0x1F,
  0x80, 0x38, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0x80, 0x7F,
  0x7E, 0x00, 0x7E, 0x3C, 0x00, 0xFC, 0x10, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0x00, 0xFE,
  0x0E, 0x00, 0x7E, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x3F, 0x3C, 0x00, 0x7F,
  0x7E, 0x00, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x3E, 0x7F, 0xE0, 0x3E, 0xFF, 0xF0, 0x3D, 0xFF, 0xF8, 0x3D, 0xFF,
  0xFC, 0x3F, 0x83, 0xFE, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x08, 0x00, 0x7E, 0x3C, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFF, 0x83,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x7F, 0xE0, 0x7E, 0xFF, 0xF8, 0x7E, 0xFF,
  0xFC, 0x7D, 0xFF, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0,
  0x3F, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0x7F, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFD, 0xF8,
  0xFF, 0xF7, 0xE0, 0xFF, 0xCF, 0xC0, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7C, 0x1F, 0x87, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x18,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0,
  0x3F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x1E,
  0x3D, 0xE0, 0xFE, 0x7B, 0xC1, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x8F,
  0xFE, 0x3E, 0x0F, 0xFC, 0x7C, 0x0F, 0xF8, 0xF8, 0x1F, 0xF1, 0xF0, 0x3F,
  0xE3, 0xE0, 0x7F, 0xC7, 0xC0, 0xFF, 0x8F, 0x81, 0xFF, 0x1F, 0x03, 0xFE,
  0x3E, 0x07, 0xFC, 0x7C, 0x0F, 0xF8, 0x7C, 0x3F, 0xF0, 0xFF, 0xFD, 0xE1,
  0xFF, 0x7B, 0xC1, 0xFE, 0xF7, 0xC1, 0xF9, 0xEF, 0x80, 0x80, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x07, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x38,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x7F, 0x00, 0x7F,
  0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xE3, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x07,
  0xF3, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0x87, 0xFF, 0xBF,
  0x07, 0xFE, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x80, 0x3F, 0x7C, 0x01, 0xFF,
  0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00,
  0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0x9F, 0x80, 0xFF, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xE7, 0xFF, 0xF7, 0xCF, 0x7F, 0xE7, 0xFE,
  0xFF, 0xCF, 0xFD, 0xFF, 0x9F, 0xF3, 0xFF, 0x1F, 0xE7, 0xFE, 0x3F, 0x8F,
  0xFC, 0x3F, 0x1F, 0xF8, 0x7E, 0x3F, 0xF0, 0xF8, 0x7F, 0xE0, 0xF0, 0xFF,
  0xC1, 0xE1, 0xFF, 0x83, 0x83, 0xFF, 0x03, 0x07, 0xFE, 0x04, 0x0F, 0xFC,
  0x08, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xEF, 0x83, 0xFF, 0xBE, 0x0F, 0xFE, 0x7C, 0x3F, 0xF9, 0xF0,
  0xFF, 0xE7, 0xC3, 0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xFC, 0xFF,
  0xE1, 0xF3, 0xFF, 0x87, 0xCF, 0xFE, 0x0F, 0xBF, 0xF8, 0x3E, 0xFF, 0xE0,
  0xFB, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xEF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0,
  0x1F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x1E, 0x3F, 0x00, 0x08,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x20, 0x00, 0xFC, 0xE0, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC1, 0xFE,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0xFC, 0x3E,
  0xF8, 0x3F, 0x0F, 0xBF, 0x0F, 0xC3, 0xE7, 0xC7, 0xF0, 0xF9, 0xF1, 0xFC,
  0x3E, 0x7C, 0x7F, 0x8F, 0x9F, 0x1F, 0xE3, 0xE7, 0xC7, 0x78, 0xF9, 0xF1,
  0xDE, 0x3E, 0x7C, 0xF7, 0x8F, 0x9F, 0x3C, 0xE3, 0xE7, 0xCF, 0x3C, 0xF9,
  0xF3, 0xCF, 0x3C, 0x7C, 0xF3, 0xCF, 0x1F, 0x38, 0xF3, 0xC7, 0xDE, 0x3C,
  0xF1, 0xF7, 0x87, 0x7C, 0x7D, 0xE1, 0xFF, 0x0F, 0x78, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xF3, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE3, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0C, 0x0F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x0E, 0x01, 0xFC,
  0x08, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xDF, 0xFE, 0x3F, 0x9F, 0xF8,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x07,
  0xE3, 0xFE, 0x0F, 0xCF, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F,
  0x83, 0xFC, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xE0, 0x1F, 0xDF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFE, 0x7E, 0xFF, 0xF8,
  0xFC, 0xFF, 0xF1, 0xF8, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE,
  0x0F, 0xE7, 0xF0, 0x1F, 0x1F, 0x80, 0x30, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x81, 0xF8, 0x01, 0x87, 0xF0,
  0x0F, 0x8F, 0xE0, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0xC3, 0xFF, 0x1F, 0x1F, 0xFE, 0x7C, 0xFF, 0xFD, 0xF3, 0xFF, 0xF7, 0xDF,
  0xE0, 0xFF, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F,
  0x00, 0xFD, 0xFE, 0x0F, 0xF3, 0xFF, 0xF7, 0xCF, 0xFF, 0xDF, 0x1F, 0xFE,
  0x7C, 0x3F, 0xF1, 0xF0, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7,
  0xE0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0x07, 0xE0, 0x0E, 0x1F,
  0xE0, 0x7C, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x0F, 0xEF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF3, 0xE0, 0x01, 0xF9,
  0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC1, 0xF8, 0xFF, 0x8F, 0xCF, 0xFE, 0x7E,
  0xFF, 0xFB, 0xF7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0xF7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x01,
  0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF8,
  0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x00, 0xFC, 0x7F, 0x01, 0xF0, 0x7F, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0xFE, 0x0F, 0x80, 0xFE, 0x1F, 0x00, 0xFE, 0x3E,
  0x01, 0xFC, 0x7C, 0x01, 0xFC, 0xF8, 0x01, 0xFD, 0xF0, 0x03, 0xFC, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xE0, 0x78, 0xFB, 0xF0, 0xFC, 0xFB,
  0xF9, 0xFE, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x3F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xFC, 0x1F, 0x07, 0xE3, 0xFE, 0x3F, 0x3F,
  0xF9, 0xFB, 0xFF, 0xEF, 0xDF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xFC, 0x03, 0xF1, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xF8,
  0xFF, 0x83, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xE0,
  0xFF, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF8, 0x07, 0xF7, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x9F, 0xBF, 0xFE, 0x3F,
  0x3F, 0xFC, 0x7E, 0x3F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x3F, 0xF1,
  0xF1, 0xFF, 0xE7, 0xCF, 0xFF, 0xDF, 0x3F, 0xFF, 0x7D, 0xFE, 0x0F, 0xF7,
  0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x0F, 0xDF,
  0xE0, 0xFF, 0x3F, 0xFF, 0x7C, 0xFF, 0xFD, 0xF1, 0xFF, 0xE7, 0xC3, 0xFF,
  0x1F, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0xE0, 0x7E, 0xC0, 0x00, 0xFD, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFE, 0x03, 0xE3, 0xF0, 0x03, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x40, 0x01,
  0xF1, 0xC0, 0x0F, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xF7,
  0xE3, 0xFF, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1,
  0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x7F, 0x07, 0xBE, 0x1F,
  0xC1, 0xEF, 0x87, 0xF8, 0x79, 0xE1, 0xDE, 0x3E, 0x78, 0x77, 0x8F, 0x9F,
  0x1C, 0xE3, 0xE7, 0xC7, 0x38, 0xF9, 0xF3, 0xCE, 0x3E, 0x7C, 0xF3, 0xCF,
  0x1F, 0x38, 0xF3, 0xC7, 0xCE, 0x3C, 0xF0, 0xF3, 0x8F, 0x3C, 0x3C, 0xE1,
  0xCF, 0x0F, 0x78, 0x77, 0xC3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xEF, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8,
  0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x80,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x1C, 0x1F, 0xE0, 0x1F, 0x1F,
  0xF0, 0x1E, 0x3F, 0xF8, 0x1E, 0x7F, 0xFC, 0x1E, 0x7C, 0xFC, 0x3E, 0x78,
  0x7E, 0x3E, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xF8, 0xF0,
  0x0F, 0xF0, 0x30, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 33, 28, 10, -32 },
  { 34, 15, 14, 28, 6, -34 },
  { 61, 27, 32, 28, 0, -32 },
  { 169, 24, 44, 28, 2, -38 },
  { 301, 27, 34, 28, 0, -33 },
  { 416, 26, 34, 28, 1, -33 },
  { 527, 5, 14, 28, 11, -34 },
  { 536, 16, 41, 28, 8, -35 },
  { 618, 15, 41, 28, 4, -35 },
  { 695, 24, 23, 28, 2, -25 },
  { 764, 22, 23, 28, 3, -26 },
  { 828, 11, 15, 28, 8, -8 },
  { 849, 14, 5, 28, 7, -16 },
  { 858, 9, 8, 28, 9, -8 },
  { 867, 20, 41, 28, 4, -35 },
  { 970, 24, 34, 28, 2, -33 },
  { 1072, 24, 32, 28, 2, -32 },
  { 1168, 23, 33, 28, 2, -33 },
  { 1263, 24, 34, 28, 1, -33 },
  { 1365, 25, 32, 28, 1, -32 },
  { 1465, 24, 33, 28, 2, -32 },
  { 1564, 24, 33, 28, 2, -32 },
  { 1663, 22, 32, 28, 3, -32 },
  { 1751, 24, 34, 28, 2, -33 },
  { 1853, 23, 33, 28, 2, -33 },
  { 1948, 9, 24, 28, 9, -24 },
  { 1975, 11, 31, 28, 8, -24 },
  { 2018, 20, 27, 28, 4, -28 },
  { 2086, 22, 16, 28, 3, -22 },
  { 2130, 20, 27, 28, 4, -28 },
  { 2198, 21, 34, 28, 3, -33 },
  { 2288, 23, 38, 28, 2, -33 },
  { 2398, 26, 32, 28, 1, -32 },
  { 2502, 21, 32, 28, 4, -32 },
  { 2586, 24, 34, 28, 2, -33 },
  { 2688, 23, 32, 28, 3, -32 },
  { 2780, 20, 32, 28, 4, -32 },
  { 2860, 21, 32, 28, 4, -32 },
  { 2944, 23, 34, 28, 2, -33 },
  { 3042, 22, 32, 28, 3, -32 },
  { 3130, 20, 32, 28, 4, -32 },
  { 3210, 21, 33, 28, 2, -32 },
  { 3297, 24, 32, 28, 3, -32 },
  { 3393, 20, 32, 28, 5, -32 },
  { 3473, 23, 32, 28, 2, -32 },
  { 3565, 22, 32, 28, 3, -32 },
  { 3653, 24, 34, 28, 2, -33 },
  { 3755, 22, 32, 28, 4, -32 },
  { 3843, 24, 42, 28, 2, -33 },
  { 3969, 22, 32, 28, 4, -32 },
  { 4057, 23, 34, 28, 2, -33 },
  { 4155, 25, 32, 28, 1, -32 },
  { 4255, 22, 33, 28, 3, -32 },
  { 4346, 26, 32, 28, 1, -32 },
  { 4450, 26, 32, 28, 1, -32 },
  { 4554, 26, 32, 28, 1, -32 },
  { 4658, 27, 32, 28, 0, -32 },
  { 4766, 23, 32, 28, 2, -32 },
  { 4858, 14, 41, 28, 9, -35 },
  { 4930, 20, 41, 28, 4, -35 },
  { 5033, 15, 41, 28, 4, -35 },
  { 5110, 25, 20, 28, 1, -32 },
  { 5173, 22, 5, 28, 3, 4 },
  { 5187, 10, 10, 28, 7, -36 },
  { 5200, 23, 25, 28, 3, -24 },
  { 5272, 23, 35, 28, 3, -34 },
  { 5373, 22, 25, 28, 3, -24 },
  { 5442, 22, 35, 28, 2, -34 },
  { 5539, 22, 25, 28, 3, -24 },
  { 5608, 22, 34, 28, 3, -34 },
  { 5702, 25, 38, 28, 2, -28 },
  { 5821, 21, 34, 28, 3, -34 },
  { 5911, 20, 35, 28, 5, -35 },
  { 5999, 17, 44, 28, 4, -35 },
  { 6093, 23, 34, 28, 4, -34 },
  { 6191, 21, 34, 28, 3, -34 },
  { 6281, 24, 24, 28, 2, -24 },
  { 6353, 21, 24, 28, 3, -24 },
  { 6416, 23, 25, 28, 2, -24 },
  { 6488, 23, 33, 28, 3, -24 },
  { 6583, 22, 33, 28, 2, -24 },
  { 6674, 23, 24, 28, 3, -24 },
  { 6743, 22, 25, 28, 2, -24 },
  { 6812, 22, 32, 28, 2, -32 },
  { 6900, 21, 25, 28, 3, -24 },
  { 6966, 24, 24, 28, 2, -24 },
  { 7038, 26, 24, 28, 1, -24 },
  { 7116, 24, 24, 28, 2, -24 },
  { 7188, 25, 33, 28, 1, -24 },
  { 7292, 21, 24, 28, 3, -24 },
  { 7355, 19, 41, 28, 4, -35 },
  { 7453, 5, 41, 28, 11, -35 },
  { 7479, 19, 41, 28, 4, -35 },
  { 7577, 24, 12, 28, 2, -20 },
};

const GFXfont IBMPlexMono_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_SEMIBOLD46PT7B_H_
