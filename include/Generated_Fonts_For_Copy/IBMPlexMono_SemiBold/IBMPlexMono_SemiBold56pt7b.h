#ifndef _IBMPLEXMONO_SEMIBOLD56PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xF8, 0xFC, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFF, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xF8,
  0x3F, 0xFC, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0xFF, 0xF0,
  0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x3F, 0xE7, 0xDF, 0xF0, 0xFF, 0x1F, 0x1F, 0x83, 0xF8,
  0x7C, 0x1C, 0x1F, 0xC1, 0xF0, 0x20, 0x7F, 0x07, 0xC0, 0x01, 0xFC, 0x1F,
  0x00, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x3F, 0x87, 0xC0,
  0x00, 0xFF, 0x9F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7C, 0xFF, 0x80, 0x01, 0xF1, 0xFE, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x08, 0x07, 0xC1,
  0xF8, 0x70, 0x1F, 0x0F, 0xE3, 0xE0, 0x7C, 0x3F, 0x9F, 0xC1, 0xF1, 0xFE,
  0xFF, 0xE7, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC7, 0xFF, 0x80,
  0x07, 0xC7, 0xFF, 0xE0, 0x07, 0xE3, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x7C,
  0x03, 0xF1, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xF8, 0x7C, 0x07,
  0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x80,
  0xF8, 0x7E, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x3F, 0x01, 0xF0,
  0x3E, 0x1F, 0x00, 0xFC, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x8F, 0x80, 0x1F,
  0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFC, 0xFF, 0xFC, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x0F,
  0x80, 0x7E, 0x3E, 0x07, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0x80,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x1F, 0x0F, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC7, 0xE0, 0x3E,
  0x07, 0xC3, 0xE0, 0x1F, 0x83, 0xE3, 0xF0, 0x07, 0xE3, 0xF1, 0xF0, 0x03,
  0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0xF0, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x1F,
  0xC0, 0x3C, 0x00, 0x1F, 0xC0, 0x10, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xC3, 0xFE, 0x3F,
  0xBF, 0xC3, 0xE0, 0x7F, 0x1F, 0xE7, 0xE0, 0x7E, 0x0F, 0xF7, 0xE0, 0xFE,
  0x07, 0xF7, 0xE0, 0xFE, 0x03, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xC0, 0xFE,
  0x01, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0xE0, 0x7F,
  0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0xC3, 0xFC, 0x0F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08,
  0x03, 0xF0, 0x04, 0x7C, 0x0F, 0xC0, 0xF1, 0xFE, 0x3F, 0x1F, 0xE7, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x60, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x8F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC3, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x3E, 0x0F, 0xEF,
  0xE0, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xF8,
  0x7F, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0x83, 0xE0, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0xC0, 0x3F, 0x80, 0x02, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x01, 0xFE, 0x3C, 0x00, 0x1F, 0xE0, 0x40, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0,
  0x7F, 0xE3, 0xF8, 0x01, 0xFE, 0x1F, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0xFF,
  0x04, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x0C, 0x00,
  0x07, 0xF1, 0xC0, 0x00, 0xFF, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xE1, 0xFF, 0xC0,
  0x3E, 0x3F, 0xFF, 0x07, 0xE7, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xC7, 0xEF,
  0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xE7, 0xF8, 0x03, 0xFE, 0x0F, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xC0, 0x00,
  0xFF, 0x1C, 0x00, 0x0F, 0xF3, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xFE, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF9, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0x07,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x7F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xCF, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xDF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xDF,
  0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFB, 0xF8, 0x7F, 0xFF, 0x9F, 0xC1, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0x8F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC3, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFC, 0x3F,
  0x00, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF,
  0xC7, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xBE, 0x00, 0x3F, 0xC3, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x3E, 0x3E,
  0xFC, 0x0F, 0xF3, 0xEF, 0xC1, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xF8, 0xFF, 0xF8, 0x3F, 0x03, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x3E, 0x03,
  0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8,
  0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0,
  0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x3E, 0x03, 0xFF,
  0x83, 0xE0, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x81, 0xFD, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0x7C, 0x07, 0xF3, 0xF7, 0xE0, 0x18, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xE3,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0x78, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x7F, 0x80, 0x07, 0xF7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xE7, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xFC, 0xFE,
  0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xF7, 0xF8, 0x00, 0x78, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7F, 0x80, 0x03, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x3F,
  0xF1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x3F, 0x03,
  0xFF, 0xE3, 0xF0, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x20,
  0x03, 0xFB, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xE0,
  0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFF,
  0x80, 0x07, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xC0, 0x1F,
  0xF9, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0xC7,
  0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFD, 0xF0, 0xFB, 0xFF, 0xDF, 0x9F,
  0xBF, 0xFD, 0xF9, 0xF3, 0xFF, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xFC, 0x7F, 0xE3, 0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x3F,
  0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x0F, 0x03, 0xFF, 0xC0,
  0xE0, 0x3F, 0xFC, 0x0E, 0x03, 0xFF, 0xC0, 0x60, 0x3F, 0xFC, 0x04, 0x03,
  0xFF, 0xC0, 0x40, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xF7, 0xE0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0x7F, 0x03, 0xFF, 0xCF, 0xC0,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC7,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xE3, 0xFF,
  0xC1, 0xF8, 0xFF, 0xF0, 0x7E, 0x3F, 0xFC, 0x0F, 0xCF, 0xFF, 0x03, 0xF3,
  0xFF, 0xC0, 0xFC, 0xFF, 0xF0, 0x1F, 0xBF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0x87,
  0xF8, 0x00, 0xFC, 0x3F, 0xC0, 0x01, 0xC1, 0xFC, 0x00, 0x04, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x20,
  0x00, 0x1F, 0xE3, 0x80, 0x00, 0xFF, 0x3E, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x7F, 0xBF, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x3F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x0F, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x7E, 0x1F, 0xF0, 0x7E, 0x7E, 0x1F, 0xF8, 0x7C, 0x7E, 0x1E,
  0xF8, 0x7C, 0x7E, 0x1E, 0xF8, 0xFC, 0x7E, 0x1E, 0xF8, 0xFC, 0x7E, 0x3E,
  0x78, 0xFC, 0x7F, 0x3E, 0x78, 0xFC, 0x3F, 0x3E, 0x7C, 0xFC, 0x3F, 0x3E,
  0x7C, 0xFC, 0x3F, 0x3C, 0x7C, 0xFC, 0x3F, 0x3C, 0x7C, 0xFC, 0x3F, 0x7C,
  0x3C, 0xFC, 0x3F, 0x7C, 0x3E, 0xFC, 0x3F, 0x7C, 0x3E, 0xFC, 0x3F, 0x7C,
  0x3E, 0xFC, 0x3F, 0x78, 0x3E, 0xFC, 0x3F, 0x78, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x1F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x1F, 0xCF, 0x00, 0x00, 0x78, 0x08, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x01, 0xC0, 0xF8, 0x7F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xE0,
  0x10, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFE,
  0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x0C, 0x00, 0x3F, 0x80, 0x40, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0xFB, 0xFC, 0x0E, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFE, 0x7F, 0xFF, 0x3F, 0xF1, 0xFF, 0xF0, 0xFF, 0x87, 0xFF,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE1,
  0xFF, 0xC1, 0xFC, 0x7F, 0xFC, 0x3F, 0x9F, 0xFF, 0xC7, 0xF7, 0xFF, 0xFC,
  0xFE, 0xFF, 0xFF, 0x9F, 0xF8, 0x1F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xEF, 0xFF, 0xF9, 0xFD,
  0xFF, 0xFF, 0x3F, 0x9F, 0xFF, 0xC7, 0xF1, 0xFF, 0xF0, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFE, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1E, 0x1F, 0xC0, 0x02,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0x07, 0xF0, 0x01, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xE0,
  0x7F, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x7F, 0xF0, 0xFE, 0x1F, 0xFF, 0x1F, 0xC7, 0xFF, 0xF3, 0xF9,
  0xFF, 0xFE, 0x7F, 0x7F, 0xFF, 0xEF, 0xEF, 0xFC, 0x1F, 0xFD, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x7F, 0xF7, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xFF, 0xF3, 0xF8, 0x7F, 0xFC, 0x7F,
  0x07, 0xFF, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20,
  0x7F, 0x80, 0x07, 0x03, 0xFC, 0x00, 0xF8, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xEF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x1F, 0xF8,
  0x3F, 0x8F, 0xFF, 0x8F, 0xE7, 0xFF, 0xF3, 0xFB, 0xFF, 0xFC, 0xFE, 0xFF,
  0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80,
  0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x07, 0xC7, 0xE7, 0xF0, 0x7F, 0x3F, 0x3F, 0xC7,
  0xFD, 0xFB, 0xFE, 0x7F, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0x8F, 0xFF, 0x83, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0,
  0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x1F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x3F, 0xF8,
  0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F,
  0x03, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x07,
  0xFF, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x87, 0xFE, 0x0F, 0xE3, 0xFF,
  0xE3, 0xF9, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xEF, 0xFC,
  0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC3, 0xFF,
  0x83, 0xF8, 0xFF, 0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xEF, 0xFF, 0xF9, 0xFD,
  0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xDF, 0xFF, 0xF3, 0xFB, 0xFF,
  0xFE, 0x7F, 0x3F, 0xFF, 0x8F, 0xE3, 0xFF, 0xE1, 0xFC, 0x3F, 0xF8, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x3F, 0x8F,
  0xFF, 0xE7, 0xF3, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xDF, 0xDF, 0xF8, 0x3F,
  0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0xE0,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xE7, 0xF0,
  0xFF, 0xF8, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0xE1, 0xFC, 0x00,
  0x78, 0x3F, 0x80, 0x02, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x20, 0x00, 0x1F,
  0xC7, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE,
  0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xCF, 0xFF, 0xEF,
  0xE3, 0xFF, 0xE7, 0xF0, 0xFF, 0xE3, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3E,
  0xFC, 0x0F, 0xF0, 0x3E, 0xFC, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x7E,
  0x7E, 0x1F, 0xF0, 0x7E, 0x7E, 0x1E, 0xF8, 0x7E, 0x7E, 0x1E, 0xF8, 0x7E,
  0x7E, 0x1E, 0x78, 0x7C, 0x7E, 0x1E, 0x78, 0x7C, 0x7E, 0x1E, 0x78, 0x7C,
  0x3E, 0x3E, 0x78, 0x7C, 0x3E, 0x3C, 0x7C, 0x7C, 0x3E, 0x3C, 0x7C, 0xFC,
  0x3E, 0x3C, 0x7C, 0xFC, 0x3F, 0x3C, 0x3C, 0xFC, 0x3F, 0x3C, 0x3C, 0xF8,
  0x3F, 0x7C, 0x3C, 0xF8, 0x3F, 0x7C, 0x3E, 0xF8, 0x1F, 0x78, 0x3E, 0xF8,
  0x1F, 0x78, 0x3E, 0xF8, 0x1F, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x3F,
  0xE0, 0x07, 0xC3, 0xFF, 0x80, 0x3E, 0x3F, 0xFE, 0x03, 0xF1, 0xFF, 0xF8,
  0x1F, 0x9F, 0xFF, 0xC0, 0xF8, 0xFC, 0x7F, 0x0F, 0xCF, 0xC3, 0xFC, 0x7E,
  0x7E, 0x0F, 0xFF, 0xE3, 0xE0, 0x3F, 0xFF, 0x1F, 0x00, 0xFF, 0xF1, 0xF8,
  0x03, 0xFF, 0x8F, 0xC0, 0x0F, 0xF8, 0x0E, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 40, 34, 12, -39 },
  { 51, 18, 17, 34, 8, -41 },
  { 90, 32, 39, 34, 1, -39 },
  { 246, 30, 53, 34, 2, -46 },
  { 445, 33, 41, 34, 0, -40 },
  { 615, 32, 41, 34, 1, -40 },
  { 779, 6, 17, 34, 14, -41 },
  { 792, 19, 51, 34, 10, -43 },
  { 914, 18, 51, 34, 5, -43 },
  { 1029, 30, 28, 34, 2, -31 },
  { 1134, 27, 28, 34, 3, -31 },
  { 1229, 13, 17, 34, 10, -9 },
  { 1257, 17, 6, 34, 8, -20 },
  { 1270, 11, 10, 34, 11, -9 },
  { 1284, 25, 51, 34, 4, -43 },
  { 1444, 30, 41, 34, 2, -40 },
  { 1598, 30, 39, 34, 2, -39 },
  { 1745, 28, 40, 34, 3, -40 },
  { 1885, 28, 41, 34, 2, -40 },
  { 2029, 30, 39, 34, 2, -39 },
  { 2176, 28, 40, 34, 3, -39 },
  { 2316, 28, 40, 34, 3, -39 },
  { 2456, 28, 39, 34, 3, -39 },
  { 2593, 29, 41, 34, 2, -40 },
  { 2742, 29, 40, 34, 2, -40 },
  { 2887, 11, 30, 34, 11, -29 },
  { 2929, 13, 37, 34, 10, -29 },
  { 2990, 24, 33, 34, 5, -34 },
  { 3089, 27, 18, 34, 3, -26 },
  { 3150, 24, 33, 34, 5, -34 },
  { 3249, 25, 41, 34, 4, -40 },
  { 3378, 28, 46, 34, 3, -40 },
  { 3539, 32, 39, 34, 1, -39 },
  { 3695, 27, 39, 34, 4, -39 },
  { 3827, 28, 41, 34, 3, -40 },
  { 3971, 27, 39, 34, 4, -39 },
  { 4103, 24, 39, 34, 5, -39 },
  { 4220, 25, 39, 34, 5, -39 },
  { 4342, 28, 41, 34, 2, -40 },
  { 4486, 26, 39, 34, 4, -39 },
  { 4613, 25, 39, 34, 4, -39 },
  { 4735, 25, 40, 34, 3, -39 },
  { 4860, 29, 39, 34, 4, -39 },
  { 5002, 24, 39, 34, 6, -39 },
  { 5119, 28, 39, 34, 3, -39 },
  { 5256, 26, 39, 34, 4, -39 },
  { 5383, 30, 41, 34, 2, -40 },
  { 5537, 27, 39, 34, 4, -39 },
  { 5669, 30, 51, 34, 2, -40 },
  { 5861, 28, 39, 34, 4, -39 },
  { 5998, 29, 41, 34, 2, -40 },
  { 6147, 31, 39, 34, 1, -39 },
  { 6299, 27, 40, 34, 3, -39 },
  { 6434, 32, 39, 34, 1, -39 },
  { 6590, 32, 39, 34, 1, -39 },
  { 6746, 32, 39, 34, 1, -39 },
  { 6902, 33, 39, 34, 0, -39 },
  { 7063, 28, 39, 34, 3, -39 },
  { 7200, 17, 51, 34, 11, -43 },
  { 7309, 25, 51, 34, 4, -43 },
  { 7469, 18, 51, 34, 5, -43 },
  { 7584, 30, 25, 34, 2, -39 },
  { 7678, 27, 6, 34, 3, 4 },
  { 7699, 11, 13, 34, 9, -45 },
  { 7717, 29, 31, 34, 3, -30 },
  { 7830, 27, 42, 34, 4, -41 },
  { 7972, 26, 31, 34, 4, -30 },
  { 8073, 27, 42, 34, 3, -41 },
  { 8215, 28, 31, 34, 3, -30 },
  { 8324, 27, 41, 34, 4, -41 },
  { 8463, 29, 47, 34, 3, -35 },
  { 8634, 26, 41, 34, 4, -41 },
  { 8768, 26, 43, 34, 5, -43 },
  { 8908, 20, 54, 34, 5, -43 },
  { 9043, 29, 41, 34, 4, -41 },
  { 9192, 26, 41, 34, 4, -41 },
  { 9326, 29, 30, 34, 2, -30 },
  { 9435, 26, 30, 34, 4, -30 },
  { 9533, 28, 31, 34, 3, -30 },
  { 9642, 27, 41, 34, 4, -30 },
  { 9781, 27, 41, 34, 3, -30 },
  { 9920, 27, 29, 34, 4, -29 },
  { 10018, 27, 31, 34, 3, -30 },
  { 10123, 28, 39, 34, 2, -39 },
  { 10260, 25, 30, 34, 4, -29 },
  { 10354, 29, 29, 34, 2, -29 },
  { 10460, 32, 29, 34, 1, -29 },
  { 10576, 30, 29, 34, 2, -29 },
  { 10685, 30, 40, 34, 2, -29 },
  { 10835, 26, 29, 34, 4, -29 },
  { 10930, 23, 51, 34, 5, -43 },
  { 11077, 6, 51, 34, 14, -43 },
  { 11116, 23, 51, 34, 5, -43 },
  { 11263, 29, 14, 34, 2, -24 },
};

const GFXfont IBMPlexMono_SemiBold56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_SEMIBOLD56PT7B_H_
