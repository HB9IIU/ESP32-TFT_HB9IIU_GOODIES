#ifndef _IBMPLEXMONO_SEMIBOLD37PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x38, 0xC3,
  0x0C, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x0F, 0xF0,
  0xFF, 0x3F, 0xC7, 0xFC, 0xFF, 0x1F, 0xF3, 0xFC, 0x7F, 0xC0, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x3F, 0xE3, 0xFC, 0xFF,
  0x8F, 0xF3, 0xFE, 0x3F, 0xCF, 0xF8, 0xFF, 0x01, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E,
  0x77, 0xC7, 0xC7, 0x18, 0x7C, 0x71, 0x07, 0xC7, 0x00, 0x7C, 0x70, 0x07,
  0xE7, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0x7E, 0x00, 0x71, 0xF0, 0x07, 0x1F, 0x00, 0x71,
  0xF1, 0x07, 0x1F, 0x38, 0x71, 0xE7, 0xE7, 0x3E, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x3C, 0xFF, 0x01, 0xE7, 0xFE, 0x07,
  0x9E, 0x38, 0x3C, 0x70, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x3C,
  0x3C, 0xF0, 0x70, 0xF3, 0xC1, 0xE3, 0x9E, 0x07, 0xFE, 0x78, 0x0F, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0xF7, 0xFE,
  0x07, 0x9E, 0x38, 0x1C, 0x70, 0xF0, 0xF3, 0xC3, 0xC3, 0x8F, 0x0F, 0x1E,
  0x3C, 0x3C, 0x70, 0x70, 0xF3, 0xC1, 0xE3, 0x8E, 0x07, 0xFE, 0x78, 0x0F,
  0xF3, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xE1, 0xE0, 0x1E, 0x06, 0x80, 0xF0, 0x40, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE1,
  0xFC, 0x3F, 0x1F, 0xF1, 0xF9, 0xFF, 0xCF, 0xDF, 0x3E, 0x78, 0xF0, 0xFB,
  0x87, 0x83, 0xFC, 0x3C, 0x0F, 0xE1, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x7E,
  0x1F, 0xC3, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x3F, 0xE1, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0x0F, 0x0E, 0x7E, 0xF3, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xE0, 0x0F, 0x9F,
  0x01, 0xF0, 0xF8, 0x1E, 0x07, 0xC0, 0xE0, 0x70, 0x04, 0x02, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8,
  0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0xF8,
  0x7C, 0x03, 0x87, 0xC0, 0x10, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x00, 0xFC,
  0x40, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0x78, 0x0F, 0xC2, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x40, 0x0F, 0x98, 0x01, 0xF7, 0x80, 0x7F, 0xFC, 0x1F, 0xDF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x0F,
  0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80,
  0xF8, 0xF0, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x1F, 0x81, 0xE7, 0xFC, 0x3D, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x8E,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x80, 0x1F, 0x98,
  0x03, 0xE7, 0x80, 0x7D, 0xFC, 0x3F, 0x9F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x9F, 0x81, 0xF7, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC,
  0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x3E,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xE0, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0x78, 0x07, 0xCF, 0x00, 0xF0, 0xF8, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xE3, 0xE0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF8, 0x1F, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE1, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xEF,
  0xE1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFD, 0xF1, 0xFF, 0x3E, 0x0F, 0xCF, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x79, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3F, 0x7F, 0xFF,
  0xFF, 0xF3, 0xC0, 0x3C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8,
  0xF0, 0xF0, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xE1, 0xFB, 0xC0, 0x7E, 0xE0,
  0x3E, 0x20, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9E, 0x00, 0xF7, 0x80, 0x3F, 0xC1, 0xE7,
  0xF0, 0xFD, 0xFC, 0x7F, 0x7F, 0x1E, 0x3F, 0x8F, 0x0F, 0xE3, 0xC1, 0xF8,
  0xF0, 0x7E, 0x3C, 0x1F, 0x8F, 0x07, 0xE3, 0xC1, 0xF8, 0xF0, 0x7E, 0x3C,
  0x1F, 0xC7, 0x0F, 0xF1, 0xFF, 0xFC, 0x7F, 0x7F, 0x0F, 0x9D, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x03, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F, 0xBE,
  0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xFD, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F,
  0x9F, 0x01, 0xF7, 0xC0, 0x1D, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0E, 0x3E, 0x03, 0xF7, 0xC0, 0x7C,
  0x7C, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F, 0x3C,
  0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x1F, 0x3C,
  0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03,
  0xEF, 0x80, 0x7F, 0xE0, 0x1C, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x83,
  0xF7, 0xFF, 0xBC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC1, 0xF0, 0xF0, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC4, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xF3, 0xE1, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xFF,
  0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E,
  0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xC0, 0xFC,
  0xFC, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0,
  0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xDC, 0xFF, 0xF7, 0xBB, 0xFD,
  0xEE, 0xFF, 0x3F, 0xBF, 0xCF, 0xCF, 0xF3, 0xF3, 0xFC, 0x7C, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF0, 0xC3, 0xFC, 0x30, 0xFF, 0x04, 0x3F, 0xC2, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xF0, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFE, 0xF0,
  0xFF, 0xBC, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0xFF, 0x8F, 0x3F,
  0xE3, 0xCF, 0xF8, 0xF3, 0xFE, 0x1E, 0xFF, 0x87, 0xBF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0x0F, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xFF, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F,
  0xBE, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF,
  0xF3, 0xF0, 0x7C, 0xFC, 0x03, 0x1F, 0x00, 0x43, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x98, 0x01, 0xF3, 0x80, 0x3E, 0xFC, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x0F, 0x9F, 0x87, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xBF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x3E,
  0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F,
  0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC3, 0xE3,
  0xDE, 0x1F, 0x1E, 0xF1, 0xF8, 0xF7, 0x8F, 0xC7, 0xBC, 0x7E, 0x3D, 0xE3,
  0xF1, 0xE7, 0x9F, 0xCF, 0x3C, 0xEE, 0x79, 0xEE, 0x73, 0xCF, 0x73, 0x9E,
  0x7B, 0x9C, 0xE3, 0xDC, 0xE7, 0x1E, 0xE7, 0xF8, 0xF7, 0x1F, 0xC7, 0xF8,
  0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0x7C,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x03,
  0xE1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x79, 0xE0,
  0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0x3E, 0x07,
  0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xF3, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xF1,
  0xE3, 0xE3, 0xC3, 0xC3, 0x86, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFF, 0x87, 0xC1, 0xF0, 0x60, 0x1F, 0x08, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xFF, 0xFF, 0x7F, 0xE7, 0xE7, 0xFC, 0xFC,
  0x7E, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xF8, 0x3C,
  0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFC, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E,
  0xF0, 0x0F, 0xBE, 0x03, 0xEF, 0xC1, 0xFB, 0xDF, 0xFC, 0xF7, 0xFF, 0x3C,
  0xFF, 0x8F, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3E, 0x0F, 0x9F, 0x01, 0xD7, 0xC0, 0x41, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x02, 0x1F, 0x01, 0xE3,
  0xE0, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xCF, 0xF9, 0xF0, 0xFC, 0x7C,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F,
  0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x87, 0xE0, 0x70, 0xFF, 0xFF,
  0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3E, 0x07,
  0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFB, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0xF8, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xC3, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xDF, 0x03, 0xE3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01,
  0xFB, 0xE0, 0x1F, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF3, 0xC3, 0xCF, 0x3E, 0x7E, 0xF7, 0xEF, 0xEF, 0x7E, 0xFF,
  0xF8, 0xF9, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xF0, 0xF8, 0xF8, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xC3,
  0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0x00, 0xF0, 0xF8, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFC, 0xFC,
  0x1F, 0xBE, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBE, 0x03, 0xEF, 0xC1, 0xFB,
  0xDF, 0xFC, 0xF7, 0xFF, 0x3C, 0xFF, 0x8F, 0x1F, 0x83, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xE1, 0xFD, 0xFF,
  0xFF, 0x3F, 0xF7, 0xCF, 0xF9, 0xF0, 0xFC, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0x07, 0xB0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x7C, 0x07, 0x1F, 0x00, 0x87, 0xC0, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07,
  0xC8, 0x01, 0xF7, 0xC0, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xEF, 0x7F, 0xEF, 0x3F,
  0xCF, 0x1F, 0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xE3, 0xC0,
  0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x1F,
  0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00,
  0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0xF0, 0xF0, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1D, 0xE3,
  0xF0, 0xEF, 0x1F, 0x8F, 0x78, 0xFC, 0x7B, 0xC7, 0x63, 0xDE, 0x3B, 0x9E,
  0x71, 0x9C, 0xF3, 0x9C, 0xE7, 0x1E, 0xE7, 0x38, 0xF7, 0x39, 0xC7, 0xB9,
  0xCE, 0x3D, 0xC7, 0xF1, 0xEC, 0x3F, 0x87, 0x61, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x03, 0xF3, 0xE0, 0x7C, 0x3F, 0x07,
  0xC1, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0x7D, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x1F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC7,
  0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03,
  0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0,
  0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07,
  0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80,
  0x1F, 0x01, 0xC7, 0xF0, 0x3D, 0xFF, 0x07, 0x3F, 0xF1, 0xEF, 0x3F, 0x3D,
  0xE3, 0xFF, 0x38, 0x3F, 0xE7, 0x03, 0xF8, 0xE0, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 12, 12, 22, 5, -27 },
  { 39, 22, 26, 22, 0, -26 },
  { 111, 20, 34, 22, 1, -30 },
  { 196, 22, 26, 22, 0, -26 },
  { 268, 21, 26, 22, 1, -26 },
  { 337, 4, 12, 22, 9, -27 },
  { 343, 12, 33, 22, 7, -28 },
  { 393, 12, 33, 22, 3, -28 },
  { 443, 20, 19, 22, 1, -20 },
  { 491, 18, 18, 22, 2, -20 },
  { 532, 8, 11, 22, 7, -6 },
  { 543, 12, 4, 22, 5, -13 },
  { 549, 7, 7, 22, 8, -6 },
  { 556, 16, 33, 22, 3, -28 },
  { 622, 20, 26, 22, 1, -26 },
  { 687, 20, 26, 22, 1, -26 },
  { 752, 18, 26, 22, 2, -26 },
  { 811, 19, 26, 22, 1, -26 },
  { 873, 20, 26, 22, 1, -26 },
  { 938, 19, 26, 22, 2, -26 },
  { 1000, 19, 26, 22, 2, -26 },
  { 1062, 18, 26, 22, 2, -26 },
  { 1121, 19, 26, 22, 2, -26 },
  { 1183, 19, 26, 22, 2, -26 },
  { 1245, 7, 20, 22, 8, -19 },
  { 1263, 8, 24, 22, 7, -19 },
  { 1287, 16, 22, 22, 3, -22 },
  { 1331, 18, 12, 22, 2, -17 },
  { 1358, 16, 22, 22, 3, -22 },
  { 1402, 17, 26, 22, 2, -26 },
  { 1458, 18, 30, 22, 2, -26 },
  { 1526, 22, 26, 22, 0, -26 },
  { 1598, 17, 26, 22, 3, -26 },
  { 1654, 19, 26, 22, 2, -26 },
  { 1716, 18, 26, 22, 3, -26 },
  { 1775, 16, 26, 22, 3, -26 },
  { 1827, 17, 26, 22, 3, -26 },
  { 1883, 18, 26, 22, 2, -26 },
  { 1942, 18, 26, 22, 2, -26 },
  { 2001, 16, 26, 22, 3, -26 },
  { 2053, 17, 26, 22, 2, -26 },
  { 2109, 19, 26, 22, 3, -26 },
  { 2171, 16, 26, 22, 4, -26 },
  { 2223, 18, 26, 22, 2, -26 },
  { 2282, 18, 26, 22, 2, -26 },
  { 2341, 20, 26, 22, 1, -26 },
  { 2406, 18, 26, 22, 3, -26 },
  { 2465, 20, 33, 22, 1, -26 },
  { 2548, 18, 26, 22, 3, -26 },
  { 2607, 19, 26, 22, 1, -26 },
  { 2669, 20, 26, 22, 1, -26 },
  { 2734, 18, 26, 22, 2, -26 },
  { 2793, 21, 26, 22, 1, -26 },
  { 2862, 21, 26, 22, 1, -26 },
  { 2931, 21, 26, 22, 1, -26 },
  { 3000, 22, 26, 22, 0, -26 },
  { 3072, 18, 26, 22, 2, -26 },
  { 3131, 12, 33, 22, 7, -28 },
  { 3181, 16, 33, 22, 3, -28 },
  { 3247, 12, 33, 22, 3, -28 },
  { 3297, 20, 16, 22, 1, -26 },
  { 3337, 18, 4, 22, 2, 3 },
  { 3346, 7, 8, 22, 6, -29 },
  { 3353, 19, 19, 22, 2, -19 },
  { 3399, 18, 27, 22, 3, -27 },
  { 3460, 18, 19, 22, 2, -19 },
  { 3503, 18, 27, 22, 2, -27 },
  { 3564, 18, 19, 22, 2, -19 },
  { 3607, 18, 27, 22, 2, -27 },
  { 3668, 19, 30, 22, 2, -23 },
  { 3740, 17, 27, 22, 3, -27 },
  { 3798, 17, 29, 22, 4, -29 },
  { 3860, 14, 36, 22, 3, -29 },
  { 3923, 19, 27, 22, 3, -27 },
  { 3988, 17, 27, 22, 3, -27 },
  { 4046, 20, 19, 22, 1, -19 },
  { 4094, 17, 19, 22, 3, -19 },
  { 4135, 18, 19, 22, 2, -19 },
  { 4178, 18, 26, 22, 3, -19 },
  { 4237, 18, 26, 22, 2, -19 },
  { 4296, 18, 19, 22, 3, -19 },
  { 4339, 18, 19, 22, 2, -19 },
  { 4382, 18, 26, 22, 2, -26 },
  { 4441, 16, 19, 22, 3, -19 },
  { 4479, 20, 19, 22, 1, -19 },
  { 4527, 21, 19, 22, 1, -19 },
  { 4577, 20, 19, 22, 1, -19 },
  { 4625, 20, 26, 22, 1, -19 },
  { 4690, 17, 19, 22, 3, -19 },
  { 4731, 15, 33, 22, 4, -28 },
  { 4793, 4, 33, 22, 9, -28 },
  { 4810, 15, 33, 22, 4, -28 },
  { 4872, 19, 9, 22, 2, -16 },
};

const GFXfont IBMPlexMono_SemiBold37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_SEMIBOLD37PT7B_H_
