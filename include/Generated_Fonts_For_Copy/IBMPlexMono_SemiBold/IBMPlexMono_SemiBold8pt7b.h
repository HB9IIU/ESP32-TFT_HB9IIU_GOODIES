#ifndef _IBMPLEXMONO_SEMIBOLD8PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x32, 0xB6, 0xAE, 0x30, 0x73, 0xB8, 0x63, 0xF8,
  0x80, 0x4D, 0xB4, 0x26, 0xDC, 0x63, 0x91, 0xFB, 0x7C, 0xE0, 0x6A, 0x48,
  0x98, 0x95, 0x58, 0x27, 0xDC, 0xA0, 0x2F, 0x22, 0x70, 0xE0, 0x80, 0x25,
  0x25, 0x20, 0x62, 0xA5, 0x79, 0x38, 0x23, 0x28, 0x42, 0x3C, 0x6D, 0x13,
  0x4F, 0x69, 0x13, 0x97, 0x31, 0x95, 0x2F, 0x88, 0x74, 0x65, 0x97, 0x34,
  0x6D, 0x97, 0xF9, 0x12, 0x26, 0x65, 0xD7, 0x97, 0x6D, 0x97, 0x16, 0x90,
  0x41, 0xC0, 0x2E, 0x22, 0xF0, 0xF0, 0x98, 0xA8, 0xD4, 0xA0, 0x80, 0x69,
  0xBB, 0xB8, 0x70, 0x23, 0x14, 0xA7, 0x4C, 0xD6, 0xFB, 0xC0, 0x25, 0xCC,
  0x57, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x25, 0x8B,
  0xD7, 0xB6, 0xFB, 0x40, 0xE9, 0x25, 0xC0, 0x71, 0x11, 0x97, 0xBA, 0xCC,
  0xAB, 0x92, 0x49, 0xC0, 0xDD, 0xBB, 0xD9, 0xB7, 0xFF, 0x40, 0x62, 0xA5,
  0x3D, 0x38, 0xD6, 0xF9, 0x00, 0x62, 0xA5, 0x3D, 0x38, 0xC0, 0xCA, 0xAE,
  0xAB, 0x75, 0xC3, 0x1F, 0xF9, 0x08, 0x42, 0x10, 0xDD, 0xDD, 0x57, 0x8E,
  0x94, 0xA5, 0x10, 0x8C, 0x6B, 0xEF, 0x68, 0x9A, 0x98, 0x45, 0x6C, 0x8A,
  0x94, 0x42, 0x10, 0xF1, 0x22, 0x4F, 0xEA, 0xAC, 0x92, 0x24, 0x48, 0xD5,
  0x5C, 0x23, 0x15, 0x30, 0xF0, 0xC0, 0x70, 0xBC, 0xF0, 0x93, 0xDB, 0xC0,
  0xF2, 0x70, 0x11, 0x79, 0x97, 0x79, 0xE7, 0x6B, 0xA5, 0xC0, 0x13, 0x94,
  0xC7, 0x45, 0xC0, 0x93, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x63, 0x24, 0x96,
  0x88, 0xBC, 0xEB, 0xC9, 0x25, 0xC0, 0xF5, 0x6B, 0x50, 0xF6, 0xD0, 0x79,
  0x97, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xE9, 0x70, 0x76, 0x1F, 0x22,
  0xF2, 0x23, 0xB6, 0xF0, 0xDA, 0x94, 0x40, 0xAF, 0xBC, 0xA0, 0xD1, 0x19,
  0xB0, 0xDA, 0x98, 0x42, 0x20, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE, 0xCA,
  0x38, 0xB0, 0xF1,
};

const GFXglyph IBMPlexMono_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 7, 5, 0, -6 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 3, 5, 2, -6 },
  { 22, 3, 7, 5, 1, -6 },
  { 25, 2, 7, 5, 1, -6 },
  { 27, 5, 4, 5, 0, -4 },
  { 30, 4, 4, 5, 0, -4 },
  { 32, 2, 2, 5, 1, -1 },
  { 33, 3, 1, 5, 1, -3 },
  { 34, 1, 1, 5, 2, -1 },
  { 35, 3, 7, 5, 1, -6 },
  { 38, 5, 6, 5, 0, -6 },
  { 42, 5, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 4, 6, 5, 0, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 4, 6, 5, 0, -6 },
  { 65, 4, 6, 5, 0, -6 },
  { 68, 4, 6, 5, 0, -6 },
  { 71, 1, 4, 5, 2, -4 },
  { 72, 2, 5, 5, 1, -4 },
  { 74, 3, 5, 5, 1, -5 },
  { 76, 4, 3, 5, 0, -4 },
  { 78, 3, 5, 5, 1, -5 },
  { 80, 3, 6, 5, 1, -6 },
  { 83, 4, 7, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 4, 6, 5, 0, -6 },
  { 97, 3, 6, 5, 1, -6 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 4, 6, 5, 0, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 0, -6 },
  { 118, 4, 6, 5, 1, -6 },
  { 121, 3, 6, 5, 1, -6 },
  { 124, 4, 6, 5, 0, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 5, 7, 5, 0, -6 },
  { 142, 4, 6, 5, 1, -6 },
  { 145, 4, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 4, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 4, 6, 5, 0, -6 },
  { 174, 2, 7, 5, 2, -6 },
  { 176, 3, 7, 5, 1, -6 },
  { 179, 2, 7, 5, 1, -6 },
  { 181, 5, 4, 5, 0, -6 },
  { 184, 4, 1, 5, 0, 1 },
  { 185, 2, 1, 5, 1, -6 },
  { 186, 5, 4, 5, 0, -4 },
  { 189, 3, 6, 5, 1, -6 },
  { 192, 3, 4, 5, 1, -4 },
  { 194, 4, 6, 5, 0, -6 },
  { 197, 4, 4, 5, 0, -4 },
  { 199, 3, 6, 5, 1, -6 },
  { 202, 5, 7, 5, 0, -5 },
  { 207, 3, 6, 5, 1, -6 },
  { 210, 3, 6, 5, 1, -6 },
  { 213, 3, 8, 5, 1, -6 },
  { 216, 4, 6, 5, 1, -6 },
  { 219, 3, 6, 5, 1, -6 },
  { 222, 5, 4, 5, 0, -4 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 4, 4, 5, 0, -4 },
  { 229, 3, 6, 5, 1, -4 },
  { 232, 4, 6, 5, 0, -4 },
  { 235, 3, 4, 5, 1, -4 },
  { 237, 4, 4, 5, 0, -4 },
  { 239, 4, 6, 5, 0, -6 },
  { 242, 3, 4, 5, 1, -4 },
  { 244, 5, 4, 5, 0, -4 },
  { 247, 5, 4, 5, 0, -4 },
  { 250, 5, 4, 5, 0, -4 },
  { 253, 5, 6, 5, 0, -4 },
  { 257, 3, 4, 5, 1, -4 },
  { 259, 3, 7, 5, 1, -6 },
  { 262, 1, 7, 5, 2, -6 },
  { 263, 3, 7, 5, 1, -6 },
  { 266, 4, 2, 5, 0, -3 },
};

const GFXfont IBMPlexMono_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_SEMIBOLD8PT7B_H_
