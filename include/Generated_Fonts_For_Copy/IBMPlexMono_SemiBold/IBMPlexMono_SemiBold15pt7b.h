#ifndef _IBMPLEXMONO_SEMIBOLD15PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA4, 0x87, 0xFC, 0xDE, 0xF7, 0xBD, 0x80, 0x1B, 0x09, 0x04,
  0x8E, 0xF3, 0x61, 0xB3, 0xDC, 0x48, 0x24, 0x36, 0x00, 0x10, 0x21, 0xFE,
  0xBD, 0x1A, 0x1E, 0x0F, 0x12, 0x27, 0x5F, 0xE1, 0x02, 0x00, 0x71, 0xEC,
  0xB6, 0x9B, 0xC7, 0x00, 0x38, 0xF6, 0x5B, 0x4D, 0xE3, 0x80, 0x3C, 0x33,
  0x18, 0x0C, 0x03, 0x03, 0xDF, 0x29, 0x8C, 0xCB, 0x3D, 0xC0, 0xF8, 0x3B,
  0x11, 0x8C, 0x42, 0x10, 0xC6, 0x10, 0xC3, 0x80, 0xE1, 0x84, 0x31, 0x84,
  0x21, 0x18, 0xC4, 0x6E, 0x00, 0x10, 0x23, 0x5F, 0xF3, 0x8D, 0x9B, 0x65,
  0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xFB, 0x40, 0xF8, 0xFF, 0x80,
  0x06, 0x08, 0x30, 0x41, 0x83, 0x04, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x00,
  0x7D, 0x8F, 0x1E, 0x3D, 0x7A, 0xF1, 0xE3, 0xC6, 0xF8, 0x38, 0x78, 0xD8,
  0x98, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x7D, 0x8E, 0x18, 0x30, 0xC1,
  0x8C, 0x30, 0xC1, 0xFC, 0x3E, 0x63, 0x03, 0x03, 0x1C, 0x03, 0x03, 0x03,
  0x63, 0xFE, 0x0E, 0x07, 0x07, 0x86, 0xC3, 0x63, 0x33, 0x19, 0xFF, 0x06,
  0x03, 0x00, 0xFF, 0x83, 0x06, 0x0D, 0xDC, 0xC1, 0x83, 0xC6, 0xF8, 0x1C,
  0x61, 0x86, 0x0F, 0xD8, 0xF1, 0xE3, 0xC6, 0xF8, 0xFF, 0x8F, 0x18, 0x60,
  0xC3, 0x86, 0x0C, 0x30, 0xE0, 0x7D, 0x8F, 0x1E, 0x33, 0x98, 0xF1, 0xE3,
  0xC6, 0xF8, 0x7D, 0x8F, 0x1E, 0x3C, 0x6F, 0xC1, 0x86, 0x18, 0xE0, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x3E, 0xD0, 0x02, 0x1C, 0xF7, 0x8C, 0x1E, 0x0F,
  0x07, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0xC1, 0xE0, 0xF0, 0x63,
  0xDE, 0x70, 0x80, 0x7D, 0x8C, 0x18, 0x73, 0xC6, 0x00, 0x18, 0x38, 0x60,
  0x7C, 0x8F, 0x0C, 0xDB, 0x76, 0x6C, 0xD9, 0x9F, 0x81, 0x01, 0xE0, 0x1C,
  0x0E, 0x0D, 0x86, 0xC3, 0x61, 0x11, 0xFC, 0xC6, 0x63, 0x60, 0xC0, 0xFD,
  0x8F, 0x1E, 0x3F, 0x98, 0xF1, 0xE3, 0xC7, 0xF8, 0x3C, 0x8F, 0x16, 0x0C,
  0x18, 0x30, 0x62, 0x46, 0x78, 0xF9, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xF0, 0xFF, 0x83, 0x06, 0x0F, 0xF8, 0x30, 0x60, 0xC1, 0xFC, 0xFF,
  0x83, 0x06, 0x0F, 0xF8, 0x30, 0x60, 0xC1, 0x80, 0x7D, 0x8F, 0x16, 0x0C,
  0x1B, 0xF1, 0xE3, 0xC6, 0xFC, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8C, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x7E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xA3, 0xCC, 0xF0, 0xC7, 0xCE, 0xCC, 0xD8,
  0xF8, 0xF8, 0xEC, 0xCC, 0xC6, 0xC7, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xFC, 0xC7, 0xCF, 0xBD, 0x5B, 0xB2, 0x64, 0xC9, 0x83, 0x04,
  0xE7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x9C, 0x7D, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF8, 0xFD, 0x8F, 0x1E, 0x3C, 0x7F, 0xB0,
  0x60, 0xC1, 0x80, 0x7D, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF8,
  0x40, 0xF0, 0xFC, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0xCC, 0xCC, 0xC6, 0xC7,
  0x7D, 0x8F, 0x06, 0x07, 0x81, 0xC1, 0x83, 0xC7, 0xF8, 0xFF, 0x84, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF8, 0xE1, 0xB1, 0x98, 0xCC, 0x63, 0x21,
  0xB0, 0xD8, 0x6C, 0x1C, 0x0E, 0x00, 0xC1, 0xE0, 0xF3, 0x6B, 0xA5, 0x52,
  0xA9, 0x54, 0xAA, 0x77, 0x3B, 0x80, 0xE3, 0xB1, 0x8D, 0x87, 0xC1, 0xC0,
  0xE0, 0xD8, 0x6C, 0x63, 0x71, 0xC0, 0xE3, 0xB1, 0x8D, 0x86, 0xC1, 0xC0,
  0xE0, 0x20, 0x10, 0x08, 0x04, 0x00, 0xFE, 0x0C, 0x30, 0xE1, 0x86, 0x1C,
  0x30, 0xC1, 0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80,
  0xC0, 0x81, 0x81, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x1C, 0x0E, 0x0D,
  0x86, 0xC6, 0x33, 0x1B, 0x0A, 0xFE, 0xCC, 0x80, 0x79, 0x98, 0x1B, 0xFC,
  0x78, 0xF3, 0xBB, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0xF0, 0x3C, 0xCF, 0x06, 0x0C, 0x18, 0x19, 0x9E, 0x06, 0x0C, 0x1B, 0xBC,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8D, 0xF8, 0x3D, 0x8F, 0x1F, 0xFC, 0x18, 0xB1,
  0x9E, 0x1E, 0x20, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x63, 0xF8, 0x06,
  0x7C, 0xC4, 0xC6, 0xC6, 0x44, 0x78, 0xC0, 0x7E, 0x83, 0xC3, 0x7E, 0xC1,
  0x83, 0x06, 0xEE, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x18, 0x30, 0x07,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8, 0x1C, 0x70, 0x3F, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0B, 0xE0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xD8,
  0xF8, 0xF8, 0xCC, 0xCE, 0xC7, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x23, 0xF8, 0xB7, 0xB6, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xDD, 0xCF,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xBE,
  0xDD, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xFE, 0xC1, 0x83, 0x00, 0x77, 0x9F,
  0x1E, 0x3C, 0x78, 0xF1, 0xBF, 0x06, 0x0C, 0x18, 0xF6, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x7F, 0x7D, 0x8F, 0x03, 0xE1, 0xE0, 0xF1, 0xBE, 0x30, 0x63,
  0xF9, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x3C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xBF, 0xC7, 0x8F, 0x1B, 0x66, 0xCD, 0x8E, 0x1C, 0xC9, 0xEE, 0xD5,
  0x4A, 0xA5, 0x52, 0xA9, 0x54, 0xEE, 0xC6, 0xD9, 0xF1, 0xC3, 0x8D, 0x9B,
  0x63, 0xE3, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xA0, 0x70, 0x38, 0x18, 0x0C,
  0x1C, 0x00, 0xFE, 0x1C, 0x70, 0xC3, 0x0C, 0x38, 0x7F, 0x1E, 0x60, 0xC0,
  0x81, 0x83, 0x38, 0x0C, 0x18, 0x20, 0xC1, 0x81, 0xE0, 0xFF, 0xF8, 0xF0,
  0x30, 0x60, 0x83, 0x06, 0x03, 0x98, 0x30, 0x20, 0x60, 0xCF, 0x00, 0x63,
  0x26, 0x30,
};

const GFXglyph IBMPlexMono_SemiBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 5, 5, 9, 2, -11 },
  { 9, 9, 10, 9, 0, -10 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 9, 10, 9, 0, -10 },
  { 46, 9, 10, 9, 0, -10 },
  { 58, 1, 5, 9, 4, -11 },
  { 59, 5, 13, 9, 3, -11 },
  { 68, 5, 13, 9, 1, -11 },
  { 77, 7, 8, 9, 1, -8 },
  { 84, 7, 7, 9, 1, -8 },
  { 91, 3, 4, 9, 3, -2 },
  { 93, 5, 1, 9, 2, -5 },
  { 94, 3, 3, 9, 3, -3 },
  { 96, 7, 13, 9, 1, -11 },
  { 108, 7, 10, 9, 1, -10 },
  { 117, 8, 10, 9, 1, -10 },
  { 127, 7, 10, 9, 1, -10 },
  { 136, 8, 10, 9, 0, -10 },
  { 146, 9, 10, 9, 0, -10 },
  { 158, 7, 10, 9, 1, -10 },
  { 167, 7, 10, 9, 1, -10 },
  { 176, 7, 10, 9, 1, -10 },
  { 185, 7, 10, 9, 1, -10 },
  { 194, 7, 10, 9, 1, -10 },
  { 203, 3, 8, 9, 3, -8 },
  { 206, 3, 10, 9, 3, -8 },
  { 210, 7, 9, 9, 1, -9 },
  { 218, 7, 5, 9, 1, -7 },
  { 223, 7, 9, 9, 1, -9 },
  { 231, 7, 10, 9, 1, -10 },
  { 240, 7, 12, 9, 1, -10 },
  { 251, 9, 10, 9, 0, -10 },
  { 263, 7, 10, 9, 1, -10 },
  { 272, 7, 10, 9, 1, -10 },
  { 281, 7, 10, 9, 1, -10 },
  { 290, 7, 10, 9, 1, -10 },
  { 299, 7, 10, 9, 1, -10 },
  { 308, 7, 10, 9, 1, -10 },
  { 317, 7, 10, 9, 1, -10 },
  { 326, 7, 10, 9, 1, -10 },
  { 335, 7, 10, 9, 1, -10 },
  { 344, 8, 10, 9, 1, -10 },
  { 354, 7, 10, 9, 1, -10 },
  { 363, 7, 10, 9, 1, -10 },
  { 372, 7, 10, 9, 1, -10 },
  { 381, 7, 10, 9, 1, -10 },
  { 390, 7, 10, 9, 1, -10 },
  { 399, 7, 12, 9, 1, -10 },
  { 410, 8, 10, 9, 1, -10 },
  { 420, 7, 10, 9, 1, -10 },
  { 429, 9, 10, 9, 0, -10 },
  { 441, 7, 10, 9, 1, -10 },
  { 450, 9, 10, 9, 0, -10 },
  { 462, 9, 10, 9, 0, -10 },
  { 474, 9, 10, 9, 0, -10 },
  { 486, 9, 10, 9, 0, -10 },
  { 498, 7, 10, 9, 1, -10 },
  { 507, 5, 13, 9, 3, -11 },
  { 516, 7, 13, 9, 1, -11 },
  { 528, 5, 13, 9, 1, -11 },
  { 537, 9, 7, 9, 0, -10 },
  { 545, 7, 1, 9, 1, 1 },
  { 546, 3, 3, 9, 2, -12 },
  { 548, 7, 8, 9, 1, -8 },
  { 555, 7, 11, 9, 1, -11 },
  { 565, 7, 8, 9, 1, -8 },
  { 572, 7, 11, 9, 1, -11 },
  { 582, 7, 8, 9, 1, -8 },
  { 589, 7, 11, 9, 1, -11 },
  { 599, 8, 12, 9, 1, -9 },
  { 611, 7, 11, 9, 1, -11 },
  { 621, 7, 11, 9, 1, -11 },
  { 631, 6, 14, 9, 1, -11 },
  { 642, 8, 11, 9, 1, -11 },
  { 653, 7, 11, 9, 1, -11 },
  { 663, 7, 8, 9, 1, -8 },
  { 670, 7, 8, 9, 1, -8 },
  { 677, 7, 8, 9, 1, -8 },
  { 684, 7, 11, 9, 1, -8 },
  { 694, 7, 11, 9, 1, -8 },
  { 704, 7, 8, 9, 1, -8 },
  { 711, 7, 8, 9, 1, -8 },
  { 718, 7, 10, 9, 1, -10 },
  { 727, 7, 8, 9, 1, -8 },
  { 734, 7, 8, 9, 1, -8 },
  { 741, 9, 8, 9, 0, -8 },
  { 750, 7, 8, 9, 1, -8 },
  { 757, 9, 11, 9, 0, -8 },
  { 770, 7, 8, 9, 1, -8 },
  { 777, 7, 13, 9, 1, -11 },
  { 789, 1, 13, 9, 4, -11 },
  { 791, 7, 13, 9, 1, -11 },
  { 803, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_SemiBold15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_SEMIBOLD15PT7B_H_
