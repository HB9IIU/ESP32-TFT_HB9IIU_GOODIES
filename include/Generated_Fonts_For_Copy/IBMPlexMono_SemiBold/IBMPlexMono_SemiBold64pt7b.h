#ifndef _IBMPLEXMONO_SEMIBOLD64PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold64pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE7, 0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x03, 0xFF, 0xF9, 0xFF, 0xF8,
  0x1F, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF0,
  0x3F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F, 0xBF, 0xF0,
  0xFF, 0x87, 0xE3, 0xF8, 0x3F, 0xC1, 0xF8, 0x3C, 0x0F, 0xF0, 0x7E, 0x06,
  0x03, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0xC1, 0xF8,
  0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0x87,
  0xE0, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x9F,
  0xF8, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x00, 0x7E,
  0x0F, 0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x01,
  0xF8, 0x3F, 0xC1, 0x00, 0x7E, 0x0F, 0xF0, 0xE0, 0x1F, 0x83, 0xFC, 0x7E,
  0x07, 0xE1, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0x9F, 0xFE, 0x7E, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xF8, 0x00,
  0x3F, 0x87, 0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0xFE,
  0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x7F, 0x00, 0x7F, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x8F, 0xE0,
  0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x0F, 0xC7, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x1F, 0x87, 0xF0, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0xFE, 0x1F,
  0xC0, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x03, 0xFF, 0x82, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x38, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0x7F,
  0x83, 0xFF, 0x8F, 0xF3, 0xFE, 0x1F, 0x80, 0xFF, 0x0F, 0xF0, 0xFC, 0x07,
  0xF8, 0x3F, 0xC7, 0xE0, 0x3F, 0x80, 0xFF, 0x3F, 0x03, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xF8, 0x0F, 0xFE, 0x0F, 0xBF, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0x80,
  0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x20, 0x03, 0xF8, 0x01, 0x0F, 0x00,
  0xFE, 0x03, 0xE7, 0xF8, 0x3F, 0x87, 0xF9, 0xFF, 0xCF, 0xEF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x07, 0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x87, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x07,
  0xFC, 0x00, 0x0C, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0x7F, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x03, 0xFE, 0x02, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0x81,
  0xC0, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x00,
  0x00, 0x7F, 0xC3, 0x80, 0x00, 0x3F, 0xE3, 0xE0, 0x00, 0x3F, 0xF7, 0xF8,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xF8, 0x07, 0xF3,
  0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xFF, 0x81, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0x0F,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x00, 0x7F,
  0x83, 0x80, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0xE0, 0x0F, 0xF3, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFF,
  0x07, 0xF9, 0xFF, 0xFF, 0xC3, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xF8,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF8, 0x1F,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xFD,
  0xFE, 0x0F, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xE3,
  0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0,
  0xFF, 0xC3, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xDF,
  0xC0, 0x03, 0xFE, 0x3E, 0x00, 0x0F, 0xF0, 0x20, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0xFC, 0x3F, 0x7E, 0x01, 0xFE, 0x3F, 0x7E, 0x03,
  0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xBF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F,
  0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFE, 0x0F, 0xF9, 0xFF, 0x7E, 0x07, 0xFF, 0xBF, 0x7E, 0x07,
  0xFF, 0xBF, 0x7E, 0x03, 0xFF, 0x3F, 0x7E, 0x01, 0xFE, 0x3F, 0x7F, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x1F,
  0xFC, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x0F, 0xEB, 0xFE, 0x00, 0x03, 0x81, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x70,
  0x3F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F,
  0xF8, 0xFF, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0x1F, 0xE0, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFF, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0xFF, 0xCF, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFE,
  0xFE, 0x1F, 0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x87,
  0xF0, 0x1F, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x9F,
  0xE0, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x9F, 0xF8,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFD,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFE,
  0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0xFC, 0x1F,
  0xFF, 0xFE, 0xFE, 0x3F, 0x7F, 0xFE, 0xFE, 0x3F, 0x7F, 0xFE, 0x7F, 0x7F,
  0x7F, 0xFE, 0x7F, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFC, 0x7F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x0F, 0xF8, 0x7F, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xE0,
  0x7F, 0xFE, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xC0, 0x7F, 0xFE, 0x03, 0xC0,
  0x7F, 0xFE, 0x01, 0xC0, 0x7F, 0xFE, 0x01, 0x80, 0x7F, 0xFE, 0x00, 0x80,
  0x7F, 0xFE, 0x01, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x9F, 0xC0,
  0x7F, 0xFE, 0x7F, 0x81, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xE3, 0xF8, 0x1F,
  0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF,
  0xE0, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x7F, 0xFE, 0x0F, 0xE1, 0xFF, 0xF8,
  0x1F, 0xC7, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x81, 0xFE, 0x7F, 0xFE, 0x03,
  0xF9, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0x80, 0x7F,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF,
  0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x1E, 0x0F,
  0xF8, 0x00, 0x06, 0x07, 0xFC, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x84, 0x00,
  0x00, 0x3F, 0xC3, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x1F, 0xF3, 0xF8,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0x03, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x03,
  0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFE, 0x07, 0xE7,
  0xF0, 0x3F, 0xE0, 0x7E, 0x7F, 0x03, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xE0,
  0xFE, 0x7F, 0x07, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xE0, 0xFE, 0x7F, 0x07,
  0xFF, 0x0F, 0xE7, 0xF0, 0x7D, 0xF0, 0xFE, 0x3F, 0x87, 0xDF, 0x0F, 0xE3,
  0xF8, 0xFD, 0xF0, 0xFE, 0x3F, 0x8F, 0x9F, 0x0F, 0xE3, 0xF8, 0xF9, 0xF0,
  0xFE, 0x3F, 0x8F, 0x9F, 0x8F, 0xE3, 0xF8, 0xF9, 0xF8, 0xFE, 0x3F, 0x8F,
  0x8F, 0x8F, 0xC3, 0xF9, 0xF8, 0xF8, 0xFC, 0x3F, 0x9F, 0x8F, 0x8F, 0xC3,
  0xF9, 0xF0, 0xFC, 0xFC, 0x3F, 0x9F, 0x0F, 0xCF, 0xC3, 0xF9, 0xF0, 0xFC,
  0xFC, 0x3F, 0x9F, 0x07, 0xDF, 0xC3, 0xFB, 0xF0, 0x7D, 0xFC, 0x3F, 0xBF,
  0x07, 0xDF, 0xC1, 0xFB, 0xE0, 0x7F, 0xFC, 0x1F, 0xBE, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0xBF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF3, 0xE0, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x78, 0x0F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1E, 0x00,
  0x40, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x1F,
  0xF0, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0xF7, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x8F, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF,
  0xC0, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0x07, 0x07, 0xFC,
  0x00, 0x10, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0xFF, 0x00, 0x07, 0x03, 0xFE,
  0x00, 0x3F, 0x07, 0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFF, 0xF7, 0xF9, 0xFF,
  0xC0, 0xEF, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE,
  0x7F, 0xF0, 0x3B, 0xFC, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0x80,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x40, 0xFF, 0x00, 0x01, 0xC1, 0xFF, 0x00, 0x07, 0xC1,
  0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x03,
  0xFD, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x3F, 0xFC, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x3F, 0xFF, 0xC7, 0xF9, 0xFF,
  0xFF, 0x3F, 0xDF, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0x8F, 0xE7, 0xFC, 0x3F,
  0xF3, 0xF9, 0xFF, 0x9F, 0xFE, 0xFE, 0xFF, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xF8, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFE, 0x03,
  0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF8,
  0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F,
  0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0,
  0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE,
  0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x3F, 0xC7, 0xFF, 0xE1,
  0xFE, 0x7F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFE, 0x7F, 0xBF, 0xFF, 0xF3, 0xFF,
  0xC1, 0xFF, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x8F, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF, 0xBF, 0xFF,
  0xF8, 0xFF, 0xBF, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF,
  0xC0, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0x8F,
  0xF1, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xFF, 0xBF, 0xCF, 0xFE, 0x07, 0x7F,
  0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x81,
  0xDF, 0xE3, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xF8,
  0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xC0,
  0x3F, 0xCF, 0xFF, 0x80, 0x7F, 0xBC, 0x00, 0x00, 0xFF, 0x60, 0x00, 0x01,
  0xFE, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xF8, 0x1F, 0xE0, 0x00, 0x60, 0x7F, 0x80, 0x00, 0x80, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x01, 0xFE, 0x1C, 0x00, 0x03,
  0xFC, 0x7C, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE7, 0xFF, 0x00, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xDF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0x87, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xBF, 0x80, 0xFF,
  0x80, 0xFD, 0xFC, 0x07, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xE0, 0x7F, 0x3F,
  0x01, 0xFF, 0x03, 0xF9, 0xF8, 0x0F, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0xC0,
  0xFE, 0x7F, 0x07, 0xFE, 0x07, 0xE3, 0xF8, 0x3E, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF7, 0xC1, 0xF8, 0xFE, 0x0F, 0xBE, 0x0F, 0xC7, 0xF0, 0x79, 0xF0, 0x7E,
  0x1F, 0x87, 0xCF, 0x83, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x87, 0xE1, 0xF1,
  0xF1, 0xFC, 0x3F, 0x0F, 0x8F, 0x8F, 0xC1, 0xFC, 0x7C, 0x7C, 0x7E, 0x0F,
  0xE3, 0xC3, 0xE3, 0xF0, 0x7F, 0x3E, 0x1F, 0x1F, 0x81, 0xF9, 0xF0, 0xF8,
  0xFC, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0x7E, 0x7C, 0x1F, 0x3F, 0x03, 0xF3,
  0xE0, 0xFB, 0xF8, 0x1F, 0x9E, 0x07, 0xDF, 0x80, 0xFD, 0xF0, 0x3E, 0xFC,
  0x07, 0xFF, 0x81, 0xF7, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xC0,
  0x0F, 0xE3, 0xFF, 0xF0, 0x07, 0xE3, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF,
  0x01, 0xF9, 0xFC, 0x7F, 0x81, 0xFC, 0xFE, 0x1F, 0xE0, 0xFC, 0x7E, 0x07,
  0xF8, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0x1F, 0x80,
  0x3F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x70,
  0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 12, 46, 38, 13, -45 },
  { 70, 21, 20, 38, 9, -47 },
  { 123, 37, 45, 38, 1, -45 },
  { 332, 34, 60, 38, 2, -52 },
  { 587, 38, 46, 38, 0, -45 },
  { 806, 37, 46, 38, 1, -45 },
  { 1019, 8, 20, 38, 15, -47 },
  { 1039, 21, 58, 38, 12, -49 },
  { 1192, 22, 58, 38, 5, -49 },
  { 1352, 34, 32, 38, 2, -35 },
  { 1488, 30, 30, 38, 4, -35 },
  { 1601, 14, 19, 38, 12, -10 },
  { 1635, 20, 7, 38, 9, -22 },
  { 1653, 12, 12, 38, 13, -11 },
  { 1671, 28, 58, 38, 5, -49 },
  { 1874, 34, 46, 38, 2, -45 },
  { 2070, 34, 45, 38, 3, -45 },
  { 2262, 32, 45, 38, 3, -45 },
  { 2442, 33, 46, 38, 2, -45 },
  { 2632, 34, 45, 38, 2, -45 },
  { 2824, 33, 46, 38, 3, -45 },
  { 3014, 33, 46, 38, 3, -45 },
  { 3204, 31, 45, 38, 4, -45 },
  { 3379, 33, 46, 38, 3, -45 },
  { 3569, 32, 45, 38, 3, -45 },
  { 3749, 12, 35, 38, 13, -34 },
  { 3802, 14, 43, 38, 12, -34 },
  { 3878, 28, 38, 38, 5, -39 },
  { 4011, 30, 21, 38, 4, -30 },
  { 4090, 28, 38, 38, 5, -39 },
  { 4223, 29, 46, 38, 4, -45 },
  { 4390, 32, 52, 38, 3, -45 },
  { 4598, 37, 45, 38, 1, -45 },
  { 4807, 30, 45, 38, 5, -45 },
  { 4976, 33, 46, 38, 3, -45 },
  { 5166, 31, 45, 38, 5, -45 },
  { 5341, 29, 45, 38, 5, -45 },
  { 5505, 30, 45, 38, 5, -45 },
  { 5674, 31, 46, 38, 3, -45 },
  { 5853, 30, 45, 38, 4, -45 },
  { 6022, 28, 45, 38, 5, -45 },
  { 6180, 29, 46, 38, 3, -45 },
  { 6347, 33, 45, 38, 5, -45 },
  { 6533, 29, 45, 38, 6, -45 },
  { 6697, 32, 45, 38, 3, -45 },
  { 6877, 30, 45, 38, 4, -45 },
  { 7046, 34, 46, 38, 2, -45 },
  { 7242, 31, 45, 38, 5, -45 },
  { 7417, 34, 56, 38, 2, -45 },
  { 7655, 31, 45, 38, 5, -45 },
  { 7830, 33, 46, 38, 2, -45 },
  { 8020, 35, 45, 38, 2, -45 },
  { 8217, 30, 46, 38, 4, -45 },
  { 8390, 36, 45, 38, 1, -45 },
  { 8593, 36, 45, 38, 1, -45 },
  { 8796, 37, 45, 38, 1, -45 },
  { 9005, 37, 45, 38, 1, -45 },
  { 9214, 32, 45, 38, 3, -45 },
  { 9394, 20, 58, 38, 12, -49 },
  { 9539, 28, 58, 38, 5, -49 },
  { 9742, 20, 58, 38, 6, -49 },
  { 9887, 34, 28, 38, 2, -45 },
  { 10006, 31, 7, 38, 4, 5 },
  { 10034, 13, 14, 38, 10, -51 },
  { 10057, 32, 35, 38, 4, -34 },
  { 10197, 32, 48, 38, 4, -47 },
  { 10389, 30, 35, 38, 4, -34 },
  { 10521, 31, 48, 38, 3, -47 },
  { 10707, 31, 35, 38, 4, -34 },
  { 10843, 31, 47, 38, 4, -47 },
  { 11026, 34, 53, 38, 3, -39 },
  { 11252, 29, 47, 38, 5, -47 },
  { 11423, 29, 48, 38, 6, -48 },
  { 11597, 23, 61, 38, 6, -48 },
  { 11773, 32, 47, 38, 5, -47 },
  { 11961, 29, 47, 38, 5, -47 },
  { 12132, 34, 34, 38, 2, -34 },
  { 12277, 29, 34, 38, 5, -34 },
  { 12401, 32, 35, 38, 3, -34 },
  { 12541, 32, 47, 38, 4, -34 },
  { 12729, 31, 47, 38, 3, -34 },
  { 12912, 31, 33, 38, 5, -33 },
  { 13040, 31, 35, 38, 3, -34 },
  { 13176, 31, 45, 38, 3, -45 },
  { 13351, 30, 34, 38, 4, -33 },
  { 13479, 34, 33, 38, 2, -33 },
  { 13620, 37, 33, 38, 1, -33 },
  { 13773, 34, 33, 38, 2, -33 },
  { 13914, 35, 46, 38, 2, -33 },
  { 14116, 29, 33, 38, 5, -33 },
  { 14236, 26, 58, 38, 6, -49 },
  { 14425, 7, 58, 38, 16, -49 },
  { 14476, 26, 58, 38, 6, -49 },
  { 14665, 33, 15, 38, 3, -27 },
};

const GFXfont IBMPlexMono_SemiBold64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_SEMIBOLD64PT7B_H_
