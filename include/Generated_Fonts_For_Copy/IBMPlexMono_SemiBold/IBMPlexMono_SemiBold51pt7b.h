#ifndef _IBMPLEXMONO_SEMIBOLD51PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x1F, 0xFE, 0x0F, 0xFE, 0xFF, 0xF0, 0x7F,
  0xF7, 0xFF, 0x87, 0xFF, 0xBF, 0xFC, 0x3F, 0xFD, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x7F, 0xF0, 0x7F,
  0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0xFF, 0xE1, 0xFF, 0xE7,
  0xFF, 0x0F, 0xFF, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0xFF, 0x3D, 0xFE, 0x1F, 0x87, 0x87, 0x87, 0xF0, 0xF0, 0x60,
  0xFC, 0x1E, 0x08, 0x1F, 0x83, 0xC0, 0x03, 0xF0, 0x78, 0x00, 0x7E, 0x0F,
  0x00, 0x0F, 0xE1, 0xE0, 0x01, 0xFE, 0x3C, 0x00, 0x1F, 0xE7, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3D, 0xFF, 0x00,
  0x07, 0x8F, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x1E, 0x1F, 0xC0, 0x03, 0xC3,
  0xF8, 0x00, 0x78, 0x7F, 0x00, 0x0F, 0x0F, 0xE3, 0x01, 0xE1, 0xF8, 0xF0,
  0x3C, 0x3F, 0x3F, 0x07, 0x8F, 0xEF, 0xF8, 0xF7, 0xF9, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F,
  0xE0, 0x03, 0xF1, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0x80, 0x7E, 0x7E, 0x3E,
  0x01, 0xF1, 0xF0, 0x7C, 0x0F, 0xC7, 0xC1, 0xF0, 0x3E, 0x1E, 0x03, 0xC1,
  0xF8, 0x78, 0x0F, 0x07, 0xC1, 0xE0, 0x3C, 0x3F, 0x07, 0x80, 0xF0, 0xF8,
  0x1E, 0x03, 0xC7, 0xE0, 0x7C, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0xFC, 0x07,
  0xE3, 0xE3, 0xE0, 0x0F, 0xFF, 0x8F, 0x80, 0x1F, 0xFC, 0x40, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xE0, 0x1F, 0x9F, 0x0F, 0x80, 0x7C, 0x7C,
  0x1E, 0x03, 0xF1, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x3E, 0x07,
  0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF1,
  0xF0, 0x1E, 0x07, 0xC7, 0xC0, 0x7C, 0x1E, 0x3E, 0x01, 0xF0, 0xF8, 0xF8,
  0x03, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0x1F, 0x00, 0x1F, 0xF8, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x0C, 0x00, 0x1F, 0x80, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0x03, 0xFC, 0x3F,
  0xFC, 0x1F, 0xE3, 0xF7, 0xF0, 0xFF, 0x3F, 0x9F, 0xC7, 0xC1, 0xF8, 0x7E,
  0x7C, 0x1F, 0x83, 0xFB, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x3F, 0xF8,
  0x3F, 0x00, 0xFF, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x77, 0xF0, 0x7F, 0xFF,
  0x9F, 0xC1, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xC1, 0xFC, 0x1F, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x0F, 0xC0, 0x23, 0x81, 0xF8, 0x1E,
  0x7E, 0x3F, 0x1F, 0xDF, 0xFF, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0xF0, 0x7F, 0xFE,
  0x3F, 0x0F, 0xFF, 0xC7, 0xE1, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0x1F, 0x87,
  0xFF, 0xE1, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F,
  0x07, 0xF0, 0x03, 0xC0, 0xFE, 0x00, 0x30, 0x1F, 0xC0, 0x04, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x83, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xF0, 0x07, 0xF8, 0x78, 0x01, 0xFE, 0x0C,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x20, 0x00, 0x7F, 0x18, 0x00, 0x3F, 0xDF, 0x00, 0x0F, 0xEF, 0xE0,
  0x07, 0xFB, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x01,
  0xF1, 0xFF, 0xC0, 0xF9, 0xFF, 0xF8, 0x7C, 0xFF, 0xFE, 0x3E, 0xFF, 0xFF,
  0x1F, 0xE0, 0x7F, 0xCF, 0xE0, 0x1F, 0xF0, 0x40, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0x00, 0x07, 0xF1, 0x80, 0x03, 0xFB, 0xE0,
  0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xE7, 0xFF, 0x03, 0xF9, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFB, 0x83, 0xFE, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7E,
  0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x0F, 0xE7, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF8, 0x03, 0xFD, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x3F, 0xF3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0x7F, 0x0F, 0xFF, 0x9F, 0x81, 0xFF, 0xCF, 0xE0, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x1F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xDF, 0xE3, 0xF0, 0x1F, 0x83, 0xFC, 0x3F, 0xE7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0x1C, 0x00, 0x7E, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7,
  0xC0, 0x7C, 0x7D, 0xF0, 0x3F, 0x9F, 0x7C, 0x1F, 0xF7, 0xDF, 0x0F, 0xFF,
  0xF7, 0xC3, 0xF0, 0xFF, 0xF0, 0xF8, 0x1F, 0xF8, 0x7E, 0x07, 0xFE, 0x1F,
  0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE,
  0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07,
  0xFE, 0x0F, 0x81, 0xF7, 0xC3, 0xE0, 0xFD, 0xF0, 0xFE, 0xFF, 0x7C, 0x1F,
  0xF7, 0xDF, 0x07, 0xFD, 0xF7, 0xC0, 0xFE, 0x7D, 0xF0, 0x04, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF,
  0x07, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xBF, 0x80, 0x04, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x0F, 0xC0, 0x03, 0xE7, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xE3, 0xF0, 0x07,
  0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB,
  0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F,
  0xE3, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0x9F, 0xC0, 0x04, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFF, 0x00,
  0xFE, 0x7F, 0xC1, 0xFF, 0x1F, 0xFF, 0xDF, 0x87, 0xFF, 0xEF, 0xC1, 0xFF,
  0xE7, 0xE0, 0x7F, 0xE3, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x0E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xEF, 0xC0, 0x0F, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFE, 0x3F,
  0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0,
  0x3F, 0x07, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F,
  0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x0F, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x7C, 0x7D, 0xFF, 0xDF, 0x1F, 0x7F,
  0xF7, 0xC7, 0x9F, 0xFC, 0xFB, 0xE7, 0xFF, 0x3E, 0xFB, 0xFF, 0xCF, 0xFC,
  0xFF, 0xF1, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x0F, 0xE3, 0xFF, 0xC3,
  0xF8, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x1F, 0x0F, 0xFF, 0x07, 0xC3, 0xFF,
  0xC1, 0xE0, 0xFF, 0xF0, 0x38, 0x3F, 0xFC, 0x0E, 0x0F, 0xFF, 0x03, 0x03,
  0xFF, 0xC0, 0x40, 0xFF, 0xF0, 0x20, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFD, 0xF8, 0x3F, 0xFC, 0xF8, 0x3F,
  0xFC, 0xF8, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3F, 0x3F,
  0xFC, 0x1F, 0x3F, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F, 0xBF, 0xFC, 0x0F, 0xBF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF9,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xF8, 0x1F, 0xE3, 0xF8,
  0x01, 0xF1, 0xFC, 0x00, 0x18, 0x7F, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x18, 0x00,
  0x1F, 0xCF, 0x00, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xFF, 0x03, 0xFE, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x1F, 0xC1, 0xF3, 0xE0, 0xFE, 0x0F,
  0x9F, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x87, 0xE7, 0xC1, 0xFC, 0x3F, 0x3E,
  0x1F, 0xE1, 0xF9, 0xF0, 0xFF, 0x8F, 0xCF, 0xC7, 0xBC, 0x7E, 0x7E, 0x3D,
  0xE3, 0xF3, 0xF1, 0xEF, 0x1F, 0x9F, 0x8F, 0x78, 0xF8, 0xFC, 0xF3, 0xC7,
  0xC7, 0xE7, 0x9F, 0x3E, 0x3F, 0x3C, 0xF9, 0xF1, 0xF9, 0xE3, 0xCF, 0x8F,
  0xCF, 0x1E, 0x7C, 0x3E, 0x78, 0xF3, 0xE1, 0xF7, 0xC7, 0x9F, 0x0F, 0xBC,
  0x3E, 0xF8, 0x7D, 0xE1, 0xF7, 0xC3, 0xEF, 0x07, 0xBE, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x80,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0x70, 0x00, 0x0E, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0C, 0x07, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF,
  0x03, 0xC0, 0x1F, 0xC0, 0x60, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x37, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F,
  0xFE, 0x7F, 0xCF, 0xFF, 0x8F, 0xF1, 0xFF, 0xC1, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC,
  0xFF, 0x83, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFF, 0x83, 0xFE, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC,
  0xFC, 0xFF, 0xF8, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFF, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x38, 0x7F, 0x00, 0x20,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x10, 0x3F, 0x00, 0x3C,
  0x3F, 0x80, 0x3F, 0x1F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x7F,
  0xE1, 0xF8, 0x7F, 0xF8, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFF, 0xBF, 0x3F,
  0xE0, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x7F, 0xCF, 0xFF, 0xF7, 0xE3, 0xFF,
  0xF3, 0xF0, 0xFF, 0xF1, 0xF8, 0x3F, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x01, 0x07, 0xE0, 0x01, 0xC3, 0xF8, 0x01, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xFE, 0x1F, 0x8F, 0xFF, 0x3F,
  0x3F, 0xFE, 0x7E, 0xFF, 0xFE, 0xFD, 0x83, 0xFD, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xBF,
  0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0xFE, 0x1F, 0xE0, 0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xE0, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x03, 0xFC, 0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x78, 0x1F, 0x1F, 0x3F, 0x8F, 0xF3, 0xE7, 0xF9, 0xFF, 0x7D, 0xFF, 0x7F,
  0xEF, 0xBF, 0xEF, 0xFD, 0xF8, 0x7F, 0x1F, 0xBF, 0x0F, 0xC1, 0xFF, 0xC1,
  0xF8, 0x3F, 0xF8, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0xFF, 0xE0, 0x7C, 0x1F,
  0xFC, 0x0F, 0x83, 0xFF, 0x81, 0xF0, 0x7F, 0xF0, 0x3E, 0x0F, 0xFE, 0x07,
  0xC1, 0xFF, 0xC0, 0xF8, 0x3F, 0xF8, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0xFF,
  0xE0, 0x7C, 0x1F, 0xFC, 0x0F, 0x83, 0xFF, 0x81, 0xF0, 0x7F, 0xF0, 0x3E,
  0x0F, 0xFE, 0x07, 0xC1, 0xFF, 0xC0, 0xF8, 0x3F, 0xF8, 0x1F, 0x07, 0xFF,
  0x03, 0xE0, 0xFF, 0xE0, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x7F,
  0xC3, 0xF1, 0xFF, 0xE7, 0xE7, 0xFF, 0xCF, 0xDF, 0xFF, 0xDF, 0xB0, 0x7F,
  0xBF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xF8, 0x07, 0xF8,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x7F, 0xE0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0xFF,
  0x83, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFF, 0x83, 0xFE, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0xFC,
  0xFF, 0xF8, 0xFC, 0x7F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xC3, 0xFF, 0xC7, 0xE3, 0xFF, 0xF3, 0xF3,
  0xFF, 0xFD, 0xF9, 0xFF, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F,
  0xFF, 0xBF, 0x1F, 0xFF, 0x9F, 0x87, 0xFF, 0x8F, 0xC1, 0xFF, 0x87, 0xE0,
  0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xF8, 0x1F,
  0xDF, 0xFC, 0x0F, 0xEC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0x3C, 0x7F, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x10, 0x00, 0x3F, 0x38, 0x00, 0x3F, 0x7C, 0x00, 0x7F, 0xFF,
  0x81, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x7F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0x3F, 0xFC, 0xFE, 0x3F, 0xF1,
  0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0xFF,
  0xC0, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0x83, 0xEF, 0xC1,
  0xFC, 0x1F, 0x7E, 0x1F, 0xE0, 0xF9, 0xF0, 0xFF, 0x87, 0xCF, 0x87, 0xBC,
  0x3E, 0x7C, 0x3D, 0xE1, 0xF3, 0xE1, 0xEF, 0x0F, 0x9F, 0x0F, 0x78, 0x7C,
  0xF8, 0xF3, 0xC7, 0xC7, 0xE7, 0x9F, 0x3E, 0x3F, 0x3C, 0x79, 0xF0, 0xF9,
  0xE3, 0xCF, 0x87, 0xCF, 0x1E, 0x7C, 0x3E, 0x78, 0xF3, 0xE1, 0xF7, 0x87,
  0x9F, 0x0F, 0xBC, 0x3E, 0xF8, 0x7D, 0xE0, 0xF7, 0x83, 0xEF, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xCF, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFC, 0xFF,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x03,
  0x81, 0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x1F, 0x1F, 0xFF, 0x03, 0xE3, 0xFF,
  0xE0, 0x7C, 0xFC, 0xFE, 0x1F, 0x9F, 0x0F, 0xE3, 0xE3, 0xE0, 0xFF, 0xFC,
  0x7C, 0x0F, 0xFF, 0x1F, 0x00, 0xFF, 0xE3, 0xE0, 0x0F, 0xF8, 0x1C, 0x00,
  0xFC, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 37, 31, 11, -36 },
  { 43, 17, 16, 31, 7, -38 },
  { 77, 29, 36, 31, 1, -36 },
  { 208, 27, 47, 31, 2, -41 },
  { 367, 30, 37, 31, 0, -36 },
  { 506, 29, 37, 31, 1, -36 },
  { 641, 6, 16, 31, 12, -38 },
  { 653, 17, 46, 31, 9, -39 },
  { 751, 17, 46, 31, 4, -39 },
  { 849, 27, 26, 31, 2, -28 },
  { 937, 24, 25, 31, 3, -28 },
  { 1012, 12, 16, 31, 9, -8 },
  { 1036, 16, 6, 31, 7, -19 },
  { 1048, 10, 9, 31, 10, -9 },
  { 1060, 23, 46, 31, 4, -39 },
  { 1193, 27, 37, 31, 2, -36 },
  { 1318, 27, 36, 31, 2, -36 },
  { 1440, 26, 36, 31, 2, -36 },
  { 1557, 26, 37, 31, 2, -36 },
  { 1678, 28, 36, 31, 1, -36 },
  { 1804, 25, 37, 31, 3, -36 },
  { 1920, 27, 37, 31, 2, -36 },
  { 2045, 25, 36, 31, 3, -36 },
  { 2158, 26, 37, 31, 2, -36 },
  { 2279, 26, 36, 31, 2, -36 },
  { 2396, 10, 27, 31, 10, -27 },
  { 2430, 12, 35, 31, 9, -27 },
  { 2483, 22, 30, 31, 4, -31 },
  { 2566, 24, 17, 31, 3, -24 },
  { 2617, 22, 30, 31, 4, -31 },
  { 2700, 24, 37, 31, 3, -36 },
  { 2811, 26, 42, 31, 2, -36 },
  { 2948, 29, 36, 31, 1, -36 },
  { 3079, 24, 36, 31, 4, -36 },
  { 3187, 25, 37, 31, 3, -36 },
  { 3303, 25, 36, 31, 4, -36 },
  { 3416, 23, 36, 31, 4, -36 },
  { 3520, 23, 36, 31, 4, -36 },
  { 3624, 25, 37, 31, 2, -36 },
  { 3740, 24, 36, 31, 3, -36 },
  { 3848, 23, 36, 31, 4, -36 },
  { 3952, 24, 37, 31, 2, -36 },
  { 4063, 26, 36, 31, 4, -36 },
  { 4180, 23, 36, 31, 5, -36 },
  { 4284, 26, 36, 31, 2, -36 },
  { 4401, 24, 36, 31, 3, -36 },
  { 4509, 27, 37, 31, 2, -36 },
  { 4634, 24, 36, 31, 4, -36 },
  { 4742, 27, 45, 31, 2, -36 },
  { 4894, 25, 36, 31, 4, -36 },
  { 5007, 26, 37, 31, 2, -36 },
  { 5128, 28, 36, 31, 1, -36 },
  { 5254, 24, 37, 31, 3, -36 },
  { 5365, 29, 36, 31, 1, -36 },
  { 5496, 29, 36, 31, 1, -36 },
  { 5627, 29, 36, 31, 1, -36 },
  { 5758, 30, 36, 31, 0, -36 },
  { 5893, 26, 36, 31, 2, -36 },
  { 6010, 16, 46, 31, 10, -39 },
  { 6102, 23, 46, 31, 4, -39 },
  { 6235, 16, 46, 31, 5, -39 },
  { 6327, 27, 23, 31, 2, -36 },
  { 6405, 25, 5, 31, 3, 4 },
  { 6421, 11, 11, 31, 8, -40 },
  { 6437, 26, 28, 31, 3, -27 },
  { 6528, 24, 39, 31, 4, -38 },
  { 6645, 24, 28, 31, 3, -27 },
  { 6729, 25, 39, 31, 2, -38 },
  { 6851, 25, 28, 31, 3, -27 },
  { 6939, 25, 38, 31, 3, -38 },
  { 7058, 26, 42, 31, 3, -31 },
  { 7195, 23, 38, 31, 4, -38 },
  { 7305, 23, 39, 31, 5, -39 },
  { 7418, 18, 49, 31, 5, -39 },
  { 7529, 26, 38, 31, 4, -38 },
  { 7653, 23, 38, 31, 4, -38 },
  { 7763, 27, 27, 31, 2, -27 },
  { 7855, 23, 27, 31, 4, -27 },
  { 7933, 26, 28, 31, 2, -27 },
  { 8024, 24, 37, 31, 4, -27 },
  { 8135, 25, 37, 31, 2, -27 },
  { 8251, 25, 26, 31, 4, -26 },
  { 8333, 24, 28, 31, 3, -27 },
  { 8417, 25, 36, 31, 2, -36 },
  { 8530, 23, 27, 31, 4, -26 },
  { 8608, 27, 26, 31, 2, -26 },
  { 8696, 29, 26, 31, 1, -26 },
  { 8791, 27, 26, 31, 2, -26 },
  { 8879, 28, 36, 31, 1, -26 },
  { 9005, 23, 26, 31, 4, -26 },
  { 9080, 21, 46, 31, 5, -39 },
  { 9201, 6, 46, 31, 12, -39 },
  { 9236, 21, 46, 31, 5, -39 },
  { 9357, 27, 12, 31, 2, -22 },
};

const GFXfont IBMPlexMono_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_SEMIBOLD51PT7B_H_
