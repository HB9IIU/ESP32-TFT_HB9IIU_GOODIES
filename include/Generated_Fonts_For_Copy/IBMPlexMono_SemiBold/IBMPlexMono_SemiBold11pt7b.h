#ifndef _IBMPLEXMONO_SEMIBOLD11PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x4F, 0xB6, 0x80, 0x3C, 0xA6, 0xCA, 0x2B, 0xB5, 0x94, 0x11,
  0xF5, 0x94, 0x70, 0x71, 0x55, 0xF8, 0x40, 0x67, 0x4A, 0xE3, 0x00, 0xCE,
  0x95, 0x46, 0x70, 0xB1, 0x03, 0x07, 0xDB, 0x32, 0x3B, 0xE0, 0x34, 0xC8,
  0x88, 0x8C, 0x43, 0xC6, 0x22, 0x33, 0x22, 0x6C, 0x12, 0x5F, 0xCE, 0x69,
  0x30, 0x21, 0x3E, 0x42, 0x00, 0x7E, 0xE0, 0xF0, 0x18, 0x84, 0x42, 0x31,
  0x08, 0xC4, 0x00, 0x39, 0x34, 0x71, 0xD5, 0x54, 0xCE, 0x39, 0xED, 0x86,
  0x18, 0x61, 0x9F, 0x79, 0x38, 0xC3, 0x18, 0xC6, 0x1F, 0x79, 0x30, 0xCC,
  0x0C, 0x34, 0xFE, 0x18, 0xE2, 0x92, 0x4B, 0xF0, 0x82, 0xFC, 0x21, 0xE9,
  0x86, 0x7E, 0x18, 0x86, 0x1E, 0x4F, 0x14, 0xCE, 0xFC, 0xE6, 0x23, 0x11,
  0x8C, 0x79, 0x34, 0xCE, 0x4F, 0x14, 0xDE, 0x39, 0x3C, 0x53, 0x7C, 0x31,
  0x9C, 0xF0, 0xF0, 0xF0, 0x7E, 0x09, 0xF9, 0x0E, 0x1C, 0x20, 0xF8, 0x3E,
  0x86, 0x0C, 0x33, 0x62, 0x00, 0xF4, 0xC6, 0xE6, 0x01, 0x8C, 0x39, 0x15,
  0xDD, 0xF5, 0xD5, 0xD0, 0x38, 0x30, 0xE2, 0x9A, 0x4D, 0xF4, 0x71, 0xF4,
  0xE7, 0xE9, 0xC6, 0x7E, 0x74, 0xE1, 0x08, 0x42, 0x6E, 0xF4, 0xE3, 0x18,
  0xC6, 0x7E, 0xFC, 0x21, 0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10,
  0x39, 0x34, 0x30, 0xDD, 0x14, 0xDD, 0x9C, 0xE7, 0xF9, 0xCE, 0x73, 0xF9,
  0x08, 0x42, 0x10, 0x9F, 0xF8, 0xC6, 0x31, 0x8E, 0x5E, 0x9A, 0x4B, 0x38,
  0xF2, 0x49, 0xA3, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0x9E, 0xF7, 0xDA, 0xE6,
  0x31, 0xCE, 0x73, 0x5A, 0xD6, 0x73, 0x39, 0x34, 0x71, 0xC5, 0x14, 0xCE,
  0xF4, 0xE3, 0x3F, 0x42, 0x10, 0x39, 0x34, 0x71, 0xC5, 0x14, 0xCE, 0x10,
  0x70, 0xF4, 0xE3, 0x3F, 0x5A, 0x53, 0x39, 0x34, 0x1C, 0x1C, 0x14, 0xFE,
  0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x9C, 0xE7, 0x39, 0xCE, 0x7E, 0xC5,
  0x14, 0xDA, 0x68, 0xA3, 0x8C, 0x87, 0x1D, 0x7D, 0xF5, 0xB6, 0xDB, 0xC5,
  0xB2, 0x8C, 0x38, 0xA4, 0xF1, 0xC6, 0x99, 0xA1, 0x43, 0x02, 0x04, 0x08,
  0xF8, 0xCC, 0x46, 0x62, 0x1F, 0xF8, 0x88, 0x88, 0x88, 0x8F, 0x86, 0x10,
  0x86, 0x10, 0x82, 0x10, 0xC0, 0xE4, 0x92, 0x49, 0x3C, 0x30, 0xE6, 0x93,
  0xC4, 0xF8, 0x90, 0xF4, 0x87, 0xF9, 0xFC, 0x84, 0x2D, 0xB8, 0xC6, 0x7E,
  0x74, 0xE1, 0x09, 0x3C, 0x0C, 0x37, 0xD3, 0x4F, 0x34, 0xDF, 0x74, 0xFF,
  0x09, 0x3C, 0x39, 0x3E, 0x42, 0x10, 0x9F, 0x1B, 0xA7, 0x37, 0x41, 0xF1,
  0xF8, 0x84, 0x2D, 0xB9, 0xCE, 0x73, 0x21, 0x81, 0xC2, 0x10, 0x84, 0xF8,
  0x33, 0x0F, 0x33, 0x33, 0x33, 0xE0, 0x84, 0x27, 0x6E, 0x7A, 0x53, 0xE1,
  0x08, 0x42, 0x10, 0x9F, 0xFF, 0x5D, 0x75, 0xD7, 0x50, 0xB6, 0xE7, 0x39,
  0xCC, 0x74, 0xE3, 0x19, 0xB8, 0xB6, 0xE3, 0x19, 0xFA, 0x10, 0x7D, 0x34,
  0xF3, 0x4D, 0xF0, 0xC3, 0xFB, 0x18, 0xC6, 0x7C, 0x74, 0xFC, 0x79, 0xF8,
  0x30, 0xCF, 0xCC, 0x30, 0xC3, 0x0F, 0x9C, 0xE7, 0x39, 0xFC, 0xC5, 0x36,
  0x8A, 0x38, 0xC0, 0x96, 0xDF, 0x5B, 0x6D, 0xB0, 0xCC, 0xA3, 0x0E, 0x6B,
  0x30, 0xC5, 0x36, 0x8A, 0x30, 0x43, 0x18, 0xF8, 0x8C, 0xCC, 0x7C, 0x7A,
  0x08, 0x4C, 0x10, 0x8C, 0x41, 0xC0, 0xFF, 0xC0, 0xE1, 0x08, 0x83, 0xA1,
  0x84, 0x27, 0x00, 0x65, 0x5D, 0x80,
};

const GFXglyph IBMPlexMono_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 0, -9 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 7, 8, 7, 0, -8 },
  { 33, 1, 3, 7, 3, -8 },
  { 34, 4, 10, 7, 2, -8 },
  { 39, 4, 10, 7, 1, -8 },
  { 44, 6, 6, 7, 0, -6 },
  { 49, 5, 5, 7, 1, -6 },
  { 53, 2, 4, 7, 2, -2 },
  { 54, 3, 1, 7, 2, -4 },
  { 55, 2, 2, 7, 2, -2 },
  { 56, 5, 10, 7, 1, -8 },
  { 63, 6, 8, 7, 0, -8 },
  { 69, 6, 8, 7, 0, -8 },
  { 75, 6, 8, 7, 0, -8 },
  { 81, 6, 8, 7, 0, -8 },
  { 87, 6, 8, 7, 0, -8 },
  { 93, 5, 8, 7, 1, -8 },
  { 98, 6, 8, 7, 0, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 6, 8, 7, 0, -8 },
  { 115, 6, 8, 7, 0, -8 },
  { 121, 2, 6, 7, 2, -6 },
  { 123, 2, 8, 7, 2, -6 },
  { 125, 5, 7, 7, 1, -7 },
  { 130, 5, 3, 7, 1, -5 },
  { 132, 5, 7, 7, 1, -7 },
  { 137, 5, 8, 7, 1, -8 },
  { 142, 6, 9, 7, 0, -8 },
  { 149, 6, 8, 7, 0, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 6, 8, 7, 0, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 5, 8, 7, 1, -8 },
  { 201, 6, 8, 7, 1, -8 },
  { 207, 5, 8, 7, 1, -8 },
  { 212, 5, 8, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 6, 8, 7, 0, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 6, 10, 7, 0, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 6, 8, 7, 0, -8 },
  { 252, 6, 8, 7, 0, -8 },
  { 258, 5, 8, 7, 1, -8 },
  { 263, 6, 8, 7, 0, -8 },
  { 269, 6, 8, 7, 0, -8 },
  { 275, 6, 8, 7, 0, -8 },
  { 281, 7, 8, 7, 0, -8 },
  { 288, 5, 8, 7, 1, -8 },
  { 293, 4, 10, 7, 2, -8 },
  { 298, 5, 10, 7, 1, -8 },
  { 305, 3, 10, 7, 1, -8 },
  { 309, 6, 5, 7, 0, -8 },
  { 313, 5, 1, 7, 1, 1 },
  { 314, 2, 2, 7, 2, -9 },
  { 315, 5, 6, 7, 1, -6 },
  { 319, 5, 8, 7, 1, -8 },
  { 324, 5, 6, 7, 1, -6 },
  { 328, 6, 8, 7, 0, -8 },
  { 334, 5, 6, 7, 1, -6 },
  { 338, 5, 8, 7, 1, -8 },
  { 343, 5, 9, 7, 1, -7 },
  { 349, 5, 8, 7, 1, -8 },
  { 354, 5, 9, 7, 1, -9 },
  { 360, 4, 11, 7, 1, -9 },
  { 366, 5, 8, 7, 1, -8 },
  { 371, 5, 8, 7, 1, -8 },
  { 376, 6, 6, 7, 0, -6 },
  { 381, 5, 6, 7, 1, -6 },
  { 385, 5, 6, 7, 1, -6 },
  { 389, 5, 8, 7, 1, -6 },
  { 394, 6, 8, 7, 0, -6 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 5, 6, 7, 1, -6 },
  { 408, 6, 8, 7, 0, -8 },
  { 414, 5, 6, 7, 1, -6 },
  { 418, 6, 6, 7, 0, -6 },
  { 423, 6, 6, 7, 0, -6 },
  { 428, 6, 6, 7, 0, -6 },
  { 433, 6, 8, 7, 0, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 5, 10, 7, 1, -8 },
  { 450, 1, 10, 7, 3, -8 },
  { 452, 5, 10, 7, 1, -8 },
  { 459, 6, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_SEMIBOLD11PT7B_H_
