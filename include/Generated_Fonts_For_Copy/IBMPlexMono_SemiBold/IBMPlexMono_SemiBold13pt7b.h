#ifndef _IBMPLEXMONO_SEMIBOLD13PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA3, 0xC0, 0xBB, 0xBB, 0x16, 0x14, 0x34, 0x77, 0x2C, 0xEE,
  0x28, 0x68, 0x68, 0x18, 0x7D, 0xEA, 0xC7, 0x87, 0x87, 0x8D, 0x5F, 0xF8,
  0x60, 0x63, 0x96, 0x94, 0x98, 0x6E, 0x0B, 0x2B, 0x4B, 0xCE, 0x38, 0x6C,
  0x40, 0x60, 0x76, 0xDC, 0xCC, 0xCC, 0x73, 0xFF, 0x19, 0x18, 0x84, 0x63,
  0x08, 0x43, 0x08, 0x30, 0xC2, 0x31, 0x11, 0x11, 0x13, 0x2C, 0x18, 0x31,
  0xFD, 0xE3, 0xCC, 0x92, 0x80, 0x30, 0xC3, 0x3F, 0x30, 0xC0, 0x6D, 0x60,
  0xF0, 0xF0, 0x0C, 0x21, 0x86, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x3C,
  0xCD, 0x0A, 0xDD, 0xA8, 0x50, 0xB3, 0x3C, 0x73, 0x49, 0x24, 0x10, 0x41,
  0x04, 0xFC, 0x7B, 0x30, 0xC3, 0x18, 0xC6, 0x30, 0xFC, 0x3C, 0x8C, 0x18,
  0x31, 0x80, 0xC1, 0xA3, 0xFC, 0x0C, 0x38, 0xD1, 0x26, 0x58, 0xBF, 0x82,
  0x04, 0xFF, 0x08, 0x2E, 0xCC, 0x30, 0xE3, 0x78, 0x39, 0x8C, 0x3E, 0xCE,
  0x38, 0xF3, 0x78, 0xFE, 0x38, 0xC6, 0x18, 0x43, 0x0C, 0x60, 0x7B, 0x38,
  0xF3, 0x73, 0x38, 0xF3, 0x78, 0x7B, 0x38, 0xE3, 0xCD, 0xF0, 0x86, 0x70,
  0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x30, 0xC1, 0xC1, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0x83, 0x07, 0x1C, 0xCE, 0x20, 0x7B, 0x30, 0xC7,
  0x38, 0x80, 0x0C, 0x70, 0x7B, 0x38, 0x6F, 0xA6, 0x9A, 0x6F, 0xC1, 0xE0,
  0x18, 0x3C, 0x3C, 0x2C, 0x64, 0x7E, 0x46, 0x42, 0xC3, 0xFB, 0x3C, 0xF3,
  0xFB, 0x3C, 0xF3, 0xF8, 0x7B, 0x3C, 0x20, 0x82, 0x0C, 0x33, 0x78, 0xFB,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xF8, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC0, 0x7B, 0x38, 0x20, 0x9E,
  0x38, 0xF3, 0x7C, 0xCF, 0x3C, 0xF3, 0xFF, 0x3C, 0xF3, 0xCC, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xF2, 0x70,
  0xCF, 0x93, 0x67, 0x8F, 0x1B, 0x36, 0x66, 0xC6, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFC, 0xCF, 0x3F, 0xED, 0xB6, 0x9A, 0x61, 0x84, 0xCF, 0xBE,
  0xEB, 0xBE, 0x79, 0xE7, 0x8C, 0x3C, 0xCD, 0x1A, 0x1C, 0x28, 0x51, 0xB3,
  0x3C, 0xFB, 0x3C, 0xF3, 0xFB, 0x0C, 0x30, 0xC0, 0x3C, 0xCD, 0x1A, 0x1C,
  0x28, 0x51, 0xB3, 0x3C, 0x30, 0x38, 0xFB, 0x3C, 0xF3, 0xFB, 0x6D, 0xB3,
  0xCC, 0x3C, 0xC5, 0x83, 0x03, 0xC0, 0xC1, 0xA3, 0xFC, 0xFE, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x78,
  0xC3, 0x46, 0x66, 0x66, 0x64, 0x2C, 0x3C, 0x3C, 0x18, 0xC3, 0xC2, 0xDA,
  0xDA, 0x5A, 0x5A, 0x6A, 0x66, 0x66, 0xE6, 0x66, 0x3C, 0x38, 0x18, 0x3C,
  0x2C, 0x66, 0xC7, 0xC3, 0x66, 0x64, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18,
  0xFC, 0x31, 0x84, 0x31, 0x84, 0x30, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0xC1, 0x04, 0x18, 0x20, 0x83, 0x04, 0x18, 0x60, 0x83, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x1F, 0x18, 0x78, 0xB3, 0x34, 0x78, 0x40, 0xFC, 0x59,
  0x80, 0x7A, 0x20, 0xFF, 0x8E, 0x3F, 0xC0, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C,
  0xF3, 0xCF, 0xE0, 0x7B, 0x3C, 0x30, 0xC3, 0x37, 0x80, 0x0C, 0x30, 0xDF,
  0xCE, 0x38, 0xE3, 0xCD, 0xF0, 0x7B, 0x38, 0xFF, 0x83, 0x27, 0xC0, 0x1C,
  0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x0D, 0xEC, 0xF3, 0xC9, 0xE8,
  0x3F, 0x86, 0x1F, 0xC0, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3, 0xCF, 0x30,
  0x30, 0xC0, 0x3C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x18, 0xC1, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x3F, 0x00, 0xC1, 0x83, 0x06, 0x6D, 0x9E, 0x3C, 0x6C,
  0xCD, 0x9C, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0xF7, 0xB7,
  0x6E, 0xDD, 0xBB, 0x76, 0x80, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B,
  0x38, 0xE3, 0x8F, 0x37, 0x80, 0xFB, 0x3C, 0xF3, 0xCF, 0x3F, 0xB0, 0xC3,
  0x00, 0x7F, 0x38, 0xE3, 0x8F, 0x37, 0xC3, 0x0C, 0x30, 0xEC, 0xC3, 0x08,
  0x20, 0x8F, 0xC0, 0x7B, 0x3C, 0x1E, 0x0E, 0x37, 0x80, 0x20, 0x8F, 0xD8,
  0x61, 0x86, 0x08, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0xC0, 0xC6, 0xCD,
  0x91, 0x23, 0xC7, 0x06, 0x00, 0xDB, 0xDA, 0xDA, 0x5A, 0x6A, 0x66, 0x66,
  0x66, 0x58, 0xE0, 0xC3, 0xC5, 0xB9, 0x80, 0xC2, 0xCD, 0x91, 0x23, 0xC7,
  0x06, 0x0C, 0x10, 0xE0, 0xFC, 0x61, 0x8C, 0x63, 0x0F, 0xC0, 0x3C, 0x82,
  0x04, 0x13, 0x81, 0x04, 0x30, 0x82, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x43,
  0x08, 0x20, 0x72, 0x08, 0x30, 0x41, 0x3C, 0xE6, 0xD9, 0x80,
};

const GFXglyph IBMPlexMono_SemiBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 11, 8, 0, -10 },
  { 25, 8, 9, 8, 0, -9 },
  { 34, 8, 9, 8, 0, -9 },
  { 43, 2, 4, 8, 3, -10 },
  { 44, 5, 12, 8, 2, -10 },
  { 52, 4, 12, 8, 1, -10 },
  { 58, 7, 7, 8, 0, -7 },
  { 65, 6, 6, 8, 1, -7 },
  { 70, 3, 4, 8, 2, -2 },
  { 72, 4, 1, 8, 2, -4 },
  { 73, 2, 2, 8, 3, -2 },
  { 74, 6, 12, 8, 1, -10 },
  { 83, 7, 9, 8, 0, -9 },
  { 91, 6, 9, 8, 1, -9 },
  { 98, 6, 9, 8, 1, -9 },
  { 105, 7, 9, 8, 0, -9 },
  { 113, 7, 9, 8, 0, -9 },
  { 121, 6, 9, 8, 1, -9 },
  { 128, 6, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 9, 8, 1, -9 },
  { 149, 6, 9, 8, 1, -9 },
  { 156, 2, 7, 8, 3, -7 },
  { 158, 3, 9, 8, 2, -7 },
  { 162, 6, 8, 8, 1, -8 },
  { 168, 6, 4, 8, 1, -6 },
  { 171, 6, 8, 8, 1, -8 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 6, 10, 8, 1, -9 },
  { 192, 8, 9, 8, 0, -9 },
  { 201, 6, 9, 8, 1, -9 },
  { 208, 6, 9, 8, 1, -9 },
  { 215, 6, 9, 8, 1, -9 },
  { 222, 6, 9, 8, 1, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 6, 9, 8, 1, -9 },
  { 243, 6, 9, 8, 1, -9 },
  { 250, 6, 9, 8, 1, -9 },
  { 257, 6, 9, 8, 1, -9 },
  { 264, 7, 9, 8, 1, -9 },
  { 272, 6, 9, 8, 1, -9 },
  { 279, 6, 9, 8, 1, -9 },
  { 286, 6, 9, 8, 1, -9 },
  { 293, 7, 9, 8, 0, -9 },
  { 301, 6, 9, 8, 1, -9 },
  { 308, 7, 11, 8, 0, -9 },
  { 318, 6, 9, 8, 1, -9 },
  { 325, 7, 9, 8, 0, -9 },
  { 333, 7, 9, 8, 0, -9 },
  { 341, 6, 9, 8, 1, -9 },
  { 348, 8, 9, 8, 0, -9 },
  { 357, 8, 9, 8, 0, -9 },
  { 366, 8, 9, 8, 0, -9 },
  { 375, 8, 9, 8, 0, -9 },
  { 384, 6, 9, 8, 1, -9 },
  { 391, 4, 12, 8, 3, -10 },
  { 397, 6, 12, 8, 1, -10 },
  { 406, 4, 12, 8, 1, -10 },
  { 412, 7, 6, 8, 0, -9 },
  { 418, 6, 1, 8, 1, 1 },
  { 419, 3, 3, 8, 2, -11 },
  { 421, 6, 7, 8, 1, -7 },
  { 427, 6, 10, 8, 1, -10 },
  { 435, 6, 7, 8, 1, -7 },
  { 441, 6, 10, 8, 1, -10 },
  { 449, 6, 7, 8, 1, -7 },
  { 455, 6, 10, 8, 1, -10 },
  { 463, 6, 11, 8, 1, -8 },
  { 472, 6, 10, 8, 1, -10 },
  { 480, 6, 10, 8, 1, -10 },
  { 488, 5, 13, 8, 1, -10 },
  { 497, 7, 10, 8, 1, -10 },
  { 506, 6, 10, 8, 1, -10 },
  { 514, 7, 7, 8, 0, -7 },
  { 521, 6, 7, 8, 1, -7 },
  { 527, 6, 7, 8, 1, -7 },
  { 533, 6, 10, 8, 1, -7 },
  { 541, 6, 10, 8, 1, -7 },
  { 549, 6, 7, 8, 1, -7 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 6, 9, 8, 1, -9 },
  { 568, 6, 7, 8, 1, -7 },
  { 574, 7, 7, 8, 0, -7 },
  { 581, 8, 7, 8, 0, -7 },
  { 588, 7, 7, 8, 0, -7 },
  { 595, 7, 10, 8, 0, -7 },
  { 604, 6, 7, 8, 1, -7 },
  { 610, 6, 12, 8, 1, -10 },
  { 619, 2, 12, 8, 3, -10 },
  { 622, 6, 12, 8, 1, -10 },
  { 631, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_SemiBold13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_SEMIBOLD13PT7B_H_
