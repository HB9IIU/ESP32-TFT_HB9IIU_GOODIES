#ifndef _IBMPLEXMONO_SEMIBOLD18PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x92, 0x43, 0xFE, 0xEF, 0xBE, 0xFB, 0xEF, 0xB0, 0x0D,
  0x81, 0x30, 0x66, 0x0C, 0xC7, 0x9E, 0xF7, 0xC6, 0xC7, 0x9E, 0xF3, 0xC6,
  0x60, 0xC8, 0x1B, 0x03, 0x60, 0x08, 0x04, 0x0F, 0x8F, 0xFE, 0x96, 0x43,
  0xA0, 0xF8, 0x7F, 0x07, 0xC2, 0x71, 0x3C, 0xBF, 0xF8, 0xF8, 0x10, 0x08,
  0x00, 0x78, 0x6F, 0x1B, 0x36, 0x66, 0xCC, 0xF0, 0xF0, 0x1E, 0xE0, 0x3E,
  0x1E, 0x66, 0xCC, 0x99, 0xB3, 0xEC, 0x38, 0x1E, 0x07, 0xE1, 0xCC, 0x30,
  0x03, 0x00, 0x73, 0x8F, 0x73, 0x6C, 0xE7, 0x98, 0xF3, 0x8E, 0x3E, 0xC3,
  0xCE, 0xFF, 0xF0, 0x1C, 0x63, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x04, 0x18,
  0x60, 0xC1, 0x87, 0xE0, 0x60, 0x60, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x08,
  0x30, 0x60, 0xC3, 0x0C, 0x70, 0x18, 0x0C, 0x26, 0x3F, 0xF7, 0xF0, 0xE0,
  0xD8, 0xEE, 0x62, 0x00, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xF8, 0xC0, 0x60,
  0x30, 0x77, 0x66, 0xEC, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xE0,
  0x3E, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0xCF, 0x77, 0xB3, 0xC1, 0xE0, 0xF8,
  0xCF, 0xE3, 0xE0, 0x3C, 0x1E, 0x1F, 0x1D, 0x8C, 0xC4, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x0F, 0xF7, 0xF8, 0x3E, 0x3F, 0xB8, 0xC8, 0x70, 0x38,
  0x18, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x1F, 0xFF, 0xF8, 0x3E, 0x3F, 0xB0,
  0xC8, 0x70, 0x30, 0xF0, 0x78, 0x06, 0x03, 0xC1, 0xF0, 0xFF, 0xE3, 0xE0,
  0x07, 0x81, 0xE0, 0xF8, 0x6E, 0x1B, 0x8C, 0xE6, 0x39, 0x8E, 0xFF, 0xFF,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0x3F, 0x98, 0x08, 0x0D, 0xE6, 0xFB,
  0x8E, 0x07, 0x01, 0xA1, 0xF8, 0xEF, 0xE3, 0xE0, 0x0F, 0x0C, 0x0C, 0x0C,
  0x06, 0xE6, 0xFB, 0x8F, 0x83, 0xC1, 0xE0, 0xF8, 0xEF, 0xE3, 0xE0, 0xFF,
  0xFF, 0xF0, 0xF8, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03,
  0x03, 0x80, 0x3E, 0x3F, 0xB8, 0xF8, 0x7E, 0x31, 0xF1, 0xFD, 0xC7, 0xC1,
  0xE0, 0xF8, 0xEF, 0xE3, 0xE0, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x1F,
  0x8E, 0xFF, 0x3B, 0x03, 0x83, 0x83, 0x87, 0x80, 0xFF, 0x80, 0x3F, 0xE0,
  0x77, 0x70, 0x00, 0x77, 0x66, 0xEC, 0x02, 0x0C, 0x7B, 0xCE, 0x18, 0x38,
  0x3C, 0x1E, 0x0C, 0x08, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x81, 0x83,
  0xC1, 0xE0, 0xE0, 0xC3, 0x9E, 0xF1, 0x82, 0x00, 0x3C, 0x7F, 0xE3, 0x43,
  0x03, 0x07, 0x1E, 0x18, 0x18, 0x00, 0x18, 0x3C, 0x18, 0x3E, 0x3F, 0x98,
  0xD8, 0x3C, 0xFE, 0xFF, 0x67, 0xB3, 0xD9, 0xEF, 0xF3, 0xF8, 0x06, 0x03,
  0xF0, 0x78, 0x0E, 0x03, 0xC0, 0x7C, 0x0D, 0x81, 0xB0, 0x77, 0x0C, 0xE1,
  0x8C, 0x7F, 0x8F, 0xF9, 0x87, 0x30, 0x6E, 0x0E, 0xFE, 0x7F, 0xB8, 0xDC,
  0x7E, 0x37, 0xF3, 0xFD, 0xC7, 0xE1, 0xF0, 0xF8, 0xFF, 0xEF, 0xE0, 0x3E,
  0x3F, 0x98, 0xFC, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0xD8, 0xEF,
  0xE3, 0xE0, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF1, 0xF8, 0xDF, 0xEF, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0xFB, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E, 0x3F, 0xB8,
  0xD8, 0x7C, 0x06, 0x03, 0x3F, 0x9F, 0xC1, 0xF0, 0xF8, 0xEF, 0xB3, 0x98,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x38, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0xFF, 0xFF, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x43, 0xE7, 0x7E, 0x3C, 0xE1, 0xF8, 0xCE, 0x73, 0xB8, 0xEC, 0x3F,
  0x0F, 0xC3, 0xF8, 0xE6, 0x39, 0xCE, 0x33, 0x8E, 0xE1, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE3,
  0xF1, 0xFD, 0xFE, 0xFF, 0x5E, 0xEF, 0x77, 0x93, 0xC9, 0xE4, 0xF0, 0x78,
  0x3C, 0x18, 0xE1, 0xF8, 0xFC, 0x7E, 0x3D, 0x9E, 0xCF, 0x67, 0x9B, 0xCD,
  0xE7, 0xF1, 0xF8, 0xFC, 0x38, 0x3E, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFE, 0x7F, 0xB8, 0xFC,
  0x7E, 0x3F, 0x1F, 0xFD, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3E,
  0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF8, 0xCF,
  0xE3, 0xE0, 0xC0, 0x7C, 0x1E, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F,
  0xFD, 0xFC, 0xEE, 0x73, 0x39, 0xDC, 0x6E, 0x38, 0x3E, 0x3F, 0xF8, 0xD8,
  0x0E, 0x03, 0xE1, 0xFC, 0x1F, 0x03, 0xC0, 0xF0, 0xFF, 0xE3, 0xE0, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xF1, 0xF8, 0xCF, 0xE3, 0xE0, 0xE0, 0xEC, 0x19, 0x87, 0x38,
  0xE3, 0x18, 0x63, 0x0C, 0xE1, 0xDC, 0x1B, 0x03, 0x60, 0x6C, 0x0F, 0x00,
  0xE0, 0xC0, 0xF0, 0x3C, 0x0D, 0xBB, 0x6E, 0xDB, 0xB6, 0xAD, 0xAB, 0x7A,
  0xDE, 0xF7, 0xBD, 0xCF, 0x71, 0xC0, 0xE0, 0xCE, 0x38, 0xC6, 0x1D, 0x81,
  0xF0, 0x1C, 0x03, 0x80, 0xF8, 0x1B, 0x07, 0x70, 0xC6, 0x38, 0xEE, 0x0E,
  0xE0, 0xEC, 0x39, 0xC6, 0x18, 0xC3, 0xB0, 0x36, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xE1, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xFF, 0xE0, 0x60, 0x60, 0x30, 0x30,
  0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0xFF,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x1C, 0x1E, 0x0D,
  0x8E, 0xC6, 0x37, 0x1B, 0x07, 0x82, 0xFF, 0xFF, 0xC0, 0x4E, 0x63, 0x3E,
  0x3F, 0xB1, 0xC0, 0x67, 0xF7, 0xFB, 0x0D, 0xFF, 0x79, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0xFF, 0xEE,
  0xE0, 0x3E, 0x3F, 0x98, 0xDC, 0x0E, 0x07, 0x01, 0x8C, 0xFF, 0x3E, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x77, 0xBF, 0xFF, 0x8F, 0x87, 0xC3, 0xE1, 0xF8,
  0xEF, 0xF7, 0xB8, 0x3E, 0x3F, 0xB8, 0xDF, 0xFF, 0xFE, 0x03, 0x84, 0xFF,
  0x3E, 0x00, 0x0F, 0x8F, 0xC7, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0x03, 0x81, 0xCF, 0x8F, 0xEE, 0x37, 0x19,
  0xFC, 0xFC, 0x40, 0x3F, 0xBF, 0xE8, 0x3C, 0x1F, 0xFD, 0xFC, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0x8D, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x38, 0x18, 0x38, 0x18, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x1C, 0x71, 0xC0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xCE, 0xE3,
  0xE0, 0xFC, 0x3B, 0x8E, 0x73, 0x8C, 0xE3, 0xC0, 0xFC, 0x7E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0xFB,
  0xFF, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9, 0x80, 0xEE, 0x7F,
  0xB8, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x3E, 0x3F, 0xB8,
  0xF8, 0x3C, 0x1E, 0x0F, 0x8E, 0xFE, 0x3E, 0x00, 0xEE, 0x7F, 0xB8, 0xFC,
  0x3E, 0x1F, 0x0F, 0x8F, 0xFE, 0xEE, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x7B,
  0xFF, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x8E, 0xFF, 0x7B, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0xFB, 0xFD, 0xC7, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xFE, 0xFF,
  0x00, 0x3E, 0x3F, 0x98, 0x9F, 0xC7, 0xF0, 0x7D, 0x0F, 0xFE, 0x3E, 0x00,
  0x18, 0x0C, 0x06, 0x07, 0x0F, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0xF1, 0xF8, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3B,
  0xC1, 0xF1, 0xD8, 0xCC, 0x67, 0x61, 0xB0, 0xD8, 0x78, 0x1C, 0x00, 0xCE,
  0x79, 0xC9, 0x3B, 0x35, 0x66, 0xAC, 0xF5, 0x9E, 0xF3, 0x9E, 0x73, 0x80,
  0xE3, 0xBB, 0x8D, 0x87, 0x81, 0xC1, 0xF0, 0xD8, 0xCE, 0xC3, 0x80, 0xC1,
  0xF1, 0xD8, 0xCC, 0x67, 0x61, 0xB0, 0xD8, 0x38, 0x1C, 0x0C, 0x06, 0x1F,
  0x0F, 0x00, 0xFF, 0x7F, 0x81, 0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0xFF, 0xFF,
  0x80, 0x3E, 0x7C, 0xC1, 0x81, 0x03, 0x06, 0x7C, 0xF8, 0x30, 0x60, 0x83,
  0x06, 0x0F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x60, 0xC3, 0x06,
  0x0C, 0x1F, 0x3E, 0x60, 0xC1, 0x81, 0x83, 0x3E, 0x78, 0x71, 0xBC, 0xF7,
  0x79, 0xE8, 0x70,
};

const GFXglyph IBMPlexMono_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 6, 6, 11, 2, -13 },
  { 11, 11, 13, 11, 0, -13 },
  { 29, 9, 17, 11, 1, -15 },
  { 49, 11, 13, 11, 0, -13 },
  { 67, 11, 13, 11, 0, -13 },
  { 85, 2, 6, 11, 4, -13 },
  { 87, 6, 16, 11, 3, -14 },
  { 99, 7, 16, 11, 1, -14 },
  { 113, 9, 9, 11, 1, -10 },
  { 124, 9, 8, 11, 1, -10 },
  { 133, 4, 6, 11, 3, -3 },
  { 136, 5, 2, 11, 3, -6 },
  { 138, 3, 3, 11, 4, -3 },
  { 140, 8, 16, 11, 1, -14 },
  { 156, 9, 13, 11, 1, -13 },
  { 171, 9, 13, 11, 1, -13 },
  { 186, 9, 13, 11, 1, -13 },
  { 201, 9, 13, 11, 1, -13 },
  { 216, 10, 13, 11, 0, -13 },
  { 233, 9, 13, 11, 1, -13 },
  { 248, 9, 13, 11, 1, -13 },
  { 263, 9, 13, 11, 1, -13 },
  { 278, 9, 13, 11, 1, -13 },
  { 293, 9, 13, 11, 1, -13 },
  { 308, 3, 9, 11, 4, -9 },
  { 312, 4, 12, 11, 3, -9 },
  { 318, 7, 11, 11, 2, -11 },
  { 328, 9, 5, 11, 1, -8 },
  { 334, 7, 11, 11, 2, -11 },
  { 344, 8, 13, 11, 1, -13 },
  { 357, 9, 15, 11, 1, -13 },
  { 374, 11, 13, 11, 0, -13 },
  { 392, 9, 13, 11, 1, -13 },
  { 407, 9, 13, 11, 1, -13 },
  { 422, 9, 13, 11, 1, -13 },
  { 437, 8, 13, 11, 1, -13 },
  { 450, 9, 13, 11, 1, -13 },
  { 465, 9, 13, 11, 1, -13 },
  { 480, 9, 13, 11, 1, -13 },
  { 495, 8, 13, 11, 1, -13 },
  { 508, 8, 13, 11, 1, -13 },
  { 521, 10, 13, 11, 1, -13 },
  { 538, 8, 13, 11, 2, -13 },
  { 551, 9, 13, 11, 1, -13 },
  { 566, 9, 13, 11, 1, -13 },
  { 581, 9, 13, 11, 1, -13 },
  { 596, 9, 13, 11, 1, -13 },
  { 611, 9, 16, 11, 1, -13 },
  { 629, 9, 13, 11, 1, -13 },
  { 644, 9, 13, 11, 1, -13 },
  { 659, 10, 13, 11, 0, -13 },
  { 676, 9, 13, 11, 1, -13 },
  { 691, 11, 13, 11, 0, -13 },
  { 709, 10, 13, 11, 0, -13 },
  { 726, 11, 13, 11, 0, -13 },
  { 744, 11, 13, 11, 0, -13 },
  { 762, 9, 13, 11, 1, -13 },
  { 777, 5, 16, 11, 4, -14 },
  { 787, 8, 16, 11, 1, -14 },
  { 803, 5, 16, 11, 2, -14 },
  { 813, 9, 8, 11, 1, -13 },
  { 822, 9, 2, 11, 1, 1 },
  { 825, 4, 4, 11, 3, -14 },
  { 827, 9, 9, 11, 1, -9 },
  { 838, 9, 13, 11, 1, -13 },
  { 853, 9, 9, 11, 1, -9 },
  { 864, 9, 13, 11, 1, -13 },
  { 879, 9, 9, 11, 1, -9 },
  { 890, 9, 13, 11, 1, -13 },
  { 905, 9, 15, 11, 1, -11 },
  { 922, 9, 13, 11, 1, -13 },
  { 937, 8, 13, 11, 2, -13 },
  { 950, 6, 17, 11, 2, -13 },
  { 963, 10, 13, 11, 1, -13 },
  { 980, 9, 13, 11, 1, -13 },
  { 995, 9, 9, 11, 1, -9 },
  { 1006, 9, 9, 11, 1, -9 },
  { 1017, 9, 9, 11, 1, -9 },
  { 1028, 9, 13, 11, 1, -9 },
  { 1043, 9, 13, 11, 1, -9 },
  { 1058, 9, 9, 11, 1, -9 },
  { 1069, 9, 9, 11, 1, -9 },
  { 1080, 9, 13, 11, 1, -13 },
  { 1095, 8, 9, 11, 1, -9 },
  { 1104, 9, 9, 11, 1, -9 },
  { 1115, 11, 9, 11, 0, -9 },
  { 1128, 9, 9, 11, 1, -9 },
  { 1139, 9, 13, 11, 1, -9 },
  { 1154, 9, 9, 11, 1, -9 },
  { 1165, 7, 16, 11, 2, -14 },
  { 1179, 2, 16, 11, 4, -14 },
  { 1183, 7, 16, 11, 2, -14 },
  { 1197, 9, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_SEMIBOLD18PT7B_H_
