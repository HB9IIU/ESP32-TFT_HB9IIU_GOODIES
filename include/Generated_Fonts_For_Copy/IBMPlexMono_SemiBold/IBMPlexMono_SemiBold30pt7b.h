#ifndef _IBMPLEXMONO_SEMIBOLD30PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xC3, 0x0C, 0x30, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0x78, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x9C, 0x01, 0xE7, 0x07, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F,
  0x1F, 0xC1, 0xCF, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0xFE, 0x3F, 0xBF, 0x8F,
  0xEF, 0xE3, 0xF8, 0x39, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7D, 0xDE, 0x79, 0xCC, 0x71, 0xC0, 0x79,
  0xC0, 0x79, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x01,
  0xDE, 0x01, 0xCF, 0x01, 0xCF, 0x61, 0xCF, 0x71, 0xCF, 0xF9, 0xDE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1E,
  0x03, 0xCF, 0xC0, 0xE7, 0xF8, 0x79, 0xCE, 0x1C, 0xE1, 0xCF, 0x38, 0x73,
  0x8E, 0x1D, 0xC1, 0xCE, 0x70, 0x7F, 0xB8, 0x0F, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xFC, 0x07, 0x7F, 0x83, 0x9C, 0xE0, 0xEE, 0x1C, 0x73, 0x87, 0x3C,
  0xE1, 0xCE, 0x1C, 0xE7, 0x87, 0xF9, 0xC0, 0xFC, 0xF0, 0x1E, 0x00, 0x0F,
  0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0x0E, 0x07, 0x86, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x0F, 0x8F, 0xC7, 0xCF, 0xF3,
  0xEF, 0x3D, 0xC7, 0x1E, 0xE3, 0x87, 0xF1, 0xC1, 0xF0, 0xE0, 0x78, 0x78,
  0x7E, 0x3F, 0xF7, 0x8F, 0xF3, 0xE1, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x63, 0xC6, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x08, 0x10, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0x8F, 0x1C, 0x38, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF1, 0x8F,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3D, 0xE0, 0x79, 0xE0,
  0xF9, 0xE0, 0x71, 0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x7C, 0xF8, 0x3E, 0x30, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1, 0xF3, 0x03, 0xE4, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x90, 0x0F, 0x70, 0x1F, 0xF0, 0x7D, 0xFF, 0xF1,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xB8, 0x07, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x3C, 0x38,
  0x38, 0x38, 0x78, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x79,
  0xF0, 0xF7, 0xF9, 0xDF, 0xF3, 0xE1, 0xF0, 0x81, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x90, 0x1F, 0x60, 0x3D, 0xF0, 0xFB, 0xFF, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x39, 0xF0, 0x7B, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0xF8, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x7C, 0x3E, 0x78,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0x7C,
  0x3E, 0x7F, 0xFE, 0x3F, 0xDE, 0x0F, 0x9C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7B, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x3C, 0xFD, 0xFB,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xE7, 0x9F, 0x3C, 0x78,
  0xE1, 0xC7, 0x80, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xF0, 0x0F, 0x03, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0x00,
  0xC0, 0x08, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE, 0x1E, 0xF0, 0x7C,
  0x80, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE0, 0xF7,
  0x80, 0xEE, 0x01, 0xDC, 0x3B, 0xB8, 0xFF, 0xE3, 0xFF, 0xC7, 0x1F, 0x8E,
  0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xB1, 0xFF, 0x73, 0xFE,
  0xE3, 0xDD, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x87, 0x01,
  0xE1, 0xE0, 0x78, 0x78, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0,
  0x3C, 0x38, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x07,
  0xC0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xCF,
  0x03, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0, 0x7B, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E,
  0x3E, 0x7C, 0x1E, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x0E, 0x7C, 0x1F, 0x3E, 0x3E, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1,
  0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78,
  0x1E, 0xF8, 0x7C, 0xFF, 0xB8, 0xFE, 0x70, 0xF8, 0xE0, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xCC, 0x0F, 0xF8, 0x3D, 0xF1, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0,
  0xF0, 0x1F, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0,
  0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFD, 0xE0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C,
  0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF1, 0x8F, 0xF1, 0x8F, 0xF1,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7E, 0xE1, 0xFB,
  0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x79, 0xF8, 0xE7, 0xE3, 0x9F, 0x8F, 0x7E,
  0x1D, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7C,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0,
  0x7B, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFE, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF9, 0xE0, 0xF3,
  0xC1, 0xF7, 0x81, 0xEF, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x1E, 0x78, 0x0C, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x20, 0x0F, 0x70, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xE7, 0xE7, 0xE7, 0xF7, 0xE7, 0xF7,
  0xE7, 0xF6, 0x6F, 0xF6, 0x6F, 0x76, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x07, 0x8F, 0x03, 0xC3,
  0xE0, 0xF0, 0x78, 0x78, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x1E, 0x0F, 0x87, 0xC3,
  0xC0, 0xF1, 0xE0, 0x3E, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xDE, 0x01, 0xE3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E,
  0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70,
  0x0E, 0xF0, 0x0F, 0x60, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x21,
  0xCF, 0x1E, 0x38, 0xF1, 0x80, 0x1F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC7, 0x87,
  0xC2, 0x07, 0x80, 0x0F, 0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0, 0xF3,
  0x81, 0xE7, 0x87, 0xCF, 0xFB, 0xEF, 0xF7, 0xCF, 0x87, 0x80, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79,
  0xF0, 0xF7, 0xF9, 0xFF, 0xF3, 0xE1, 0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xE1, 0xF7, 0xFF, 0xEF,
  0x7F, 0x9E, 0x7C, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0xF8,
  0x33, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x01, 0x9E,
  0x0F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xCF, 0x3F, 0xDE,
  0xFF, 0xFD, 0xF0, 0xFB, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB, 0xFF, 0xF3, 0xFD, 0xE1, 0xF3,
  0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x04, 0x7F, 0xFC,
  0xFF, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x7F, 0x03, 0xFF, 0x0F, 0xFF, 0x1E, 0x1E, 0x78,
  0x1C, 0xF0, 0x39, 0xF0, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x06, 0x00,
  0x1C, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFD, 0x80, 0x7F, 0x00, 0x7E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xF7, 0xFB, 0xFF,
  0xEF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7B, 0xFF, 0x7F, 0xCF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0,
  0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x1C, 0xEF, 0xBE, 0xEF, 0xFF,
  0xF3, 0xCF, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xF3, 0xE3, 0xDF, 0xEF, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78,
  0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF3, 0xE1, 0xEF,
  0xF3, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0xC3, 0xEF, 0xFF, 0xDE, 0xFF, 0x3C,
  0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x0F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xE1, 0xF7, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x7B, 0xE1, 0xF7,
  0xFF, 0xE7, 0xFB, 0xC3, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0x1F, 0xFE, 0x7F, 0xFD, 0xF8, 0x7A,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0xE7, 0xFF, 0xDE, 0x0E, 0xF0, 0x11, 0xE0, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xF4, 0x03, 0xFC, 0x1F, 0xFF, 0xF9, 0xFF, 0xC1, 0xFC,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x1F, 0x7F, 0xFD, 0xFE, 0xF1, 0xF3, 0xC0, 0xF0, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x38,
  0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xF1, 0xE3, 0xDC, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x8E, 0x71,
  0xF3, 0x9C, 0xFC, 0xE7, 0x33, 0x39, 0xCC, 0xCE, 0x3B, 0x33, 0x0E, 0xCD,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x1F, 0x7C, 0x3E, 0x3E, 0x3C, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78,
  0x3C, 0x3C, 0x78, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x78, 0xFF, 0x0F, 0xC0,
  0xFF, 0x00, 0x78, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0x0F, 0xF1, 0xE0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0xFF, 0x8F,
  0xF0, 0xFE, 0x00, 0x1E, 0x07, 0x3F, 0x07, 0x7F, 0x8E, 0x73, 0xCE, 0x71,
  0xFE, 0xE0, 0xFC, 0xE0, 0x78,
};

const GFXglyph IBMPlexMono_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 21, 18, 6, -21 },
  { 17, 10, 9, 18, 4, -22 },
  { 29, 18, 21, 18, 0, -21 },
  { 77, 16, 27, 18, 1, -24 },
  { 131, 18, 21, 18, 0, -21 },
  { 179, 17, 21, 18, 1, -21 },
  { 224, 4, 9, 18, 7, -22 },
  { 229, 11, 27, 18, 5, -23 },
  { 267, 11, 27, 18, 2, -23 },
  { 305, 16, 15, 18, 1, -16 },
  { 335, 14, 15, 18, 2, -17 },
  { 362, 7, 9, 18, 5, -5 },
  { 370, 10, 3, 18, 4, -11 },
  { 374, 6, 5, 18, 6, -5 },
  { 378, 14, 27, 18, 2, -23 },
  { 426, 16, 21, 18, 1, -21 },
  { 468, 16, 21, 18, 1, -21 },
  { 510, 16, 21, 18, 1, -21 },
  { 552, 15, 21, 18, 1, -21 },
  { 592, 16, 21, 18, 1, -21 },
  { 634, 15, 21, 18, 2, -21 },
  { 674, 16, 21, 18, 1, -21 },
  { 716, 14, 21, 18, 2, -21 },
  { 753, 16, 21, 18, 1, -21 },
  { 795, 16, 21, 18, 1, -21 },
  { 837, 6, 16, 18, 6, -16 },
  { 849, 7, 20, 18, 5, -16 },
  { 867, 12, 18, 18, 3, -18 },
  { 894, 14, 10, 18, 2, -14 },
  { 912, 12, 18, 18, 3, -18 },
  { 939, 14, 21, 18, 2, -21 },
  { 976, 15, 24, 18, 1, -21 },
  { 1021, 18, 21, 18, 0, -21 },
  { 1069, 15, 21, 18, 2, -21 },
  { 1109, 16, 21, 18, 1, -21 },
  { 1151, 15, 21, 18, 2, -21 },
  { 1191, 14, 21, 18, 2, -21 },
  { 1228, 14, 21, 18, 2, -21 },
  { 1265, 15, 21, 18, 1, -21 },
  { 1305, 14, 21, 18, 2, -21 },
  { 1342, 14, 21, 18, 2, -21 },
  { 1379, 14, 21, 18, 1, -21 },
  { 1416, 16, 21, 18, 2, -21 },
  { 1458, 13, 21, 18, 3, -21 },
  { 1493, 16, 21, 18, 1, -21 },
  { 1535, 14, 21, 18, 2, -21 },
  { 1572, 16, 21, 18, 1, -21 },
  { 1614, 15, 21, 18, 2, -21 },
  { 1654, 16, 26, 18, 1, -21 },
  { 1706, 15, 21, 18, 2, -21 },
  { 1746, 16, 21, 18, 1, -21 },
  { 1788, 16, 21, 18, 1, -21 },
  { 1830, 14, 21, 18, 2, -21 },
  { 1867, 16, 21, 18, 1, -21 },
  { 1909, 16, 21, 18, 1, -21 },
  { 1951, 18, 21, 18, 0, -21 },
  { 1999, 18, 21, 18, 0, -21 },
  { 2047, 16, 21, 18, 1, -21 },
  { 2089, 9, 27, 18, 6, -23 },
  { 2120, 14, 27, 18, 2, -23 },
  { 2168, 9, 27, 18, 3, -23 },
  { 2199, 16, 13, 18, 1, -21 },
  { 2225, 14, 3, 18, 2, 2 },
  { 2231, 6, 7, 18, 5, -24 },
  { 2237, 15, 15, 18, 2, -15 },
  { 2266, 15, 22, 18, 2, -22 },
  { 2308, 14, 15, 18, 2, -15 },
  { 2335, 15, 22, 18, 1, -22 },
  { 2377, 14, 15, 18, 2, -15 },
  { 2404, 15, 22, 18, 2, -22 },
  { 2446, 15, 24, 18, 2, -18 },
  { 2491, 14, 22, 18, 2, -22 },
  { 2530, 14, 23, 18, 3, -23 },
  { 2571, 11, 29, 18, 3, -23 },
  { 2611, 16, 22, 18, 2, -22 },
  { 2655, 14, 22, 18, 2, -22 },
  { 2694, 16, 15, 18, 1, -15 },
  { 2724, 14, 15, 18, 2, -15 },
  { 2751, 16, 15, 18, 1, -15 },
  { 2781, 15, 21, 18, 2, -15 },
  { 2821, 15, 21, 18, 1, -15 },
  { 2861, 15, 15, 18, 2, -15 },
  { 2890, 14, 15, 18, 2, -15 },
  { 2917, 15, 21, 18, 1, -21 },
  { 2957, 14, 15, 18, 2, -15 },
  { 2984, 16, 15, 18, 1, -15 },
  { 3014, 18, 15, 18, 0, -15 },
  { 3048, 16, 15, 18, 1, -15 },
  { 3078, 16, 21, 18, 1, -15 },
  { 3120, 14, 15, 18, 2, -15 },
  { 3147, 12, 27, 18, 3, -23 },
  { 3188, 4, 27, 18, 7, -23 },
  { 3202, 12, 27, 18, 3, -23 },
  { 3243, 16, 7, 18, 1, -13 },
};

const GFXfont IBMPlexMono_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_SEMIBOLD30PT7B_H_
