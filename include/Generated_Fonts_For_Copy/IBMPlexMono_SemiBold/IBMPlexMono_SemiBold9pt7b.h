#ifndef _IBMPLEXMONO_SEMIBOLD9PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xA8, 0xB0, 0xB6, 0x80, 0x29, 0xB7, 0xB5, 0x28, 0x23, 0xDC, 0xC3,
  0xD5, 0xC4, 0xED, 0xB8, 0x36, 0xCC, 0x73, 0x13, 0xE9, 0x34, 0xE0, 0x72,
  0x49, 0x23, 0x88, 0x92, 0x54, 0x27, 0x4C, 0xA5, 0x80, 0x44, 0xF4, 0x40,
  0xE0, 0xE0, 0xF0, 0x32, 0x24, 0x44, 0x88, 0x72, 0x73, 0x96, 0xB8, 0x72,
  0xA4, 0x21, 0x3C, 0x76, 0xC6, 0x66, 0x3C, 0x74, 0x4C, 0x18, 0xB8, 0x31,
  0x94, 0xAF, 0x88, 0x7A, 0x1C, 0x14, 0xF8, 0x32, 0x1D, 0x94, 0xB8, 0xFE,
  0x44, 0x22, 0x30, 0x72, 0x4D, 0x9C, 0xB8, 0x76, 0x72, 0xF1, 0x30, 0xF3,
  0xC0, 0xF0, 0xE0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xEB,
  0x40, 0x44, 0x72, 0x6F, 0x5B, 0xA1, 0xC0, 0x33, 0x94, 0xB7, 0xE4, 0xE9,
  0xE9, 0x9E, 0x72, 0x71, 0x84, 0xB8, 0xE9, 0x99, 0x9E, 0xF8, 0xF8, 0x8F,
  0xF8, 0xF8, 0x88, 0x72, 0x71, 0xB4, 0xBC, 0x99, 0xF9, 0x99, 0xF4, 0x44,
  0x4F, 0x78, 0xC6, 0x3D, 0xB8, 0x9A, 0xCA, 0xA9, 0x88, 0x88, 0x8F, 0xDF,
  0xEB, 0x58, 0xC4, 0x9D, 0xDD, 0xBB, 0x72, 0x73, 0x94, 0xB8, 0xE9, 0x9E,
  0x88, 0x72, 0x73, 0x94, 0xB8, 0x87, 0xE9, 0x9E, 0xA9, 0x72, 0xD8, 0x38,
  0xB8, 0xF9, 0x08, 0x42, 0x10, 0x99, 0x99, 0x9E, 0xCA, 0x56, 0xA7, 0x18,
  0x8D, 0x6F, 0xBD, 0xAC, 0xCA, 0x8C, 0x65, 0x64, 0xCA, 0xD4, 0x62, 0x10,
  0x78, 0x8C, 0x44, 0x7C, 0xF2, 0x49, 0x27, 0x88, 0x44, 0x42, 0x23, 0xE4,
  0x92, 0x4F, 0x32, 0x97, 0x10, 0xF0, 0xD0, 0x74, 0xDF, 0xB6, 0x80, 0x88,
  0xE9, 0x99, 0xE0, 0xEB, 0x8A, 0xF0, 0x08, 0x5A, 0xBC, 0xA5, 0xE0, 0x72,
  0x7E, 0x87, 0x80, 0x74, 0xF4, 0x44, 0xF0, 0x0B, 0x92, 0xE4, 0x3E, 0x2F,
  0x88, 0xE9, 0x99, 0x90, 0x60, 0xE6, 0x66, 0xF0, 0x23, 0x92, 0x49, 0xE0,
  0x88, 0xBE, 0xEA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xBF, 0x6B, 0x5A, 0x80,
  0xE9, 0x99, 0x90, 0x72, 0x72, 0x97, 0x00, 0xE9, 0x99, 0xE8, 0x80, 0x6A,
  0xF2, 0x97, 0x84, 0x20, 0xD6, 0x44, 0xF0, 0x72, 0xDD, 0x17, 0x00, 0x27,
  0xC8, 0x42, 0x1C, 0x99, 0x99, 0xF0, 0xCA, 0xD4, 0x63, 0x00, 0xAD, 0x77,
  0xB5, 0x80, 0xDB, 0x88, 0xAD, 0x80, 0xCA, 0xD4, 0x62, 0x11, 0x80, 0xF2,
  0x48, 0xF0, 0x74, 0x2C, 0x24, 0x47, 0xFF, 0xC4, 0x43, 0x44, 0x4C, 0x6D,
  0xC0,
};

const GFXglyph IBMPlexMono_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 3, 5, 1, -7 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 5, 6, 5, 0, -6 },
  { 22, 1, 3, 5, 2, -7 },
  { 23, 3, 8, 5, 2, -7 },
  { 26, 3, 8, 5, 1, -7 },
  { 29, 5, 5, 5, 0, -5 },
  { 33, 4, 5, 5, 1, -5 },
  { 36, 2, 2, 5, 2, -1 },
  { 37, 3, 1, 5, 1, -3 },
  { 38, 2, 2, 5, 2, -2 },
  { 39, 4, 8, 5, 1, -7 },
  { 43, 5, 6, 5, 0, -6 },
  { 47, 5, 6, 5, 0, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 5, 6, 5, 0, -6 },
  { 59, 5, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 5, 6, 5, 0, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 2, 5, 5, 2, -5 },
  { 85, 2, 6, 5, 2, -5 },
  { 87, 4, 5, 5, 1, -5 },
  { 90, 4, 3, 5, 1, -4 },
  { 92, 4, 5, 5, 1, -5 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 5, 7, 5, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 4, 6, 5, 1, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 4, 6, 5, 1, -6 },
  { 157, 5, 8, 5, 0, -6 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 5, 6, 5, 0, -6 },
  { 173, 4, 6, 5, 1, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 5, 6, 5, 0, -6 },
  { 196, 3, 8, 5, 2, -7 },
  { 199, 4, 8, 5, 1, -7 },
  { 203, 3, 8, 5, 1, -7 },
  { 206, 5, 4, 5, 0, -6 },
  { 209, 4, 1, 5, 1, 1 },
  { 210, 2, 2, 5, 1, -8 },
  { 211, 5, 5, 5, 0, -5 },
  { 215, 4, 7, 5, 1, -7 },
  { 219, 4, 5, 5, 1, -5 },
  { 222, 5, 7, 5, 0, -7 },
  { 227, 5, 5, 5, 0, -5 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 5, 8, 5, 0, -6 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 4, 7, 5, 1, -7 },
  { 248, 3, 9, 5, 1, -7 },
  { 252, 4, 7, 5, 1, -7 },
  { 256, 4, 7, 5, 1, -7 },
  { 260, 5, 5, 5, 0, -5 },
  { 264, 4, 5, 5, 1, -5 },
  { 267, 5, 5, 5, 0, -5 },
  { 271, 4, 7, 5, 1, -5 },
  { 275, 5, 7, 5, 0, -5 },
  { 280, 4, 5, 5, 1, -5 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 5, 6, 5, 0, -6 },
  { 291, 4, 5, 5, 1, -5 },
  { 294, 5, 5, 5, 0, -5 },
  { 298, 5, 5, 5, 0, -5 },
  { 302, 5, 5, 5, 0, -5 },
  { 306, 5, 7, 5, 0, -5 },
  { 311, 4, 5, 5, 1, -5 },
  { 314, 4, 8, 5, 1, -7 },
  { 318, 1, 8, 5, 2, -7 },
  { 319, 4, 8, 5, 1, -7 },
  { 323, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_SEMIBOLD9PT7B_H_
