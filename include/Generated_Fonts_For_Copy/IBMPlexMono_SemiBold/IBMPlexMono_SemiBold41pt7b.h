#ifndef _IBMPLEXMONO_SEMIBOLD41PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7,
  0x8F, 0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x3F, 0xF1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1,
  0xFF, 0x01, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0xFF, 0xC3, 0xFE, 0xFF, 0xC7, 0xFE, 0xFF, 0xC7,
  0xFE, 0xFF, 0x87, 0xFE, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0x07, 0x87,
  0x80, 0x07, 0x8F, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFE, 0x7E, 0x73, 0xFB, 0xE3, 0x87, 0x1F, 0x1C, 0x11, 0xF0, 0xE0, 0x0F,
  0xC7, 0x00, 0x3E, 0x38, 0x01, 0xF9, 0xC0, 0x0F, 0xEE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x39, 0xFC, 0x01, 0xC3, 0xE0, 0x0E, 0x1F, 0x00, 0x70, 0xF8, 0x03, 0x87,
  0xCC, 0x1C, 0x3E, 0xF0, 0xE3, 0xFF, 0xE7, 0x3F, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x1F, 0xE0, 0x1F,
  0x3F, 0xF0, 0x1E, 0x7F, 0xF0, 0x3C, 0x78, 0xF8, 0x3C, 0x78, 0x78, 0x78,
  0xF0, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x79, 0xE0,
  0x78, 0xF9, 0xE0, 0x7F, 0xF3, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xEF, 0xFE,
  0x03, 0xCF, 0x1F, 0x07, 0x8E, 0x0F, 0x07, 0x9E, 0x0F, 0x0F, 0x1E, 0x0F,
  0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0x1F, 0x3C, 0x0F, 0xFE,
  0x3C, 0x07, 0xFE, 0x78, 0x03, 0xFC, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0xF8, 0x07,
  0xC0, 0xE0, 0x0F, 0x81, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC7, 0xF8, 0x3F, 0x9F, 0xF8, 0x7F, 0x7D, 0xF8, 0xFF, 0xF1, 0xFB,
  0xE3, 0xE1, 0xF7, 0x87, 0xC1, 0xFF, 0x0F, 0x81, 0xFE, 0x1F, 0x03, 0xF8,
  0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF, 0xFB, 0xE0,
  0xFF, 0xE3, 0xE0, 0xFF, 0x87, 0xE0, 0x7C, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x81, 0xF0, 0x27, 0x87, 0xC7, 0x9F,
  0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xF3, 0xF0,
  0x0F, 0xC7, 0xC0, 0x7E, 0x0F, 0x81, 0xF0, 0x3F, 0x01, 0xC0, 0x70, 0x02,
  0x01, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x83,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x78, 0x7F, 0xF1,
  0xF1, 0xFF, 0xC7, 0xC7, 0xFF, 0x1F, 0x1F, 0x7C, 0x78, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x01, 0xF8,
  0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x03, 0xC1, 0xF0, 0x0C, 0x0F, 0x80,
  0x40, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0,
  0xFE, 0x7E, 0x03, 0xF3, 0xE0, 0x0F, 0xC3, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F, 0x0F, 0x01, 0xFC, 0x20, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x84, 0x00, 0x7C, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0xFF, 0x07, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0x7E, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x1F,
  0x81, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0xF9,
  0xFF, 0x07, 0xDF, 0xFC, 0x3D, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x88, 0x00, 0xFC, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0xFF, 0x07, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0xF9, 0xFF, 0x07, 0xDF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xCF,
  0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x7E, 0x0F,
  0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x7F, 0x07, 0xF3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0x7E, 0x3E,
  0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFD, 0xFC,
  0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFD, 0xF0, 0xFF, 0xDF, 0x81, 0xF8, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3E, 0x1F, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0xFE, 0x1F, 0xFE, 0x03, 0xF7, 0x80, 0x7C, 0x40,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0x07, 0xE3, 0xC0, 0x1F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x3C, 0xFF,
  0x07, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0xFF, 0x1E, 0x0F,
  0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0,
  0xFF, 0x1E, 0x0F, 0xF1, 0xF0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xEF, 0x70, 0x7E, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7E, 0x7C,
  0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x3E,
  0x7C, 0x01, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x18, 0x3E, 0x00,
  0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x1F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F,
  0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xF7, 0xC0, 0x1E, 0xFC, 0x01, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F,
  0x3F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0xFF, 0x9F, 0x03, 0xE1,
  0xF0, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x70, 0x0F, 0xFF, 0x01, 0xF7, 0xE0,
  0x7E, 0x7E, 0x1F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F,
  0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0x8F,
  0x80, 0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0xF8, 0x7E,
  0x07, 0xC7, 0xE0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF3, 0xF0,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xFD,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFE, 0xF1, 0xFF, 0xF7, 0xDE, 0xFF,
  0x9E, 0xF7, 0xFC, 0xF7, 0xBF, 0xF7, 0xF9, 0xFF, 0x9F, 0xCF, 0xFC, 0xFC,
  0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF0, 0xFF, 0xC3, 0x87, 0xFE,
  0x1C, 0x3F, 0xF0, 0xC1, 0xFF, 0x82, 0x0F, 0xFC, 0x20, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xF7, 0x83, 0xFE, 0xF8, 0x7F, 0xCF, 0x0F, 0xF9, 0xE1, 0xFF, 0x3E, 0x3F,
  0xE3, 0xC7, 0xFC, 0x7C, 0xFF, 0x8F, 0x9F, 0xF0, 0xF3, 0xFE, 0x1F, 0x7F,
  0xC3, 0xEF, 0xF8, 0x3D, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x80, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00,
  0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x83,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC,
  0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x3F, 0x81, 0xF0, 0xFC, 0x01, 0xC3, 0xE0, 0x02, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x40, 0x03, 0xF1, 0x80, 0x0F, 0x8F, 0x00, 0x7E, 0x7F, 0x03, 0xFB,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0x7C, 0x3E, 0x1E, 0xF8, 0x7C, 0x3D, 0xF1, 0xF8,
  0x7B, 0xE3, 0xF0, 0xF3, 0xC7, 0xF1, 0xE7, 0x8F, 0xE3, 0xCF, 0x1D, 0xC7,
  0x9E, 0x3B, 0x8F, 0x3C, 0xF7, 0x1E, 0x79, 0xEF, 0x7C, 0xF3, 0x9E, 0xF9,
  0xE7, 0x3D, 0xF3, 0xCE, 0x3B, 0xE7, 0x9C, 0x77, 0xCF, 0xF8, 0xEF, 0x1F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0xFC,
  0x01, 0xF9, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xBE, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F,
  0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x7C,
  0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x78, 0xF8, 0x7C, 0x7C, 0x3E,
  0x1E, 0x0F, 0x0C, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xE0, 0xFC, 0x1C, 0x03, 0xE0, 0x40, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xE0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xE3,
  0xFF, 0xDF, 0xDF, 0xFE, 0xFE, 0x7F, 0xE3, 0xF0, 0xFC, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFB, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC,
  0x07, 0xEF, 0xE0, 0xFE, 0xFB, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9, 0xFF, 0x0F,
  0x87, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7,
  0xF0, 0xFC, 0xF8, 0x07, 0x7F, 0x00, 0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x43, 0xE0, 0x1E, 0x7F, 0x07, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x7E, 0x1F, 0x1F, 0xF1, 0xF3, 0xFF, 0x9F, 0x7F, 0xFD,
  0xF7, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0xFD, 0xF3,
  0xFF, 0x9F, 0x1F, 0xF1, 0xF0, 0x7E, 0x1F, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x01,
  0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x08, 0x3F,
  0x03, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7E, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9,
  0xE0, 0x03, 0xE7, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x0F, 0xC3, 0xE3, 0xFC,
  0x7C, 0xFF, 0xCF, 0xBF, 0xFD, 0xF4, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F,
  0xBE, 0x03, 0xF9, 0xF0, 0x3F, 0x8F, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x07,
  0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF,
  0x80, 0x3F, 0x7C, 0x01, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xC1, 0xE7, 0xBF, 0x3F, 0xBD, 0xFD,
  0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0x8F, 0xF8, 0x7C, 0x3F, 0xC3, 0xC1, 0xFE,
  0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0,
  0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0,
  0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07,
  0x80, 0xF8, 0x7E, 0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0x7D, 0xFF, 0xEF, 0xA0,
  0xFD, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x7F, 0x07, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x7E, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFE, 0x0F, 0xEF,
  0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xBF, 0xFC, 0xFB, 0xFF, 0x8F, 0x9F,
  0xF0, 0xF8, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE1, 0xF1, 0xFF, 0x1F, 0x3F, 0xF9, 0xF7, 0xFF, 0xDF, 0x7F, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xF7, 0xC0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xDF, 0x3F, 0xF9, 0xF1,
  0xFF, 0x1F, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x03, 0xC7, 0xE0, 0x08, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x20, 0x01, 0xF3, 0x80, 0x3F, 0x7E, 0x07,
  0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF, 0xDF, 0x9F, 0xF3, 0xF0,
  0xFC, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x7C,
  0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F, 0x87, 0xE1, 0xFF, 0x0F, 0xE3,
  0xDF, 0x1F, 0xC7, 0xBE, 0x3B, 0x8F, 0x3C, 0x77, 0x1E, 0x78, 0xEE, 0x3C,
  0xF3, 0xDC, 0x79, 0xE7, 0x3C, 0xF3, 0xCE, 0x79, 0xE7, 0x9C, 0x77, 0x8F,
  0x38, 0xEF, 0x1E, 0x71, 0xDE, 0x1F, 0xE3, 0xBC, 0x3F, 0x87, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0xC7,
  0xC0, 0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x87, 0xE0, 0x7C, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xFC, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x70,
  0xFE, 0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xE7, 0x9F, 0x0F, 0x7C, 0x7C,
  0xFB, 0xC1, 0xFF, 0x9E, 0x07, 0xFC, 0xF0, 0x3F, 0xC3, 0x80, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 13, 13, 25, 6, -30 },
  { 49, 24, 29, 25, 0, -29 },
  { 136, 21, 37, 25, 2, -33 },
  { 234, 24, 29, 25, 0, -29 },
  { 321, 23, 29, 25, 1, -29 },
  { 405, 5, 13, 25, 10, -30 },
  { 414, 14, 37, 25, 7, -31 },
  { 479, 14, 37, 25, 3, -31 },
  { 544, 22, 21, 25, 1, -23 },
  { 602, 19, 20, 25, 3, -23 },
  { 650, 10, 13, 25, 7, -7 },
  { 667, 13, 5, 25, 6, -15 },
  { 676, 8, 7, 25, 8, -7 },
  { 683, 18, 37, 25, 3, -31 },
  { 767, 22, 29, 25, 1, -29 },
  { 847, 21, 29, 25, 2, -29 },
  { 924, 21, 29, 25, 2, -29 },
  { 1001, 21, 29, 25, 1, -29 },
  { 1078, 22, 29, 25, 1, -29 },
  { 1158, 21, 29, 25, 2, -29 },
  { 1235, 21, 29, 25, 2, -29 },
  { 1312, 20, 29, 25, 2, -29 },
  { 1385, 21, 29, 25, 2, -29 },
  { 1462, 21, 29, 25, 2, -29 },
  { 1539, 8, 22, 25, 8, -22 },
  { 1561, 10, 28, 25, 7, -22 },
  { 1596, 18, 24, 25, 3, -25 },
  { 1650, 19, 13, 25, 3, -19 },
  { 1681, 18, 24, 25, 3, -25 },
  { 1735, 18, 29, 25, 3, -29 },
  { 1801, 20, 34, 25, 2, -29 },
  { 1886, 23, 29, 25, 1, -29 },
  { 1970, 20, 29, 25, 3, -29 },
  { 2043, 21, 29, 25, 2, -29 },
  { 2120, 20, 29, 25, 3, -29 },
  { 2193, 18, 29, 25, 3, -29 },
  { 2259, 19, 29, 25, 3, -29 },
  { 2328, 20, 29, 25, 2, -29 },
  { 2401, 19, 29, 25, 3, -29 },
  { 2470, 18, 29, 25, 3, -29 },
  { 2536, 19, 29, 25, 2, -29 },
  { 2605, 21, 29, 25, 3, -29 },
  { 2682, 18, 29, 25, 4, -29 },
  { 2748, 21, 29, 25, 2, -29 },
  { 2825, 19, 29, 25, 3, -29 },
  { 2894, 22, 29, 25, 1, -29 },
  { 2974, 20, 29, 25, 3, -29 },
  { 3047, 22, 36, 25, 1, -29 },
  { 3146, 20, 29, 25, 3, -29 },
  { 3219, 22, 29, 25, 1, -29 },
  { 3299, 23, 29, 25, 1, -29 },
  { 3383, 19, 29, 25, 3, -29 },
  { 3452, 23, 29, 25, 1, -29 },
  { 3536, 23, 29, 25, 1, -29 },
  { 3620, 23, 29, 25, 1, -29 },
  { 3704, 24, 29, 25, 0, -29 },
  { 3791, 21, 29, 25, 2, -29 },
  { 3868, 13, 37, 25, 8, -31 },
  { 3929, 18, 37, 25, 3, -31 },
  { 4013, 13, 37, 25, 4, -31 },
  { 4074, 22, 18, 25, 1, -29 },
  { 4124, 20, 4, 25, 2, 3 },
  { 4134, 8, 9, 25, 7, -33 },
  { 4143, 21, 21, 25, 2, -21 },
  { 4199, 20, 30, 25, 3, -30 },
  { 4274, 19, 21, 25, 3, -21 },
  { 4324, 20, 30, 25, 2, -30 },
  { 4399, 20, 21, 25, 2, -21 },
  { 4452, 20, 30, 25, 3, -30 },
  { 4527, 22, 33, 25, 2, -25 },
  { 4618, 19, 30, 25, 3, -30 },
  { 4690, 19, 30, 25, 4, -30 },
  { 4762, 15, 38, 25, 4, -30 },
  { 4834, 21, 30, 25, 3, -30 },
  { 4913, 19, 30, 25, 3, -30 },
  { 4985, 21, 21, 25, 2, -21 },
  { 5041, 19, 21, 25, 3, -21 },
  { 5091, 21, 21, 25, 2, -21 },
  { 5147, 20, 29, 25, 3, -21 },
  { 5220, 20, 29, 25, 2, -21 },
  { 5293, 20, 21, 25, 3, -21 },
  { 5346, 20, 21, 25, 2, -21 },
  { 5399, 20, 29, 25, 2, -29 },
  { 5472, 19, 21, 25, 3, -21 },
  { 5522, 21, 21, 25, 2, -21 },
  { 5578, 23, 21, 25, 1, -21 },
  { 5639, 22, 21, 25, 1, -21 },
  { 5697, 22, 29, 25, 1, -21 },
  { 5777, 19, 21, 25, 3, -21 },
  { 5827, 17, 37, 25, 4, -31 },
  { 5906, 5, 37, 25, 10, -31 },
  { 5930, 17, 37, 25, 4, -31 },
  { 6009, 21, 10, 25, 2, -17 },
};

const GFXfont IBMPlexMono_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_SEMIBOLD41PT7B_H_
