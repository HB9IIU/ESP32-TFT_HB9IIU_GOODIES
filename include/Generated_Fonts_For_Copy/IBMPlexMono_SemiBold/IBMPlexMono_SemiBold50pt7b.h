#ifndef _IBMPLEXMONO_SEMIBOLD50PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x7F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF8, 0xFC, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x7F, 0xF8, 0x7F, 0xF7, 0xFF, 0x87, 0xFF,
  0x7F, 0xF8, 0x7F, 0xF7, 0xFF, 0x87, 0xFF, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x1F, 0xFE, 0xFF,
  0xE1, 0xFF, 0xEF, 0xFE, 0x1F, 0xFE, 0xFF, 0xE1, 0xFF, 0xE0, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFD, 0xF7, 0xF1, 0xFC, 0x7C, 0x78,
  0x7F, 0x1F, 0x06, 0x1F, 0x87, 0xC1, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0xC7, 0xC0, 0x03, 0xF9, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF3,
  0xF8, 0x00, 0x7C, 0x7F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x10, 0x1F, 0x0F, 0xCF, 0x07, 0xC7, 0xF7,
  0xE1, 0xF1, 0xFB, 0xFE, 0x7D, 0xFE, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xF1, 0xFF,
  0xC0, 0x0F, 0x8F, 0xFF, 0x80, 0x7C, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x78,
  0x0F, 0x87, 0x81, 0xF0, 0x3E, 0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07,
  0xC1, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0xC7, 0xC0,
  0x78, 0x1F, 0x1F, 0x01, 0xF0, 0x78, 0xF8, 0x07, 0xE3, 0xE3, 0xE0, 0x0F,
  0xFF, 0x9F, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xE7,
  0xFF, 0xC0, 0x1F, 0x1F, 0x1F, 0x80, 0x7C, 0xF8, 0x3E, 0x03, 0xE3, 0xE0,
  0x78, 0x0F, 0x8F, 0x81, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x1E,
  0x0F, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xE1, 0xF0, 0x3E, 0x07, 0x87,
  0xC0, 0xF8, 0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0xF8, 0x07, 0xFF, 0xC7, 0xC0,
  0x0F, 0xFE, 0x1F, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xF0, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x3F, 0xFC, 0x3F, 0xE3, 0xF7,
  0xF1, 0xFF, 0x3F, 0x1F, 0x8F, 0x81, 0xF8, 0xFE, 0x7C, 0x1F, 0x83, 0xFB,
  0xE0, 0xFC, 0x0F, 0xDE, 0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x01, 0xFF, 0x81,
  0xF8, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8,
  0x07, 0xFC, 0x0F, 0xF0, 0xF7, 0xF0, 0x7F, 0xFF, 0x9F, 0xC1, 0xFF, 0xF8,
  0xFE, 0x07, 0xFF, 0xC3, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x04, 0x03, 0xF0, 0x09,
  0xE0, 0xFC, 0x1E, 0x7F, 0x3F, 0x1F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x78, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x1E, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x1E, 0x07, 0xF0, 0x01, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF0,
  0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x03, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0x38, 0x00,
  0xFE, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE1, 0x00, 0x07, 0xF1, 0x80, 0x03, 0xFB, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFE, 0x01, 0xF1, 0xFF, 0xC0, 0xF9, 0xFF,
  0xF0, 0x7D, 0xFF, 0xFC, 0x3E, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xC0,
  0x1F, 0xE0, 0x40, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC4, 0x00, 0x0F, 0xE3,
  0x00, 0x0F, 0xE7, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xFE, 0x07, 0xF8,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE3,
  0xF8, 0x03, 0xF3, 0xFF, 0x81, 0xFD, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE, 0x1F,
  0xBF, 0xFF, 0xC7, 0xFC, 0x0F, 0xFB, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xDF, 0xF0, 0x3F, 0xE3, 0xFF, 0xFD,
  0xF8, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xBF, 0x81, 0xFF, 0xCF, 0xC0, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE3, 0xF0, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00,
  0x7F, 0x1C, 0x00, 0xFE, 0x08, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0xFE, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x01, 0xF3, 0xEF,
  0x81, 0xFD, 0xF7, 0xC1, 0xFF, 0xFB, 0xE1, 0xFF, 0xFD, 0xE0, 0xFC, 0x7F,
  0xF0, 0xFC, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x03,
  0xFF, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0xFF, 0xC3, 0xE0, 0x7F, 0xE1, 0xF0,
  0x3F, 0xF0, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x0F,
  0x83, 0xEF, 0x07, 0xF7, 0xF7, 0xC3, 0xFF, 0xFB, 0xE0, 0xFF, 0x7D, 0xF0,
  0x3F, 0x3E, 0xF8, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xC7, 0xF0, 0x00,
  0x81, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x80, 0xFC, 0x00, 0x7C, 0x3F, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0x1F, 0x80, 0x04, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0xC1, 0xFF, 0x1F, 0xFF, 0xDF,
  0x87, 0xFF, 0xCF, 0xC3, 0xFF, 0xE7, 0xE0, 0x7F, 0xE3, 0xF0, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x38, 0x03, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0,
  0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xF8, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xFC, 0x03, 0xF1, 0xFE, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xDF, 0xE0, 0x03, 0xF7, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xBF, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x0F, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x03, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x7C, 0x7B, 0xFF, 0xDF,
  0x3E, 0xFF, 0xF7, 0xCF, 0xBF, 0xFC, 0xFB, 0xCF, 0xFF, 0x3F, 0xF3, 0xFF,
  0xCF, 0xFC, 0xFF, 0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xE3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x1E, 0x0F, 0xFF, 0x07,
  0x83, 0xFF, 0xC1, 0xE0, 0xFF, 0xF0, 0x30, 0x3F, 0xFC, 0x0C, 0x0F, 0xFF,
  0x03, 0x03, 0xFF, 0xC0, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFD, 0xF0, 0x3F, 0xFD, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F, 0xFC,
  0xF8, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7C, 0x3F, 0xFC,
  0x7E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC,
  0x1F, 0x3F, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F, 0xBF, 0xFC, 0x0F, 0xBF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xC3, 0xF8,
  0x01, 0xE1, 0xFC, 0x00, 0x30, 0x7F, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x18, 0x00,
  0x1F, 0x8F, 0x00, 0x0F, 0xE7, 0xE0, 0x07, 0xFB, 0xFF, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x1F, 0x83, 0xF7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0xC3,
  0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x3F, 0xE3, 0xE7, 0xE7, 0x9E,
  0x3E, 0x7E, 0x79, 0xE3, 0xE7, 0xE7, 0x9E, 0x3E, 0x7E, 0x79, 0xE3, 0xE7,
  0xE7, 0x9E, 0x7E, 0x7E, 0x79, 0xF7, 0xE7, 0xEF, 0x8F, 0x7E, 0x3E, 0xF0,
  0xF7, 0xC3, 0xEF, 0x0F, 0x7C, 0x3E, 0xF0, 0xF7, 0xC3, 0xEF, 0x0F, 0x7C,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x9F,
  0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x0F,
  0x86, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x0F, 0x0F, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xE0, 0x20, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xF8, 0x1F, 0xE0, 0xF0, 0x07, 0xF0, 0x30, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xF8, 0xFE,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0xFC, 0xFF,
  0x3F, 0xFC, 0x3F, 0x8F, 0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x0F,
  0xE3, 0xFF, 0x07, 0xF3, 0xFF, 0xC3, 0xFB, 0xFF, 0xF1, 0xFD, 0xFF, 0xFC,
  0xFF, 0xC1, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xFE,
  0x01, 0xFE, 0xFF, 0xC1, 0xFE, 0x7F, 0x7F, 0xFF, 0x3F, 0xBF, 0xFF, 0x1F,
  0xCF, 0xFF, 0x0F, 0xE3, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0x7C, 0x7F, 0x00, 0x38, 0x7E, 0x00, 0x20,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x10, 0x7F, 0x00, 0x38, 0x3F, 0x80, 0x7E,
  0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0xE3, 0xF8, 0x7F,
  0xF9, 0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xFF, 0x7F, 0x3F, 0xC1, 0xFF, 0xBF,
  0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC1,
  0xFF, 0x9F, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xE7, 0xF0, 0x7F,
  0xE3, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x10, 0x7E, 0x00, 0x18, 0x7F, 0x00, 0x7C, 0x3F, 0xC0, 0xFE, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x70, 0x00, 0xFF, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x0F, 0xC7, 0xFE, 0x1F, 0x9F, 0xFE, 0x3F, 0x3F, 0xFE, 0x7E, 0xFF,
  0xFC, 0xFD, 0x83, 0xFD, 0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xEF,
  0xC0, 0x1F, 0xE7, 0xE0, 0x1F, 0xE3, 0xF0, 0x1F, 0xE1, 0xF8, 0x1F, 0xE0,
  0xFC, 0x1F, 0xE0, 0x7E, 0x1F, 0xE0, 0x3F, 0x1F, 0xE0, 0x1F, 0x9F, 0xE0,
  0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x83, 0xF0, 0x1F, 0xE1, 0xF8,
  0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x7E, 0x00, 0xFF, 0x3F, 0x00, 0x3F, 0x9F,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0xF0, 0x3E, 0x3E, 0x7F, 0x1F, 0xCF, 0xBF, 0xCF, 0xFB, 0xEF, 0xFB,
  0xFE, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0x83, 0xF0, 0x7F, 0xE0,
  0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F,
  0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0,
  0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF, 0x83,
  0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF,
  0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1,
  0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xE7, 0xFF,
  0xCF, 0xDF, 0xFF, 0x9F, 0xB0, 0x7F, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x7F,
  0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xDF, 0xFF, 0x8F, 0xEF, 0xFF, 0xE7,
  0xFE, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xFE, 0x0F, 0xF3, 0xFB, 0xFF, 0xF9, 0xFD, 0xFF, 0xF8, 0xFE,
  0x7F, 0xF8, 0x7F, 0x1F, 0xF8, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x3F, 0x83, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF,
  0xF7, 0xF3, 0xFF, 0xFB, 0xF9, 0xFE, 0x0F, 0xFD, 0xFE, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x0F, 0xFC, 0xFF, 0xFE,
  0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFB, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0x38, 0x7E, 0x00, 0x10,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x30, 0x00, 0x7E,
  0x7C, 0x00, 0x7E, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x7F, 0xCF, 0xFF, 0xDF,
  0x9F, 0xFF, 0xBF, 0x1F, 0xFE, 0x7E, 0x1F, 0xF8, 0xFC, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF,
  0x81, 0xFC, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xC3, 0xFC, 0x1F, 0x7C, 0x3F,
  0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x3D, 0xC3, 0xE7, 0xC3, 0x9E, 0x3E,
  0x7C, 0x79, 0xE3, 0xE7, 0xC7, 0x9E, 0x3E, 0x7C, 0x79, 0xE3, 0xE7, 0xC7,
  0x9E, 0x3E, 0x3E, 0x79, 0xE3, 0xC3, 0xE7, 0x0F, 0x3C, 0x3E, 0xF0, 0xF7,
  0xC3, 0xEF, 0x0F, 0x7C, 0x3E, 0xF0, 0xF7, 0xC3, 0xEF, 0x0F, 0x7C, 0x3E,
  0xF0, 0xF7, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xE0, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFC,
  0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x07, 0x03, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0x7C, 0xFF, 0xF0, 0x1E,
  0x3F, 0xFE, 0x0F, 0x9F, 0x9F, 0xC3, 0xE7, 0xC3, 0xF9, 0xF9, 0xF0, 0x7F,
  0xFC, 0xF8, 0x0F, 0xFF, 0x3E, 0x03, 0xFF, 0x8F, 0x80, 0x3F, 0xC0, 0xE0,
  0x07, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 10, 36, 30, 10, -35 },
  { 46, 16, 16, 30, 7, -37 },
  { 78, 28, 35, 30, 1, -35 },
  { 201, 26, 46, 30, 2, -40 },
  { 351, 30, 37, 30, 0, -36 },
  { 490, 29, 37, 30, 1, -36 },
  { 625, 6, 16, 30, 12, -37 },
  { 637, 17, 45, 30, 9, -38 },
  { 733, 17, 45, 30, 4, -38 },
  { 829, 26, 25, 30, 2, -27 },
  { 911, 24, 25, 30, 3, -28 },
  { 986, 11, 15, 30, 9, -8 },
  { 1007, 16, 6, 30, 7, -18 },
  { 1019, 10, 9, 30, 10, -8 },
  { 1031, 22, 45, 30, 4, -38 },
  { 1155, 26, 37, 30, 2, -36 },
  { 1276, 27, 35, 30, 2, -35 },
  { 1395, 26, 36, 30, 2, -36 },
  { 1512, 25, 37, 30, 2, -36 },
  { 1628, 28, 35, 30, 1, -35 },
  { 1751, 25, 36, 30, 3, -35 },
  { 1864, 26, 36, 30, 2, -35 },
  { 1981, 24, 35, 30, 3, -35 },
  { 2086, 26, 37, 30, 2, -36 },
  { 2207, 26, 36, 30, 2, -36 },
  { 2324, 10, 27, 30, 10, -26 },
  { 2358, 11, 33, 30, 9, -26 },
  { 2404, 22, 30, 30, 4, -30 },
  { 2487, 24, 16, 30, 3, -23 },
  { 2535, 22, 30, 30, 4, -30 },
  { 2618, 23, 37, 30, 3, -36 },
  { 2725, 25, 42, 30, 2, -36 },
  { 2857, 28, 35, 30, 1, -35 },
  { 2980, 24, 35, 30, 4, -35 },
  { 3085, 26, 37, 30, 2, -36 },
  { 3206, 24, 35, 30, 4, -35 },
  { 3311, 22, 35, 30, 4, -35 },
  { 3408, 23, 35, 30, 4, -35 },
  { 3509, 25, 37, 30, 2, -36 },
  { 3625, 24, 35, 30, 3, -35 },
  { 3730, 22, 35, 30, 4, -35 },
  { 3827, 23, 36, 30, 2, -35 },
  { 3931, 26, 35, 30, 4, -35 },
  { 4045, 22, 35, 30, 5, -35 },
  { 4142, 26, 35, 30, 2, -35 },
  { 4256, 24, 35, 30, 3, -35 },
  { 4361, 26, 37, 30, 2, -36 },
  { 4482, 24, 35, 30, 4, -35 },
  { 4587, 26, 45, 30, 2, -36 },
  { 4734, 24, 35, 30, 4, -35 },
  { 4839, 26, 37, 30, 2, -36 },
  { 4960, 28, 35, 30, 1, -35 },
  { 5083, 24, 36, 30, 3, -35 },
  { 5191, 28, 35, 30, 1, -35 },
  { 5314, 28, 35, 30, 1, -35 },
  { 5437, 28, 35, 30, 1, -35 },
  { 5560, 30, 35, 30, 0, -35 },
  { 5692, 26, 35, 30, 2, -35 },
  { 5806, 15, 45, 30, 10, -38 },
  { 5891, 22, 45, 30, 4, -38 },
  { 6015, 15, 45, 30, 5, -38 },
  { 6100, 26, 22, 30, 2, -35 },
  { 6172, 24, 5, 30, 3, 4 },
  { 6187, 10, 11, 30, 8, -40 },
  { 6201, 25, 27, 30, 3, -26 },
  { 6286, 25, 38, 30, 3, -37 },
  { 6405, 24, 27, 30, 3, -26 },
  { 6486, 25, 38, 30, 2, -37 },
  { 6605, 24, 27, 30, 3, -26 },
  { 6686, 25, 37, 30, 3, -37 },
  { 6802, 26, 42, 30, 3, -31 },
  { 6939, 23, 37, 30, 4, -37 },
  { 7046, 23, 39, 30, 5, -39 },
  { 7159, 18, 49, 30, 5, -39 },
  { 7270, 25, 37, 30, 4, -37 },
  { 7386, 22, 37, 30, 4, -37 },
  { 7488, 26, 26, 30, 2, -26 },
  { 7573, 23, 26, 30, 4, -26 },
  { 7648, 26, 27, 30, 2, -26 },
  { 7736, 25, 36, 30, 3, -26 },
  { 7849, 25, 36, 30, 2, -26 },
  { 7962, 24, 26, 30, 4, -26 },
  { 8040, 24, 27, 30, 3, -26 },
  { 8121, 24, 35, 30, 2, -35 },
  { 8226, 23, 27, 30, 3, -26 },
  { 8304, 26, 26, 30, 2, -26 },
  { 8389, 28, 26, 30, 1, -26 },
  { 8480, 26, 26, 30, 2, -26 },
  { 8565, 28, 36, 30, 1, -26 },
  { 8691, 22, 26, 30, 4, -26 },
  { 8763, 20, 45, 30, 5, -38 },
  { 8876, 6, 45, 30, 12, -38 },
  { 8910, 20, 45, 30, 5, -38 },
  { 9023, 26, 12, 30, 2, -21 },
};

const GFXfont IBMPlexMono_SemiBold50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_SEMIBOLD50PT7B_H_
