#ifndef _IBMPLEXMONO_SEMIBOLD17PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB2, 0x1B, 0xE0, 0xCF, 0x3C, 0xF3, 0xCC, 0x09, 0x86,
  0x41, 0xB1, 0xEF, 0x7B, 0xC4, 0xC1, 0x33, 0xCE, 0xF7, 0x8D, 0x83, 0x60,
  0x98, 0x18, 0x0C, 0x0F, 0x8F, 0xEC, 0xB6, 0x43, 0xA0, 0xFC, 0x3F, 0x05,
  0x82, 0xF9, 0x6F, 0xF3, 0xF0, 0x60, 0x30, 0x70, 0xFE, 0x2C, 0x9B, 0x24,
  0xFB, 0x1C, 0x00, 0x38, 0xDF, 0x34, 0xD9, 0x36, 0x7F, 0x0E, 0x1C, 0x0F,
  0x86, 0x31, 0x80, 0x30, 0x0E, 0x77, 0xDF, 0xB4, 0xC7, 0x38, 0xC7, 0xD8,
  0xE7, 0xFF, 0xC0, 0x1C, 0xC6, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x04, 0x18,
  0x60, 0xC1, 0xC0, 0xE0, 0xC1, 0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC6,
  0x18, 0xCE, 0x00, 0x18, 0x0C, 0x26, 0x5F, 0xF7, 0xE1, 0xE1, 0xD8, 0xCE,
  0x44, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x76, 0x6E,
  0xCC, 0xFF, 0xF0, 0x6F, 0x60, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x3C, 0x3F, 0x38, 0xD8,
  0x6D, 0xBE, 0xDF, 0x6F, 0x87, 0xC3, 0x71, 0x9F, 0x87, 0x80, 0x3C, 0x3E,
  0x1B, 0x1D, 0x8C, 0xC4, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0xEF, 0xF0,
  0x3C, 0x7E, 0xC7, 0x43, 0x03, 0x06, 0x0E, 0x1C, 0x30, 0xE0, 0xFF, 0xFF,
  0x3C, 0xFF, 0xC7, 0x03, 0x07, 0x3E, 0x3E, 0x03, 0x83, 0xC3, 0xFF, 0x7C,
  0x07, 0x03, 0xC0, 0xF0, 0x6C, 0x13, 0x0C, 0xC6, 0x31, 0x8C, 0xFF, 0xFF,
  0xF0, 0x30, 0x0C, 0x7F, 0x7F, 0x40, 0xC0, 0xDE, 0xFF, 0xE3, 0x03, 0x43,
  0xC3, 0x7F, 0x3C, 0x1E, 0x1C, 0x1C, 0x0C, 0x0F, 0xE7, 0xFB, 0x8D, 0x86,
  0xC3, 0xF1, 0x9F, 0xC7, 0x80, 0xFF, 0xFF, 0xC3, 0xC7, 0x06, 0x06, 0x0C,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x3E, 0x7F, 0xE3, 0xC3, 0xE3, 0x7E, 0x7E,
  0xC3, 0xC3, 0xC3, 0xFF, 0x3E, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xE3, 0xFF,
  0x7B, 0x06, 0x0E, 0x1C, 0x78, 0x6F, 0x60, 0x00, 0x6F, 0x60, 0x6F, 0x60,
  0x00, 0x76, 0x6E, 0xCC, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x3C, 0x7E, 0xE7, 0x43, 0x07, 0x1E,
  0x18, 0x18, 0x00, 0x38, 0x38, 0x38, 0x3C, 0x7F, 0xE3, 0xCD, 0xDF, 0x99,
  0x91, 0x91, 0x9F, 0xDD, 0xC0, 0xE0, 0x7E, 0x3E, 0x1E, 0x07, 0x81, 0xE0,
  0x7C, 0x33, 0x0C, 0xC3, 0x31, 0xFE, 0x7F, 0x98, 0x66, 0x1F, 0x87, 0xFE,
  0xFF, 0xE3, 0xE3, 0xE3, 0xFE, 0xFE, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0x3C,
  0x7F, 0xE3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xE3, 0x7F, 0x3C, 0xFC,
  0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x0F, 0x86, 0xC3, 0x63, 0xBF, 0x9F,
  0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x3C, 0x7E, 0xE7, 0xC3, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3, 0xE3, 0x7F,
  0x3B, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x47, 0xC6, 0x7E,
  0x3C, 0xC3, 0xE3, 0xB1, 0x99, 0x8D, 0xC7, 0xC3, 0xF1, 0xDC, 0xC6, 0x63,
  0xB0, 0xD8, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0xFF, 0xF0, 0xE3, 0xE7, 0xE7, 0xF5, 0xFD, 0xDB, 0xDB, 0xCB, 0xD3, 0xC3,
  0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xD3, 0xDB, 0xDB, 0xCF, 0xCF, 0xCF,
  0xC7, 0xC7, 0x3C, 0x3F, 0x38, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0x71, 0x9F, 0x87, 0x80, 0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3C, 0x3F, 0x38, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0x71, 0x9F, 0xC7, 0x81, 0x80, 0xF8, 0x3C, 0xFE, 0x7F, 0xB8,
  0xDC, 0x6E, 0x37, 0x1B, 0xFD, 0xFC, 0xEE, 0x73, 0x39, 0xDC, 0x70, 0x3E,
  0x7F, 0xE3, 0xC0, 0xE0, 0x7E, 0x3F, 0x03, 0x83, 0xC3, 0xFF, 0x3C, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7,
  0x7F, 0x3E, 0xE1, 0xD8, 0x76, 0x19, 0xC6, 0x73, 0x8C, 0xC3, 0x30, 0xEC,
  0x1B, 0x07, 0x81, 0xE0, 0x78, 0xC0, 0xF0, 0x3C, 0x0D, 0x33, 0x4C, 0xDB,
  0xB7, 0xE9, 0xEA, 0x7A, 0x9C, 0xA7, 0x39, 0xCE, 0xE1, 0xDC, 0x63, 0x30,
  0xEC, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x33, 0x0C, 0xE6, 0x1B, 0x87, 0xE1,
  0xD8, 0x67, 0x38, 0xCC, 0x1F, 0x07, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFF, 0xE0, 0x1C, 0x1E, 0x0F, 0x8C, 0xC6, 0x76, 0x1B, 0x0F, 0x04,
  0xFF, 0xFF, 0x59, 0x90, 0x3C, 0x3F, 0x31, 0xC0, 0xE7, 0xF6, 0x3B, 0x1D,
  0xF7, 0x7B, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE, 0xDF, 0xE3, 0xC3, 0xC3,
  0xC3, 0xE3, 0xDF, 0xDE, 0x3C, 0x7E, 0xE3, 0xC0, 0xC0, 0xC0, 0xE3, 0x7F,
  0x3E, 0x03, 0x03, 0x03, 0x03, 0x7B, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3,
  0xFF, 0x7B, 0x3C, 0x7E, 0xE3, 0xC3, 0xFF, 0xC0, 0xE2, 0x7F, 0x3E, 0x0F,
  0x1F, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x03, 0x01, 0x8F, 0x8F, 0xCE, 0x37, 0x19, 0xF8, 0x78, 0x40, 0x7F, 0x9F,
  0xF8, 0x3F, 0xFB, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0xCE, 0xDF, 0xE7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x38, 0x70, 0xE0, 0x0F, 0x9F, 0x06, 0x0C,
  0x18, 0x30, 0x67, 0xFF, 0xE0, 0x1C, 0x71, 0xC0, 0xFB, 0xE1, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x6F, 0xBE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3E, 0x33,
  0x31, 0xB0, 0xFC, 0x76, 0x31, 0x98, 0xEC, 0x38, 0xF8, 0xF8, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xB3, 0x5F, 0xB6,
  0x73, 0x39, 0x9C, 0xCE, 0x67, 0x33, 0x99, 0x80, 0xCE, 0xDF, 0xE7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7E, 0x3C, 0xDE, 0xDF, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xDF, 0xDE, 0xC0,
  0xC0, 0xC0, 0x7B, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0x7B, 0x03,
  0x03, 0x03, 0xFB, 0xFF, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE1, 0xFE, 0xFF,
  0x00, 0x3E, 0x7F, 0xE2, 0xFC, 0x7F, 0x1F, 0x43, 0xFF, 0x7C, 0x30, 0x30,
  0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7B, 0x7B, 0xC3, 0xE1, 0x98, 0xCC, 0xC6,
  0x61, 0xB0, 0xF0, 0x78, 0x1C, 0x00, 0xCC, 0xF3, 0x34, 0xED, 0x3B, 0x7A,
  0x9E, 0xA7, 0x29, 0xCE, 0x73, 0x80, 0xE3, 0x33, 0x0F, 0x87, 0x81, 0x81,
  0xE1, 0xF8, 0xCE, 0xC3, 0x80, 0xE1, 0xD8, 0x63, 0x18, 0xCC, 0x33, 0x06,
  0x81, 0xE0, 0x38, 0x0C, 0x03, 0x07, 0x81, 0xE0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFF, 0xFF, 0x3E, 0x7C, 0x81, 0x81, 0x03, 0x3C, 0x78,
  0x18, 0x30, 0xC1, 0x02, 0x07, 0xCF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1,
  0xF0, 0x60, 0x82, 0x0C, 0x0F, 0x9F, 0x60, 0x40, 0xC0, 0x81, 0x9F, 0x3C,
  0x00, 0x71, 0xFC, 0xB7, 0xD1, 0xC0,
};

const GFXglyph IBMPlexMono_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 6, 5, 10, 2, -13 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 9, 16, 10, 1, -14 },
  { 43, 10, 12, 10, 0, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 2, 5, 10, 4, -13 },
  { 75, 6, 15, 10, 3, -13 },
  { 87, 6, 15, 10, 1, -13 },
  { 99, 9, 9, 10, 1, -9 },
  { 110, 8, 8, 10, 1, -9 },
  { 118, 4, 6, 10, 3, -3 },
  { 121, 6, 2, 10, 2, -6 },
  { 123, 4, 3, 10, 3, -3 },
  { 125, 8, 15, 10, 1, -13 },
  { 140, 9, 12, 10, 1, -12 },
  { 154, 9, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 8, 12, 10, 1, -12 },
  { 192, 10, 12, 10, 0, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 9, 12, 10, 1, -12 },
  { 233, 8, 12, 10, 1, -12 },
  { 245, 8, 12, 10, 1, -12 },
  { 257, 8, 12, 10, 1, -12 },
  { 269, 4, 9, 10, 3, -9 },
  { 274, 4, 12, 10, 3, -9 },
  { 280, 8, 10, 10, 1, -10 },
  { 290, 8, 6, 10, 1, -8 },
  { 296, 8, 10, 10, 1, -10 },
  { 306, 8, 12, 10, 1, -12 },
  { 318, 8, 14, 10, 1, -12 },
  { 332, 10, 12, 10, 0, -12 },
  { 347, 8, 12, 10, 1, -12 },
  { 359, 8, 12, 10, 1, -12 },
  { 371, 9, 12, 10, 1, -12 },
  { 385, 8, 12, 10, 1, -12 },
  { 397, 8, 12, 10, 1, -12 },
  { 409, 8, 12, 10, 1, -12 },
  { 421, 8, 12, 10, 1, -12 },
  { 433, 8, 12, 10, 1, -12 },
  { 445, 8, 12, 10, 1, -12 },
  { 457, 9, 12, 10, 1, -12 },
  { 471, 7, 12, 10, 2, -12 },
  { 482, 8, 12, 10, 1, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 9, 12, 10, 1, -12 },
  { 520, 8, 12, 10, 1, -12 },
  { 532, 9, 15, 10, 1, -12 },
  { 549, 9, 12, 10, 1, -12 },
  { 563, 8, 12, 10, 1, -12 },
  { 575, 10, 12, 10, 0, -12 },
  { 590, 8, 12, 10, 1, -12 },
  { 602, 10, 12, 10, 0, -12 },
  { 617, 10, 12, 10, 0, -12 },
  { 632, 10, 12, 10, 0, -12 },
  { 647, 10, 12, 10, 0, -12 },
  { 662, 8, 12, 10, 1, -12 },
  { 674, 6, 15, 10, 3, -13 },
  { 686, 8, 15, 10, 1, -13 },
  { 701, 5, 15, 10, 2, -13 },
  { 711, 9, 8, 10, 1, -12 },
  { 720, 8, 2, 10, 1, 1 },
  { 722, 3, 4, 10, 3, -14 },
  { 724, 9, 9, 10, 1, -9 },
  { 735, 8, 13, 10, 1, -13 },
  { 748, 8, 9, 10, 1, -9 },
  { 757, 8, 13, 10, 1, -13 },
  { 770, 8, 9, 10, 1, -9 },
  { 779, 8, 13, 10, 1, -13 },
  { 792, 9, 14, 10, 1, -11 },
  { 808, 8, 13, 10, 1, -13 },
  { 821, 7, 13, 10, 2, -13 },
  { 833, 6, 16, 10, 2, -13 },
  { 845, 9, 13, 10, 1, -13 },
  { 860, 8, 13, 10, 1, -13 },
  { 873, 9, 9, 10, 1, -9 },
  { 884, 8, 9, 10, 1, -9 },
  { 893, 8, 9, 10, 1, -9 },
  { 902, 8, 12, 10, 1, -9 },
  { 914, 8, 12, 10, 1, -9 },
  { 926, 9, 9, 10, 1, -9 },
  { 937, 8, 9, 10, 1, -9 },
  { 946, 8, 12, 10, 1, -12 },
  { 958, 8, 9, 10, 1, -9 },
  { 967, 9, 9, 10, 1, -9 },
  { 978, 10, 9, 10, 0, -9 },
  { 990, 9, 9, 10, 1, -9 },
  { 1001, 10, 12, 10, 0, -9 },
  { 1016, 8, 9, 10, 1, -9 },
  { 1025, 7, 15, 10, 2, -13 },
  { 1039, 2, 15, 10, 4, -13 },
  { 1043, 7, 15, 10, 2, -13 },
  { 1057, 9, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_SEMIBOLD17PT7B_H_
