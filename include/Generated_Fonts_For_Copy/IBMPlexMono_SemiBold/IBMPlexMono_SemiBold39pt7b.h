#ifndef _IBMPLEXMONO_SEMIBOLD39PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF1, 0xC3,
  0x87, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x1F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F,
  0xC7, 0xFC, 0xFF, 0x8F, 0xF8, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0xFF, 0x87, 0xF9, 0xFF, 0x0F,
  0xF3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC0, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0x7B, 0xF1, 0xF3, 0xC7, 0x1F, 0x1E, 0x10, 0xF8, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x3C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0x9F, 0x80, 0x3C,
  0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x10, 0x78, 0xF9, 0xE3, 0xCF, 0xDF,
  0x9E, 0xFD, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x1E, 0x7F, 0xC0, 0x78, 0xFF, 0x80, 0xF3, 0xFF, 0x83, 0xC7, 0x8F,
  0x07, 0x8E, 0x0E, 0x1E, 0x3C, 0x1C, 0x3C, 0x78, 0x38, 0xF0, 0x70, 0x71,
  0xE0, 0xF1, 0xE7, 0x81, 0xFF, 0xDE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xDF, 0xFC,
  0x0F, 0x3C, 0x3C, 0x1E, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC3, 0xC7, 0x87, 0x87, 0x9E, 0x0F, 0xFE, 0x3C, 0x0F, 0xFC, 0xF0,
  0x0F, 0xF3, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x38, 0x03, 0xC0, 0x80,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF, 0x87, 0xE7, 0xFF, 0x1F, 0x9F, 0x7C,
  0x78, 0xF8, 0xF9, 0xC3, 0xE1, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0,
  0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC1, 0xFC, 0x1F, 0xFE, 0xF8, 0x7F,
  0xF9, 0xF0, 0xFF, 0xC7, 0xE0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x3E, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x30,
  0x3C, 0x19, 0xF1, 0xE7, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0x7E, 0x01, 0xF1, 0xF0, 0x1F, 0x87, 0xC0, 0xF8, 0x1F, 0x03, 0x80, 0xE0,
  0x08, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0x9F,
  0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0xE1, 0xFF,
  0xCF, 0x8F, 0xFE, 0x7C, 0x7F, 0xF3, 0xE3, 0xFF, 0x8E, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F,
  0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8,
  0x7C, 0x07, 0x07, 0xC0, 0x20, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE1, 0xFD, 0xF8,
  0x0F, 0xBE, 0x01, 0xF8, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0x07, 0xE3, 0xC0, 0x3F, 0x08, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF1, 0x00, 0x1F, 0x38, 0x01, 0xF7, 0xC0, 0x3F, 0xFE,
  0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7B, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x87, 0xC0,
  0x79, 0xFF, 0x07, 0xBF, 0xFC, 0x7B, 0xFF, 0xC7, 0xE0, 0xFE, 0x7C, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF1, 0x00,
  0x3F, 0x38, 0x03, 0xE7, 0x80, 0x7E, 0xFE, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x7D, 0xFF, 0x87, 0xFF,
  0xFC, 0xFB, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xE7,
  0xC0, 0x3E, 0x7E, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xE7, 0xC0, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3E, 0x0F, 0xC1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xE0, 0xFE,
  0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3E, 0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xEF, 0xE0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xBE, 0x1F, 0xF7, 0xC0, 0x7C,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78,
  0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xC1, 0xFF, 0xC0, 0x7D, 0xC0, 0x3E,
  0x20, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0xF0, 0x7D, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0xFF, 0xFF,
  0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x3F, 0x8E, 0x07, 0xF1, 0xC0, 0xFE,
  0x38, 0x1F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1F, 0xFF, 0xE3, 0xFD, 0xFC,
  0x3F, 0xBB, 0xC3, 0xE7, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x78, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xE7, 0xE0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x1D, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1C, 0x7C, 0x03,
  0xF7, 0xE0, 0x3E, 0x3F, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0x83, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x0F, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00,
  0xFF, 0xE0, 0x1E, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xFC, 0x0F,
  0xDF, 0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFB, 0xE3, 0xFE, 0x7C, 0x1F, 0x8F,
  0x80, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x60, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xE7, 0xE1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8,
  0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F,
  0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x7C, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80,
  0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0x79, 0xFF, 0xF7, 0x9D, 0xFF, 0x7B, 0xDF, 0xF3, 0xFD, 0xFF, 0x3F,
  0x9F, 0xF1, 0xF9, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x0F, 0x1F, 0xF0,
  0xE1, 0xFF, 0x0E, 0x1F, 0xF0, 0x61, 0xFF, 0x04, 0x1F, 0xF0, 0x41, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xF0, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xF7, 0x87, 0xFD,
  0xE1, 0xFF, 0x7C, 0x7F, 0xCF, 0x1F, 0xF3, 0xE7, 0xFC, 0x79, 0xFF, 0x1E,
  0x7F, 0xC7, 0xDF, 0xF0, 0xF7, 0xFC, 0x3D, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x1F,
  0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xE7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0x3E, 0x1F, 0x00, 0x61, 0xF8,
  0x01, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF1,
  0x00, 0x1F, 0x1E, 0x00, 0xF9, 0xFC, 0x1F, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0x9F, 0x83, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF9,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x0F, 0x87, 0xBE, 0x3E, 0x1E, 0xF8,
  0xFC, 0x7B, 0xE3, 0xF1, 0xEF, 0x8F, 0xC7, 0xBE, 0x7F, 0x1E, 0x79, 0xDC,
  0x79, 0xE7, 0x71, 0xE7, 0x9D, 0xE7, 0x9E, 0x77, 0x9E, 0x79, 0xCE, 0x79,
  0xEF, 0x3B, 0xE7, 0xB8, 0xEF, 0x1E, 0xE3, 0xBC, 0x7B, 0x8F, 0xF1, 0xEE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0x7F, 0x00, 0xFC, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x00, 0xF8, 0xFC, 0x03,
  0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xF0, 0x1F,
  0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x7C, 0x01,
  0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3E,
  0x03, 0xE0, 0xFC, 0x07, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03,
  0xEF, 0x80, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x30, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x38, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F,
  0x0F, 0x04, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8,
  0x7C, 0x1F, 0x83, 0x80, 0xFC, 0x10, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0x7F, 0x3F,
  0xE3, 0xF0, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x1F, 0x83, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8,
  0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x7E, 0xFC, 0x1F, 0xDF, 0xFF, 0xF3, 0xEF, 0xFE, 0x7C, 0xFF, 0x8F, 0x8F,
  0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F,
  0xBF, 0x01, 0xDF, 0x80, 0x43, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x8F, 0xC0, 0x79, 0xF8,
  0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x7C, 0x7F, 0xCF,
  0x9F, 0xFD, 0xF7, 0xFF, 0xBE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0x7C,
  0xFF, 0xEF, 0x8F, 0xF9, 0xF0, 0x7C, 0x3E, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x07, 0xDE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x43, 0xF8, 0x3C, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0xE0, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x38, 0x01, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x3F, 0x0F, 0x9F,
  0xE3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x0F,
  0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE,
  0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F,
  0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xC1, 0xE7, 0xDF, 0x1F, 0xBF, 0xFD, 0xFD,
  0xFF, 0xEF, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x3F, 0xE1, 0xE1, 0xFF, 0x0F,
  0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF,
  0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78,
  0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xF0, 0xF8, 0xFC, 0x3E,
  0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xF8, 0xFC, 0x1F, 0x3F,
  0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC1, 0xFD, 0xF0, 0x1F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF,
  0x9F, 0x7F, 0xF3, 0xE7, 0xFC, 0x7C, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC3, 0xE3, 0xFE, 0x7C, 0xFF, 0xEF, 0xBF, 0xFD,
  0xF7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0xFB, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF,
  0x83, 0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF0, 0x7D, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xE0, 0x38, 0xF8, 0x02,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xCC, 0x00, 0xFB, 0xE0, 0x3E,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xBF, 0xF7, 0xCF, 0xFB, 0xE1, 0xF1, 0xF0, 0xFC, 0x00,
  0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x0F,
  0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x83, 0xFC,
  0x3F, 0x1E, 0xF0, 0xFC, 0x7B, 0xC3, 0xF1, 0xEF, 0x1D, 0xC7, 0x9E, 0x77,
  0x1E, 0x79, 0xDE, 0x79, 0xE7, 0x39, 0xE7, 0x9C, 0xE7, 0x9E, 0x73, 0x9C,
  0x7B, 0x8E, 0x71, 0xEE, 0x3B, 0xC7, 0xB8, 0xFF, 0x0E, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x01,
  0xF9, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3F, 0x0F, 0x80, 0xFC, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xEF, 0x80, 0x3E,
  0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xFD,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0xE3, 0xF8, 0x0F, 0x3F, 0xC0, 0xF7,
  0xFE, 0x1E, 0x79, 0xF1, 0xEF, 0x0F, 0x9E, 0xF0, 0xFF, 0xCF, 0x07, 0xFC,
  0xE0, 0x3F, 0x86, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 7, 27, 23, 8, -27 },
  { 25, 13, 12, 23, 5, -29 },
  { 45, 23, 27, 23, 0, -27 },
  { 123, 21, 35, 23, 1, -31 },
  { 215, 23, 27, 23, 0, -27 },
  { 293, 22, 27, 23, 1, -27 },
  { 368, 5, 12, 23, 9, -29 },
  { 376, 13, 35, 23, 7, -30 },
  { 433, 13, 35, 23, 3, -30 },
  { 490, 21, 20, 23, 1, -21 },
  { 543, 19, 18, 23, 2, -21 },
  { 586, 9, 12, 23, 7, -6 },
  { 600, 12, 4, 23, 6, -14 },
  { 606, 7, 7, 23, 8, -7 },
  { 613, 17, 35, 23, 3, -30 },
  { 688, 21, 27, 23, 1, -27 },
  { 759, 20, 27, 23, 2, -27 },
  { 827, 19, 27, 23, 2, -27 },
  { 892, 20, 27, 23, 1, -27 },
  { 960, 21, 27, 23, 1, -27 },
  { 1031, 20, 27, 23, 2, -27 },
  { 1099, 20, 27, 23, 2, -27 },
  { 1167, 19, 27, 23, 2, -27 },
  { 1232, 20, 27, 23, 2, -27 },
  { 1300, 20, 27, 23, 2, -27 },
  { 1368, 7, 21, 23, 8, -21 },
  { 1387, 9, 27, 23, 7, -21 },
  { 1418, 17, 23, 23, 3, -23 },
  { 1467, 19, 12, 23, 2, -18 },
  { 1496, 17, 23, 23, 3, -23 },
  { 1545, 17, 27, 23, 3, -27 },
  { 1603, 19, 31, 23, 2, -27 },
  { 1677, 23, 27, 23, 0, -27 },
  { 1755, 19, 27, 23, 3, -27 },
  { 1820, 20, 27, 23, 2, -27 },
  { 1888, 19, 27, 23, 3, -27 },
  { 1953, 17, 27, 23, 3, -27 },
  { 2011, 18, 27, 23, 3, -27 },
  { 2072, 19, 27, 23, 2, -27 },
  { 2137, 18, 27, 23, 3, -27 },
  { 2198, 17, 27, 23, 3, -27 },
  { 2256, 18, 27, 23, 2, -27 },
  { 2317, 20, 27, 23, 3, -27 },
  { 2385, 17, 27, 23, 4, -27 },
  { 2443, 20, 27, 23, 2, -27 },
  { 2511, 18, 27, 23, 3, -27 },
  { 2572, 21, 27, 23, 1, -27 },
  { 2643, 19, 27, 23, 3, -27 },
  { 2708, 21, 34, 23, 1, -27 },
  { 2798, 19, 27, 23, 3, -27 },
  { 2863, 21, 27, 23, 1, -27 },
  { 2934, 21, 27, 23, 1, -27 },
  { 3005, 19, 27, 23, 2, -27 },
  { 3070, 22, 27, 23, 1, -27 },
  { 3145, 22, 27, 23, 1, -27 },
  { 3220, 22, 27, 23, 1, -27 },
  { 3295, 23, 27, 23, 0, -27 },
  { 3373, 20, 27, 23, 2, -27 },
  { 3441, 12, 35, 23, 8, -30 },
  { 3494, 17, 35, 23, 3, -30 },
  { 3569, 12, 35, 23, 4, -30 },
  { 3622, 21, 17, 23, 1, -27 },
  { 3667, 19, 4, 23, 2, 3 },
  { 3677, 8, 9, 23, 6, -31 },
  { 3686, 20, 20, 23, 2, -20 },
  { 3736, 19, 29, 23, 3, -29 },
  { 3805, 18, 20, 23, 3, -20 },
  { 3850, 19, 29, 23, 2, -29 },
  { 3919, 19, 20, 23, 2, -20 },
  { 3967, 19, 29, 23, 3, -29 },
  { 4036, 20, 32, 23, 2, -24 },
  { 4116, 18, 29, 23, 3, -29 },
  { 4182, 18, 30, 23, 4, -30 },
  { 4250, 14, 38, 23, 4, -30 },
  { 4317, 20, 29, 23, 3, -29 },
  { 4390, 18, 29, 23, 3, -29 },
  { 4456, 21, 20, 23, 1, -20 },
  { 4509, 18, 20, 23, 3, -20 },
  { 4554, 20, 20, 23, 2, -20 },
  { 4604, 19, 28, 23, 3, -20 },
  { 4671, 19, 28, 23, 2, -20 },
  { 4738, 19, 20, 23, 3, -20 },
  { 4786, 19, 20, 23, 2, -20 },
  { 4834, 19, 27, 23, 2, -27 },
  { 4899, 17, 20, 23, 3, -20 },
  { 4942, 21, 20, 23, 1, -20 },
  { 4995, 22, 20, 23, 1, -20 },
  { 5050, 21, 20, 23, 1, -20 },
  { 5103, 21, 28, 23, 1, -20 },
  { 5177, 18, 20, 23, 3, -20 },
  { 5222, 16, 35, 23, 4, -30 },
  { 5292, 4, 35, 23, 10, -30 },
  { 5310, 16, 35, 23, 4, -30 },
  { 5380, 20, 10, 23, 2, -17 },
};

const GFXfont IBMPlexMono_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_SEMIBOLD39PT7B_H_
