#ifndef _IBMPLEXMONO_SEMIBOLD20PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0xF6, 0xCF, 0x3C, 0xF3, 0xCF,
  0x30, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xDC, 0x7D, 0xF7, 0x9F, 0x19, 0x81,
  0x98, 0xF9, 0xEF, 0xBE, 0x3B, 0x03, 0x30, 0x33, 0x03, 0x30, 0x0C, 0x03,
  0x03, 0xF1, 0xFF, 0xED, 0xBB, 0x0E, 0xC1, 0xF0, 0x7F, 0x07, 0xF0, 0xDC,
  0x33, 0x8C, 0xFB, 0x7F, 0xF8, 0xFC, 0x0C, 0x03, 0x00, 0x38, 0x37, 0xC6,
  0xCC, 0x6C, 0x4C, 0xCC, 0xC7, 0xD8, 0x38, 0x00, 0x1C, 0x1B, 0xE3, 0x33,
  0x32, 0x36, 0x33, 0x63, 0xEC, 0x1C, 0x1E, 0x03, 0xF0, 0x31, 0x87, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0xE7, 0xCE, 0x6E, 0xCE, 0x7C, 0xE3, 0x86, 0x3C,
  0x7E, 0xE3, 0xC7, 0xFF, 0xF0, 0x1C, 0xE3, 0x18, 0x63, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x18, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x8C, 0x73, 0x80, 0x0C, 0x03, 0x00,
  0xC3, 0xB7, 0xFF, 0xCF, 0xC1, 0xE0, 0xFC, 0x73, 0x88, 0x40, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F,
  0xEE, 0xCC, 0xFF, 0xF0, 0x6F, 0xF6, 0x03, 0x03, 0x07, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0xC0,
  0x1E, 0x1F, 0xE6, 0x1B, 0x87, 0xC0, 0xF3, 0x3C, 0xCF, 0x33, 0xC0, 0xF0,
  0x3E, 0x1D, 0x86, 0x7F, 0x87, 0x80, 0x1E, 0x0F, 0x87, 0x63, 0x98, 0xE6,
  0x11, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x7F, 0xDF, 0xF0,
  0x3E, 0x1F, 0xEE, 0x39, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC0, 0xFF, 0xFF, 0xF0, 0x3E, 0x1F, 0xEE, 0x39, 0x07, 0x01,
  0xC0, 0xE1, 0xF0, 0x7C, 0x03, 0x80, 0x74, 0x1F, 0x8F, 0xFF, 0x8F, 0x80,
  0x07, 0x83, 0xE0, 0xF8, 0x6E, 0x3B, 0x8C, 0xE6, 0x3B, 0x8E, 0xC3, 0xBF,
  0xFF, 0xFC, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x1B, 0xC7, 0xF9, 0x87, 0x81, 0xC0, 0x74, 0x1F, 0x87, 0x7F, 0x8F, 0x80,
  0x0F, 0x87, 0x83, 0x80, 0xC0, 0x70, 0x3B, 0xCF, 0xFB, 0x87, 0xE1, 0xF8,
  0x7E, 0x1D, 0x87, 0x7F, 0x87, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0x06, 0xC3,
  0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00,
  0x3F, 0x1F, 0xEE, 0x1F, 0x87, 0xE1, 0xD8, 0x63, 0xF1, 0xFE, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x7F, 0x8F, 0xC0, 0x3E, 0x1F, 0xEE, 0x1B, 0x87, 0xE1,
  0xF8, 0x7E, 0x1D, 0xFF, 0x3D, 0xC0, 0xE0, 0x30, 0x1C, 0x1E, 0x1F, 0x00,
  0x6F, 0xF6, 0x00, 0x06, 0xFF, 0x60, 0x6F, 0xF6, 0x00, 0x00, 0x7F, 0xEE,
  0xCC, 0x01, 0x03, 0x0F, 0x3C, 0xF8, 0xE0, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0xC0, 0xF0,
  0x3C, 0x1F, 0x07, 0x07, 0x1F, 0x3C, 0xF0, 0xC0, 0x80, 0x3E, 0x3F, 0xD8,
  0xFC, 0x30, 0x38, 0x78, 0x78, 0x38, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x1F, 0x1F, 0xE6, 0x1B, 0x03, 0xCE, 0xF3, 0xFD, 0xCF, 0x63, 0xD8,
  0xF7, 0x3C, 0xFF, 0x3B, 0xE0, 0x1C, 0x03, 0xF0, 0x7C, 0x0F, 0x00, 0xF0,
  0x1F, 0x81, 0xF8, 0x19, 0x81, 0x98, 0x39, 0xC3, 0x1C, 0x3F, 0xC3, 0xFC,
  0x70, 0xE7, 0x0E, 0x60, 0x6E, 0x07, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E,
  0x1B, 0xF9, 0xFE, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xF7, 0xF0, 0x1F, 0x0F,
  0xE7, 0x1F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x1D,
  0xC7, 0x3F, 0x87, 0xC0, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xFF, 0xBF, 0x80, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE0, 0x38, 0x0E,
  0x7F, 0x9F, 0xE1, 0xF8, 0x7E, 0x1D, 0xC7, 0x7F, 0xCF, 0x70, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0x9F, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xF8, 0xFC, 0x77, 0xF1, 0xF0, 0xE1, 0xFC,
  0x3B, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x87, 0xF0, 0xF7, 0x1C, 0xE3,
  0x8E, 0x70, 0xEE, 0x1D, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xE1, 0xFC,
  0x7F, 0x3F, 0xCF, 0xDA, 0xF7, 0xBD, 0xEF, 0x33, 0xCC, 0xF3, 0x3C, 0x8F,
  0x03, 0xC0, 0xF0, 0x30, 0xF1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xFF, 0x7E,
  0xDF, 0xB7, 0xEF, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xF0, 0x1E, 0x1F,
  0xE6, 0x1B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D,
  0x86, 0x7F, 0x87, 0x80, 0xFE, 0x7F, 0xB0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0xFE, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x1E, 0x1F, 0xE6, 0x1B,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x7F,
  0x8F, 0xC0, 0xC0, 0x30, 0x0F, 0x81, 0xE0, 0xFE, 0x7F, 0xB0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xFE, 0xFE, 0x67, 0x31, 0x98, 0xEC, 0x36, 0x1C, 0x3F,
  0x1F, 0xFE, 0x1B, 0x80, 0xE0, 0x1C, 0x07, 0xF0, 0x7E, 0x01, 0xC0, 0x74,
  0x1F, 0x87, 0xFF, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x7F, 0x8F, 0xC0, 0xE0, 0x77, 0x06, 0x70,
  0xE7, 0x0E, 0x30, 0xC3, 0x8C, 0x39, 0xC3, 0x9C, 0x19, 0x81, 0xD8, 0x1F,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0xE0, 0x7E, 0x07, 0x60, 0x66, 0x66, 0x67,
  0x66, 0xF6, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0x96, 0x69, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x70, 0xF7, 0x0E, 0x39, 0xC1, 0x9C, 0x1F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x81, 0xB8, 0x39, 0xC3, 0x1C, 0x70, 0xEE, 0x0F, 0xE0,
  0x77, 0x0E, 0x70, 0xE3, 0x9C, 0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0,
  0x1E, 0x07, 0x83, 0xF0, 0xCC, 0x73, 0x98, 0x6E, 0x1F, 0x03, 0x40, 0x80,
  0xFF, 0xFF, 0xF0, 0xE6, 0x33, 0x3E, 0x1F, 0xEE, 0x38, 0x06, 0x3F, 0x9F,
  0xEE, 0x1B, 0x8E, 0xFD, 0xDF, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3B, 0xCF, 0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xEE,
  0xF0, 0x1F, 0x0F, 0xE7, 0x1D, 0x80, 0xE0, 0x38, 0x06, 0x11, 0xC7, 0x3F,
  0x87, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x77, 0xFF, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDF, 0xF3, 0xDC, 0x1E, 0x1F, 0xE6,
  0x1B, 0x87, 0xFF, 0xFF, 0xFE, 0x01, 0x86, 0x7F, 0xC7, 0xC0, 0x07, 0xC3,
  0xF0, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x01, 0xC0, 0x38, 0xFC, 0x3F, 0xC6, 0x38,
  0xC3, 0x18, 0xE3, 0xFC, 0x1E, 0x0C, 0x01, 0xFE, 0x1F, 0xE4, 0x0D, 0x81,
  0xFF, 0xF3, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB,
  0xC6, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x1C, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC7, 0xFF, 0xFE, 0x0E, 0x1C, 0x38, 0x00, 0x1F, 0xFF, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFB, 0xF0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xEC, 0x73, 0x38, 0xDC, 0x3F, 0x0F, 0xC3, 0x38, 0xC7,
  0x30, 0xEC, 0x3C, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0xD9, 0xFF,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x30, 0xEF,
  0x3F, 0xEF, 0x1B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70,
  0x1E, 0x1F, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0x87,
  0x80, 0xEF, 0x3F, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF,
  0xBB, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3D, 0xDF, 0xFE, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0xFD, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF,
  0xBF, 0xE0, 0x3F, 0x1F, 0xE6, 0x19, 0x80, 0x7F, 0x0F, 0xE0, 0x1D, 0x87,
  0xFF, 0x8F, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xFF, 0xF1, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xC3, 0xF0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x8F, 0x7F, 0xCF, 0x70, 0xE1, 0xF8,
  0x76, 0x19, 0xC6, 0x73, 0x8C, 0xC3, 0xB0, 0x78, 0x1E, 0x07, 0x80, 0xC6,
  0x3E, 0x63, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0x96, 0x69, 0x66, 0x9E, 0x79,
  0xE3, 0x9C, 0xE1, 0xDC, 0xE3, 0xB0, 0xF8, 0x1E, 0x07, 0x83, 0xF0, 0xCC,
  0x63, 0xB8, 0x70, 0xC0, 0xF8, 0x76, 0x19, 0xCE, 0x73, 0x8C, 0xC3, 0xF0,
  0x78, 0x1E, 0x03, 0x00, 0xC0, 0x70, 0xF8, 0x3C, 0x00, 0x7F, 0x9F, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0x3F,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0xF8, 0xF8, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFC, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x1F, 0x1F, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0xFC, 0xF8, 0x38, 0xDF, 0x3C, 0xCF, 0x3E, 0xC7, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 6, 6, 12, 3, -15 },
  { 13, 12, 14, 12, 0, -14 },
  { 34, 10, 18, 12, 1, -16 },
  { 57, 12, 14, 12, 0, -14 },
  { 78, 12, 14, 12, 0, -14 },
  { 99, 2, 6, 12, 5, -15 },
  { 101, 6, 18, 12, 4, -15 },
  { 115, 6, 18, 12, 2, -15 },
  { 129, 10, 10, 12, 1, -11 },
  { 142, 10, 10, 12, 1, -11 },
  { 155, 4, 6, 12, 4, -3 },
  { 158, 6, 2, 12, 3, -7 },
  { 160, 4, 4, 12, 4, -4 },
  { 162, 8, 18, 12, 2, -15 },
  { 180, 10, 14, 12, 1, -14 },
  { 198, 10, 14, 12, 1, -14 },
  { 216, 10, 14, 12, 1, -14 },
  { 234, 10, 14, 12, 1, -14 },
  { 252, 10, 14, 12, 1, -14 },
  { 270, 10, 14, 12, 1, -14 },
  { 288, 10, 14, 12, 1, -14 },
  { 306, 10, 14, 12, 1, -14 },
  { 324, 10, 14, 12, 1, -14 },
  { 342, 10, 14, 12, 1, -14 },
  { 360, 4, 11, 12, 4, -11 },
  { 366, 4, 14, 12, 4, -11 },
  { 373, 8, 12, 12, 2, -12 },
  { 385, 10, 6, 12, 1, -9 },
  { 393, 8, 12, 12, 2, -12 },
  { 405, 9, 14, 12, 1, -14 },
  { 421, 10, 16, 12, 1, -14 },
  { 441, 12, 14, 12, 0, -14 },
  { 462, 9, 14, 12, 2, -14 },
  { 478, 10, 14, 12, 1, -14 },
  { 496, 10, 14, 12, 1, -14 },
  { 514, 8, 14, 12, 2, -14 },
  { 528, 9, 14, 12, 2, -14 },
  { 544, 10, 14, 12, 1, -14 },
  { 562, 10, 14, 12, 1, -14 },
  { 580, 8, 14, 12, 2, -14 },
  { 594, 9, 14, 12, 1, -14 },
  { 610, 11, 14, 12, 1, -14 },
  { 630, 9, 14, 12, 2, -14 },
  { 646, 10, 14, 12, 1, -14 },
  { 664, 10, 14, 12, 1, -14 },
  { 682, 10, 14, 12, 1, -14 },
  { 700, 9, 14, 12, 2, -14 },
  { 716, 10, 18, 12, 1, -14 },
  { 739, 9, 14, 12, 2, -14 },
  { 755, 10, 14, 12, 1, -14 },
  { 773, 12, 14, 12, 0, -14 },
  { 794, 10, 14, 12, 1, -14 },
  { 812, 12, 14, 12, 0, -14 },
  { 833, 12, 14, 12, 0, -14 },
  { 854, 12, 14, 12, 0, -14 },
  { 875, 12, 14, 12, 0, -14 },
  { 896, 10, 14, 12, 1, -14 },
  { 914, 6, 18, 12, 4, -15 },
  { 928, 8, 18, 12, 2, -15 },
  { 946, 6, 18, 12, 2, -15 },
  { 960, 10, 9, 12, 1, -14 },
  { 972, 10, 2, 12, 1, 2 },
  { 975, 4, 4, 12, 3, -16 },
  { 977, 10, 10, 12, 1, -10 },
  { 990, 10, 15, 12, 1, -15 },
  { 1009, 10, 10, 12, 1, -10 },
  { 1022, 10, 15, 12, 1, -15 },
  { 1041, 10, 10, 12, 1, -10 },
  { 1054, 10, 15, 12, 1, -15 },
  { 1073, 11, 16, 12, 1, -12 },
  { 1095, 10, 15, 12, 1, -15 },
  { 1114, 9, 15, 12, 2, -15 },
  { 1131, 7, 19, 12, 2, -15 },
  { 1148, 10, 15, 12, 2, -15 },
  { 1167, 10, 15, 12, 1, -15 },
  { 1186, 10, 10, 12, 1, -10 },
  { 1199, 10, 10, 12, 1, -10 },
  { 1212, 10, 10, 12, 1, -10 },
  { 1225, 10, 14, 12, 1, -10 },
  { 1243, 10, 14, 12, 1, -10 },
  { 1261, 10, 10, 12, 1, -10 },
  { 1274, 10, 10, 12, 1, -10 },
  { 1287, 10, 14, 12, 1, -14 },
  { 1305, 10, 10, 12, 1, -10 },
  { 1318, 10, 10, 12, 1, -10 },
  { 1331, 12, 10, 12, 0, -10 },
  { 1346, 10, 10, 12, 1, -10 },
  { 1359, 10, 14, 12, 1, -10 },
  { 1377, 10, 10, 12, 1, -10 },
  { 1390, 8, 18, 12, 2, -15 },
  { 1408, 2, 18, 12, 5, -15 },
  { 1413, 8, 18, 12, 2, -15 },
  { 1431, 10, 5, 12, 1, -9 },
};

const GFXfont IBMPlexMono_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_SEMIBOLD20PT7B_H_
