#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0xFD,
  0xF3, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0xE3, 0xEF, 0x8F, 0x3E, 0x7C,
  0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE7,
  0xC0, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x78, 0xF0,
  0x03, 0xCF, 0x81, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xF9,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x1F, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0x9C, 0x3F,
  0x61, 0x0F, 0xD8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x6F, 0xC8, 0x1B, 0xE3,
  0x8E, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F,
  0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0xE0, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x1E, 0x07, 0xDF, 0x07,
  0x80, 0xF3, 0xE1, 0xF0, 0x3E, 0x7C, 0x7C, 0x07, 0xCF, 0x8F, 0x00, 0xF9,
  0xF3, 0xE0, 0x1E, 0x3C, 0xF8, 0x03, 0xCF, 0x9E, 0x3E, 0x7D, 0xF7, 0xDF,
  0xEF, 0xFD, 0xF7, 0xFE, 0xFF, 0x3C, 0xFF, 0xDF, 0xCF, 0xBE, 0x78, 0xE3,
  0xE7, 0xCF, 0x00, 0x78, 0xF1, 0xE0, 0x1F, 0x3E, 0x7C, 0x07, 0xC7, 0xCF,
  0x80, 0xF0, 0xF9, 0xF0, 0x3E, 0x1F, 0x7C, 0x0F, 0x83, 0xFF, 0x81, 0xE0,
  0x3F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF3, 0xF0, 0xFF, 0x87, 0xE3, 0xFF,
  0x9F, 0x8F, 0xFF, 0x3F, 0x3F, 0xFF, 0xFC, 0xFE, 0x7F, 0xF9, 0xF8, 0xFF,
  0xE3, 0xF0, 0xFF, 0xC7, 0xF0, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xF3, 0xF8, 0x7E, 0xF9, 0xF3,
  0xE7, 0xDF, 0x3E, 0x7C, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x21, 0xE0, 0x79, 0xE0, 0x7F, 0xE3, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0x7E, 0xF8, 0x3C, 0xF8, 0x0C,
  0x7C, 0x08, 0x60, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F,
  0x8F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF0, 0xF8, 0x00, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFE, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0xBF, 0x8F, 0xDF,
  0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFD, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7E, 0x3F, 0xBF, 0x1F, 0x9F, 0x9F, 0xCF, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x7F, 0xC3, 0xFF, 0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0x7E, 0x7B, 0xF0,
  0xCF, 0xC2, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xE3, 0xF8, 0x18, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x47, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xEF, 0xF0, 0x40, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0x01, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xDF, 0x01, 0xFF, 0xC0, 0xFB, 0xF0,
  0x7C, 0xFC, 0x1E, 0x3F, 0x0F, 0x9F, 0x87, 0xC7, 0xE5, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x02, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xCC, 0x07, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFC,
  0x61, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x9F, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF8, 0xFC, 0xFE,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0x9F,
  0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFC, 0xFC, 0xFC, 0x7E, 0x7E, 0x1F, 0xBE, 0x0F, 0xDF, 0x8F, 0xCF,
  0xEF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x60, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFD, 0xFC,
  0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xCF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0x7E, 0x0F, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x7F, 0xC7,
  0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0xF7, 0xF3, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x78, 0x3F, 0x8F, 0x3E, 0x3F, 0xF3, 0xCF, 0x1F, 0xFC,
  0xF7, 0xCF, 0xCF, 0x3D, 0xE3, 0xC7, 0xCF, 0x79, 0xF1, 0xE3, 0xFE, 0x78,
  0x78, 0xFF, 0x1E, 0x3E, 0x3F, 0xC7, 0x8F, 0x9F, 0xF3, 0xE3, 0xC7, 0xBC,
  0x79, 0xF3, 0xEF, 0x1F, 0xFF, 0xF3, 0xC7, 0xFF, 0xF8, 0xF8, 0xFC, 0xFC,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x0F,
  0xCF, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7,
  0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xE0, 0x63, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F, 0xE1, 0xF8,
  0xFF, 0x1F, 0xCF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x08, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xC0, 0x43, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE7, 0xFE, 0xFC, 0x7F, 0xCF, 0xC7, 0xFC, 0xFC, 0x7F,
  0xCF, 0xCF, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xF0,
  0xFF, 0x07, 0xE1, 0xFC, 0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE,
  0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xDF, 0x07, 0xFF, 0x3F, 0xF8, 0x3E,
  0xF9, 0xEF, 0xC1, 0xF7, 0xDF, 0x7E, 0x1F, 0xBE, 0xFB, 0xE0, 0xFD, 0xFF,
  0x9F, 0x07, 0xEF, 0xFD, 0xF8, 0x3F, 0x7F, 0xCF, 0xC1, 0xF3, 0xFE, 0x7E,
  0x1F, 0x9F, 0xE3, 0xE0, 0xFC, 0xFF, 0x3F, 0x07, 0xE7, 0xF1, 0xF8, 0x3E,
  0x3F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0x07, 0xF8,
  0x1F, 0x83, 0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xE0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xFC, 0x7E, 0x0F,
  0xFE, 0x3E, 0x0F, 0xFF, 0x3F, 0x07, 0xEF, 0x9F, 0x83, 0xE7, 0xEF, 0xC1,
  0xF3, 0xF7, 0xC1, 0xF9, 0xFB, 0xE0, 0xFC, 0x7D, 0xF0, 0x7E, 0x3F, 0xF8,
  0x3E, 0x1F, 0xFC, 0x1F, 0x0F, 0xFC, 0x1F, 0x83, 0xFE, 0x0F, 0xC1, 0xFF,
  0x07, 0xE0, 0xFF, 0x83, 0xE0, 0x7F, 0xC1, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0x87, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F,
  0xCF, 0xE3, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x9F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0x87, 0xF3, 0xF0, 0x3F,
  0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFE, 0xFC, 0x1F, 0xCF, 0xE3, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC,
  0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xF7, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE0, 0xFE, 0x00, 0x30,
  0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFC, 0x10, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x84, 0x07, 0xE1, 0xC3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x1F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0xDF, 0x80,
  0x7D, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0xFD,
  0xF8, 0x7F, 0x07, 0xEF, 0xC3, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3, 0xF3, 0xF1,
  0xFE, 0x1F, 0x9F, 0x0F, 0xF1, 0xF8, 0xF8, 0xFF, 0x8F, 0xC7, 0xC7, 0xFC,
  0xFC, 0x3E, 0x7F, 0xE7, 0xE1, 0xF3, 0xFF, 0x3F, 0x0F, 0x9F, 0xFB, 0xF0,
  0x7D, 0xF7, 0xDF, 0x83, 0xEF, 0xBE, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF,
  0xCF, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xF7, 0xF0,
  0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xFF, 0xC3, 0xFB,
  0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x81,
  0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0xCF,
  0x87, 0xC7, 0xC7, 0xC1, 0xE3, 0xE0, 0xF3, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x7E,
  0x3E, 0x1F, 0x03, 0xC7, 0xC3, 0xF9, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xCF, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x3F, 0x8F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xF7, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x7C, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC7, 0xF3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3E, 0x7E, 0x00, 0x03, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE0, 0x9F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC2, 0x3F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x7C, 0xFC, 0x0F, 0xEF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0x3F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xF7,
  0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xF9,
  0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE,
  0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x23, 0xF8, 0x70, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0xFF, 0x7C,
  0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x3F, 0x8F, 0xE3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE1, 0x01, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xC0, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x7F,
  0x0F, 0xC7, 0xF0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x3F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0x0F, 0x9F, 0x07, 0xC0, 0xFB, 0xF9, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFC, 0xFE, 0x7F,
  0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7E, 0x7F, 0x1F, 0x8F,
  0xE7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E,
  0x3F, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x80, 0x0F, 0x9F,
  0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7F, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xEF, 0xC3, 0xF7, 0xE3, 0xFB, 0xFB,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x3E, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF7, 0xF0, 0x3F, 0x3E, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE7, 0xC3, 0xFD, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xCF, 0xE7, 0xF1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0x03, 0xEF,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0x9E, 0x1F, 0x7C, 0x3F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xE3, 0xF9, 0xC7, 0xE0, 0x8F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xD0, 0x3F, 0xBE, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xEF, 0x83, 0xF3, 0xE0, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8,
  0xFD, 0xF8, 0x3E, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0xFC, 0x7F, 0x0F, 0xFF, 0x1F, 0xC7, 0xEF, 0xC7, 0xF1, 0xFB, 0xF3, 0xFC,
  0x7E, 0xFC, 0xFF, 0x3F, 0x3F, 0x3F, 0xCF, 0xCF, 0xDE, 0xF7, 0xE3, 0xF7,
  0xFD, 0xF8, 0xFF, 0xFF, 0x7C, 0x3E, 0xF7, 0xFF, 0x0F, 0xBD, 0xFF, 0x83,
  0xFF, 0x7B, 0xE0, 0xFF, 0x9F, 0xF8, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xFD,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x9F,
  0x81, 0xFC, 0x7E, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0xBF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 14, 9, 15, 3, -24 },
  { 50, 21, 24, 21, 0, -24 },
  { 113, 18, 28, 18, 1, -26 },
  { 176, 27, 25, 30, 2, -25 },
  { 261, 23, 25, 23, 0, -25 },
  { 333, 7, 9, 8, 3, -24 },
  { 341, 13, 30, 12, 1, -25 },
  { 390, 13, 30, 12, -2, -25 },
  { 439, 16, 16, 17, 2, -26 },
  { 471, 16, 16, 19, 2, -20 },
  { 503, 9, 9, 10, -2, -4 },
  { 514, 10, 5, 11, 0, -12 },
  { 521, 7, 6, 10, 0, -6 },
  { 527, 20, 25, 15, -2, -25 },
  { 590, 17, 25, 18, 1, -25 },
  { 644, 14, 24, 18, 3, -24 },
  { 686, 19, 25, 18, -1, -25 },
  { 746, 18, 25, 18, 0, -25 },
  { 803, 18, 24, 18, 0, -24 },
  { 857, 18, 24, 18, 0, -24 },
  { 911, 18, 25, 18, 1, -25 },
  { 968, 19, 24, 18, 1, -24 },
  { 1025, 17, 25, 18, 1, -25 },
  { 1079, 17, 25, 18, 1, -25 },
  { 1133, 10, 19, 10, 0, -19 },
  { 1157, 12, 24, 10, -2, -19 },
  { 1193, 17, 18, 19, 1, -21 },
  { 1232, 16, 12, 19, 2, -18 },
  { 1256, 16, 18, 19, 2, -21 },
  { 1292, 14, 25, 15, 2, -25 },
  { 1336, 26, 28, 28, 1, -25 },
  { 1427, 21, 24, 21, -2, -24 },
  { 1490, 20, 24, 20, 0, -24 },
  { 1550, 19, 25, 19, 2, -25 },
  { 1610, 21, 24, 21, 0, -24 },
  { 1673, 19, 24, 17, 0, -24 },
  { 1730, 19, 24, 17, 0, -24 },
  { 1787, 20, 25, 22, 2, -25 },
  { 1850, 23, 24, 22, 0, -24 },
  { 1919, 17, 24, 14, -1, -24 },
  { 1970, 17, 32, 11, -5, -24 },
  { 2038, 24, 24, 21, 0, -24 },
  { 2110, 15, 24, 16, 0, -24 },
  { 2155, 29, 24, 29, 0, -24 },
  { 2242, 25, 24, 25, 0, -24 },
  { 2317, 20, 25, 23, 2, -25 },
  { 2380, 20, 24, 19, 0, -24 },
  { 2440, 20, 31, 23, 2, -25 },
  { 2518, 20, 24, 20, 0, -24 },
  { 2578, 18, 25, 17, 0, -25 },
  { 2635, 17, 24, 17, 3, -24 },
  { 2686, 21, 24, 22, 2, -24 },
  { 2749, 20, 24, 20, 3, -24 },
  { 2809, 29, 24, 29, 3, -24 },
  { 2896, 25, 24, 21, -2, -24 },
  { 2971, 19, 24, 19, 3, -24 },
  { 3028, 20, 24, 17, -1, -24 },
  { 3088, 15, 31, 11, -1, -25 },
  { 3147, 8, 25, 15, 4, -25 },
  { 3172, 15, 31, 11, -2, -25 },
  { 3231, 17, 16, 17, 0, -24 },
  { 3265, 15, 4, 14, -3, 2 },
  { 3273, 8, 5, 12, 5, -26 },
  { 3278, 18, 19, 19, 1, -19 },
  { 3321, 18, 26, 19, 0, -26 },
  { 3380, 15, 19, 16, 1, -19 },
  { 3416, 20, 26, 19, 1, -26 },
  { 3481, 17, 19, 18, 1, -19 },
  { 3522, 20, 34, 13, -4, -26 },
  { 3607, 19, 27, 19, 0, -19 },
  { 3672, 18, 26, 20, 0, -26 },
  { 3731, 11, 26, 10, 0, -26 },
  { 3767, 15, 34, 10, -4, -26 },
  { 3831, 21, 26, 19, 0, -26 },
  { 3900, 12, 26, 10, 0, -26 },
  { 3939, 28, 19, 29, 0, -19 },
  { 4006, 18, 19, 20, 0, -19 },
  { 4049, 17, 19, 19, 1, -19 },
  { 4090, 20, 27, 19, -2, -19 },
  { 4158, 18, 27, 19, 1, -19 },
  { 4219, 15, 19, 14, 0, -19 },
  { 4255, 15, 19, 16, 0, -19 },
  { 4291, 14, 23, 14, 1, -23 },
  { 4332, 18, 19, 20, 1, -19 },
  { 4375, 17, 19, 17, 2, -19 },
  { 4416, 26, 19, 26, 2, -19 },
  { 4478, 22, 19, 18, -2, -19 },
  { 4531, 21, 27, 17, -2, -19 },
  { 4602, 17, 19, 15, -1, -19 },
  { 4643, 15, 29, 12, 0, -24 },
  { 4698, 5, 34, 17, 6, -26 },
  { 4720, 14, 29, 12, -2, -24 },
  { 4771, 17, 6, 19, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC34PT7B_H_
