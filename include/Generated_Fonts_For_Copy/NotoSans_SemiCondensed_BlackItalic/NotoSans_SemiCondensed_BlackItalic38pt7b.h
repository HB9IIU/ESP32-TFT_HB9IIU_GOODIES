#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F,
  0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF9, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xB9,
  0xC1, 0xFB, 0x80, 0x1F, 0xB0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0C, 0xF8, 0x80, 0xCF, 0x8E, 0x1D, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xC0, 0x7F, 0xC0, 0x1F, 0x01, 0xFF, 0xC0, 0x7C, 0x03,
  0xFF, 0x81, 0xF8, 0x0F, 0xDF, 0x03, 0xE0, 0x1F, 0x3F, 0x0F, 0x80, 0x3E,
  0x7C, 0x3F, 0x00, 0xFC, 0xF8, 0x7C, 0x01, 0xF1, 0xF1, 0xF0, 0x03, 0xE3,
  0xE7, 0xE0, 0x07, 0xCF, 0xCF, 0x8E, 0x0F, 0x9F, 0x3E, 0x7F, 0x9F, 0xFE,
  0xFD, 0xFF, 0x9F, 0xF9, 0xF7, 0xFF, 0x3F, 0xE7, 0xCF, 0xFE, 0x3F, 0x9F,
  0xBF, 0x3E, 0x08, 0x3E, 0x7C, 0x7C, 0x00, 0xF8, 0xF9, 0xF8, 0x03, 0xE3,
  0xF3, 0xE0, 0x07, 0xC7, 0xC7, 0xC0, 0x1F, 0x0F, 0x8F, 0x80, 0x7C, 0x1F,
  0x3F, 0x00, 0xF8, 0x3E, 0x7C, 0x03, 0xE0, 0x7F, 0xF8, 0x0F, 0x80, 0x7F,
  0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xF3, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC7, 0xF0, 0xFF, 0xE3, 0xF8, 0x7F, 0xFC,
  0xFE, 0x3F, 0xFF, 0x7F, 0x1F, 0xDF, 0xFF, 0xC7, 0xF3, 0xFF, 0xE3, 0xF8,
  0xFF, 0xF8, 0xFE, 0x1F, 0xFC, 0x3F, 0x83, 0xFE, 0x0F, 0xF1, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE7, 0xFC, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x7C, 0x08, 0x3E, 0x07, 0x1F, 0x03, 0xEF, 0x03, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0xC1, 0xFB, 0xF0, 0x38, 0xF8, 0x08, 0x7E, 0x00, 0x30,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC7, 0xF1, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x7F, 0xF7, 0xFE,
  0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFC, 0x1C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB, 0xF8, 0xFE,
  0x7F, 0x3F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE, 0x3F, 0xBF, 0x87, 0xF7, 0xF0,
  0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xDF, 0xC3,
  0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0xDF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x7E, 0xFE, 0x7C, 0xFC, 0x39, 0xFC, 0x21,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x70, 0x7F, 0x01, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0x8F, 0xF0, 0x20, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC8, 0x03, 0xFC, 0xF8, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7D,
  0xFC, 0x0F, 0xDF, 0xC1, 0xF9, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF8, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x8C, 0x03, 0xFC, 0x7C, 0x7F,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF8, 0x21, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x3E, 0x03, 0xF7, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0xF1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xC7, 0xE3, 0xFC, 0x7F, 0x7F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF9, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xE7, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x8F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xF3, 0xF9, 0xFC,
  0x7F, 0x3F, 0x8F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF1,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xEF, 0xC3, 0xFB,
  0xF8, 0x3E, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x20, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0x81, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xF0, 0xFF,
  0x1F, 0xE3, 0xF8, 0x7F, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3C, 0x7F, 0x10, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x3E, 0x1F, 0x07, 0xFC, 0xF8, 0x7C, 0x7F, 0xF9, 0xF3, 0xE3,
  0xFF, 0xC7, 0xCF, 0x8F, 0xFF, 0x1F, 0x7C, 0x7C, 0x7C, 0x7D, 0xF3, 0xF1,
  0xF1, 0xF7, 0x8F, 0x87, 0xC7, 0x9E, 0x3E, 0x1E, 0x1E, 0xF8, 0xF0, 0xF8,
  0xFB, 0xE7, 0xC3, 0xE3, 0xEF, 0x9F, 0x0F, 0x9F, 0x3E, 0x7C, 0x7E, 0x7C,
  0xF8, 0xFF, 0xFF, 0xE3, 0xE3, 0xFF, 0xFF, 0x0F, 0x87, 0xF7, 0xF8, 0x1F,
  0x0F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x03, 0xF8,
  0x03, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F,
  0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xCF, 0x87, 0xFC, 0x0C,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC,
  0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0xFF, 0x1F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFE, 0x0F, 0xF1,
  0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0x3E, 0x1F, 0xF0, 0x08, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x9F, 0xC7,
  0xFF, 0x3F, 0x8F, 0xFE, 0x7F, 0x1F, 0xFC, 0xFE, 0x3F, 0xF1, 0xFC, 0x7F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xE1, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x81,
  0x1F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xBF, 0x03, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xE3, 0xEF, 0xC0, 0xFD, 0xF3, 0xF7,
  0xE0, 0x7E, 0xF9, 0xF7, 0xF0, 0x3F, 0x7D, 0xFB, 0xF8, 0x1F, 0xBE, 0xF9,
  0xF8, 0x1F, 0xDF, 0x7C, 0xFC, 0x0F, 0xCF, 0xFC, 0x7E, 0x07, 0xE7, 0xFE,
  0x7F, 0x03, 0xF3, 0xFE, 0x3F, 0x03, 0xF9, 0xFF, 0x1F, 0x81, 0xFC, 0xFF,
  0x8F, 0xC0, 0xFC, 0x7F, 0x8F, 0xE0, 0x7E, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F,
  0xC3, 0xF0, 0x3F, 0x8F, 0xE1, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x3F,
  0xC0, 0x7F, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x7F, 0xE0, 0x7E, 0x07, 0xFF, 0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x0F,
  0xFF, 0x0F, 0xC0, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0x8F, 0xC0, 0xFD, 0xF9,
  0xFC, 0x1F, 0x9F, 0x9F, 0x81, 0xF9, 0xF9, 0xF8, 0x1F, 0x9F, 0xDF, 0x81,
  0xF8, 0xFD, 0xF8, 0x1F, 0x8F, 0xDF, 0x83, 0xF8, 0xFF, 0xF0, 0x3F, 0x0F,
  0xFF, 0x03, 0xF0, 0x7F, 0xF0, 0x3F, 0x07, 0xFF, 0x07, 0xF0, 0x7F, 0xF0,
  0x7F, 0x07, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xE0,
  0x3F, 0xE0, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0xFF, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x3F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0xFF, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xCF,
  0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0,
  0xFE, 0x3F, 0x83, 0xFB, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x03, 0xF9, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x80, 0x00,
  0x0C, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xF3, 0xC1, 0xFE, 0x04, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x40, 0x3F, 0x86, 0x03, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x81,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F,
  0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x07,
  0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xE7,
  0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x1F, 0xDF,
  0xC1, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x07, 0xE7, 0xF0, 0xFF, 0x87, 0xF3,
  0xF8, 0x7F, 0xC3, 0xF1, 0xF8, 0x3F, 0xE3, 0xF8, 0xFC, 0x3F, 0xF1, 0xFC,
  0x7E, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xFC, 0xFE, 0x1F, 0x8F, 0xFC, 0x7E,
  0x0F, 0xCF, 0xFE, 0x7F, 0x07, 0xE7, 0xDF, 0x3F, 0x83, 0xF3, 0xEF, 0x9F,
  0x81, 0xFB, 0xF7, 0xDF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0x7F, 0xF9, 0xF7,
  0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xEF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xFD, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC3,
  0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xE1,
  0xF8, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x7C, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0x80, 0xFF, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x03, 0xF1, 0xF0,
  0x7F, 0xBF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFD, 0xFE,
  0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xF7,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x1F, 0xE7,
  0xF9, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xDF, 0xF0,
  0xFC, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF1, 0xFE, 0x30, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x11, 0xFE,
  0x38, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x83, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xE3, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0x1F, 0xCF, 0xC3,
  0xFB, 0xF8, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x18, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFE, 0x40, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xEF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xF7,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x00,
  0xFB, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x10, 0x0F, 0xE0, 0xF0, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xEF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x1F, 0xC0, 0x00, 0x40, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x81,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F,
  0xCF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7E, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xCF, 0xE1, 0xF8, 0x1F, 0xBF, 0xCF, 0xF8, 0x3F, 0xFF, 0xDF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xFF, 0x9F, 0xC7, 0xF9,
  0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x0F,
  0xE1, 0xFC, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xE1, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8, 0x7E, 0x3F, 0x87, 0xF1,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xC0,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFE, 0x7F,
  0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x87,
  0xF3, 0xF8, 0x7F, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF,
  0x8F, 0xF7, 0xF9, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFE, 0x3F, 0x87, 0xF9, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xEF, 0xF0, 0x3F,
  0x9F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFD, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xF7, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFB, 0xF0, 0x1F, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xCF, 0x87, 0xEF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xE4, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF1, 0xFC, 0x10, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF2, 0x03, 0xF9, 0xC1,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0xE7, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF9, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xBF, 0x03, 0xF9, 0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE,
  0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7E, 0x3F,
  0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC3, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0x8F, 0xF0, 0xFD, 0xF8,
  0x7F, 0x8F, 0xEF, 0xC7, 0xFC, 0x7E, 0x7E, 0x3F, 0xE7, 0xF3, 0xF3, 0xFF,
  0x3F, 0x1F, 0x9F, 0xF9, 0xF8, 0xFC, 0xFF, 0xDF, 0xC7, 0xEF, 0xBE, 0xFC,
  0x3F, 0x7D, 0xFF, 0xE1, 0xFB, 0xCF, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F,
  0xF3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7,
  0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x00, 0xFE, 0x1F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF1, 0xFE, 0x07,
  0xF9, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xCF, 0xC0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x8F, 0xE0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE3, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF9, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xE8, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 27, 11, 0, -27 },
  { 45, 16, 10, 17, 3, -27 },
  { 65, 24, 27, 23, 0, -27 },
  { 146, 20, 31, 21, 1, -29 },
  { 224, 31, 28, 33, 2, -28 },
  { 333, 26, 28, 26, 0, -28 },
  { 424, 8, 10, 9, 3, -27 },
  { 434, 15, 34, 13, 1, -28 },
  { 498, 15, 34, 13, -3, -28 },
  { 562, 17, 18, 19, 3, -29 },
  { 601, 18, 19, 21, 2, -23 },
  { 644, 10, 10, 11, -2, -5 },
  { 657, 12, 6, 12, 0, -13 },
  { 666, 8, 7, 11, 0, -7 },
  { 673, 22, 28, 17, -2, -28 },
  { 750, 19, 28, 21, 1, -28 },
  { 817, 16, 27, 21, 3, -27 },
  { 871, 21, 28, 21, -1, -28 },
  { 945, 20, 28, 21, 0, -28 },
  { 1015, 20, 27, 21, 0, -27 },
  { 1083, 21, 27, 21, 0, -27 },
  { 1154, 20, 28, 21, 1, -28 },
  { 1224, 21, 27, 21, 1, -27 },
  { 1295, 19, 28, 21, 1, -28 },
  { 1362, 19, 28, 21, 1, -28 },
  { 1429, 11, 21, 11, 0, -21 },
  { 1458, 13, 26, 11, -2, -21 },
  { 1501, 18, 20, 21, 2, -24 },
  { 1546, 18, 13, 21, 2, -20 },
  { 1576, 18, 20, 21, 2, -24 },
  { 1621, 16, 28, 17, 2, -28 },
  { 1677, 30, 31, 31, 1, -28 },
  { 1794, 23, 27, 24, -2, -27 },
  { 1872, 22, 27, 22, 0, -27 },
  { 1947, 21, 28, 22, 2, -28 },
  { 2021, 23, 27, 24, 0, -27 },
  { 2099, 21, 27, 19, 0, -27 },
  { 2170, 21, 27, 19, 0, -27 },
  { 2241, 23, 28, 24, 2, -28 },
  { 2322, 26, 27, 25, 0, -27 },
  { 2410, 19, 27, 15, -1, -27 },
  { 2475, 19, 36, 13, -6, -27 },
  { 2561, 26, 27, 23, 0, -27 },
  { 2649, 16, 27, 18, 0, -27 },
  { 2703, 33, 27, 32, 0, -27 },
  { 2815, 28, 27, 27, 0, -27 },
  { 2910, 23, 28, 26, 2, -28 },
  { 2991, 22, 27, 22, 0, -27 },
  { 3066, 23, 34, 26, 2, -28 },
  { 3164, 22, 27, 23, 0, -27 },
  { 3239, 20, 28, 19, 0, -28 },
  { 3309, 19, 27, 19, 3, -27 },
  { 3374, 23, 27, 24, 2, -27 },
  { 3452, 22, 27, 22, 3, -27 },
  { 3527, 33, 27, 33, 3, -27 },
  { 3639, 28, 27, 23, -2, -27 },
  { 3734, 22, 27, 21, 3, -27 },
  { 3809, 23, 27, 19, -2, -27 },
  { 3887, 16, 34, 13, -1, -28 },
  { 3955, 10, 28, 17, 4, -28 },
  { 3990, 17, 34, 13, -3, -28 },
  { 4063, 19, 18, 19, 0, -27 },
  { 4106, 18, 5, 16, -4, 2 },
  { 4118, 9, 6, 13, 5, -29 },
  { 4125, 20, 21, 21, 1, -21 },
  { 4178, 20, 29, 21, 0, -29 },
  { 4251, 17, 21, 18, 1, -21 },
  { 4296, 22, 29, 21, 1, -29 },
  { 4376, 19, 21, 20, 1, -21 },
  { 4426, 22, 38, 14, -4, -29 },
  { 4531, 21, 30, 21, 0, -21 },
  { 4610, 20, 29, 22, 0, -29 },
  { 4683, 13, 30, 11, 0, -30 },
  { 4732, 18, 39, 11, -5, -30 },
  { 4820, 24, 29, 22, 0, -29 },
  { 4907, 13, 29, 11, 0, -29 },
  { 4955, 31, 21, 32, 0, -21 },
  { 5037, 20, 21, 22, 0, -21 },
  { 5090, 19, 21, 21, 1, -21 },
  { 5140, 22, 30, 21, -2, -21 },
  { 5223, 20, 30, 21, 1, -21 },
  { 5298, 17, 21, 15, 0, -21 },
  { 5343, 17, 21, 17, 0, -21 },
  { 5388, 15, 25, 16, 1, -25 },
  { 5435, 21, 21, 22, 1, -21 },
  { 5491, 20, 21, 19, 2, -21 },
  { 5544, 29, 21, 29, 2, -21 },
  { 5621, 24, 21, 20, -2, -21 },
  { 5684, 24, 30, 19, -2, -21 },
  { 5774, 19, 21, 17, -1, -21 },
  { 5824, 16, 33, 13, 0, -27 },
  { 5890, 5, 38, 19, 7, -29 },
  { 5914, 16, 33, 13, -2, -27 },
  { 5980, 18, 7, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC38PT7B_H_
