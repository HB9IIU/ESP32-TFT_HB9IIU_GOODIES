#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xE3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F,
  0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xFC, 0x7F,
  0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0x1F, 0x00, 0xFF, 0x9E,
  0x06, 0x03, 0xFF, 0x3C, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0x0F, 0xFD, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF7, 0xFC, 0x10, 0x03, 0xCF, 0xF8, 0x30, 0x07, 0x9F, 0xF0, 0x78,
  0x0F, 0x3F, 0xE0, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC7, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x9F, 0xE3,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xCF, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF9, 0xFF,
  0xFF, 0x1F, 0xFF, 0x1F, 0xE7, 0xFD, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xDF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0x00, 0x7F,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFB, 0xFF, 0xFF, 0xF8, 0x7F, 0xF3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFD, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x40, 0x3F, 0xC0, 0x06, 0x07,
  0xF8, 0x01, 0xF0, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xFF, 0xF8, 0x05,
  0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xEF, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xC3, 0xFC, 0x00, 0x70, 0x7F, 0xC0, 0x06, 0x0F, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xFB, 0xFF,
  0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF9, 0xFF,
  0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x07,
  0xFF, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFE,
  0xFF, 0xC3, 0xFE, 0xFF, 0xE0, 0xFE, 0x7F, 0xE0, 0x7C, 0x3F, 0xF0, 0x1C,
  0x1F, 0xF8, 0x04, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x3E,
  0x07, 0xFF, 0x00, 0x3C, 0x07, 0xFF, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x10,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7F, 0xF0, 0x04, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x20, 0x00, 0x3F, 0xFC, 0xE0, 0x01, 0xFF, 0xF3, 0xF0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xDF, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xF9,
  0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0x00, 0x7F, 0x87, 0xFE, 0x01, 0xFF, 0x1F,
  0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x20,
  0x00, 0x7F, 0xF8, 0x60, 0x01, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x02, 0xD0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0xC1, 0xFF, 0x8F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF,
  0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x83,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFE, 0x7F, 0xF0,
  0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xFF, 0x03, 0xFF,
  0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x04,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF,
  0xC3, 0x00, 0x7F, 0xE1, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0x07, 0xF0, 0x3F,
  0xFF, 0xE3, 0xFC, 0x7F, 0x83, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF,
  0xF8, 0x7F, 0x3F, 0xC3, 0xFF, 0xFF, 0xC3, 0xF9, 0xFC, 0x1F, 0xF1, 0xFC,
  0x1F, 0xDF, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF7, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xBF, 0x87, 0xF0, 0x3F, 0x81, 0xFB,
  0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xDF, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF7, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x01, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xE0,
  0x0E, 0x03, 0xFF, 0xC0, 0x01, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0x00, 0xFF, 0xF0, 0x03, 0x80, 0x7F, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x87,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x18, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xFE,
  0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xEF,
  0xE0, 0x7F, 0xBF, 0xE0, 0x0F, 0xFB, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFE,
  0xFE, 0x0F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0x83, 0xFD, 0xFF, 0x00, 0x7F,
  0xEF, 0xE1, 0xFE, 0xFF, 0xC0, 0x1F, 0xF3, 0xF8, 0x7F, 0xBF, 0xF0, 0x07,
  0xFC, 0xFE, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0x8F, 0xF3, 0xFF, 0x00,
  0xFF, 0xCF, 0xE3, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xF9, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFE, 0x7F, 0x9F, 0xF8, 0x03, 0xFE, 0x3F, 0xBF, 0xC7, 0xFE,
  0x00, 0xFF, 0x8F, 0xEF, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF8, 0xFF, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x1F,
  0xF8, 0x03, 0xFE, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF9, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC7, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x0F,
  0xF9, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xCF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE,
  0x7F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF9, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0x80,
  0x3F, 0xF8, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x10, 0x00, 0x7F, 0xF0, 0x38, 0x00, 0xFF, 0xE0, 0x7C, 0x03, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xEF, 0xFC,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0xF1, 0xFF,
  0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xCF, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xDF, 0xE3, 0xFF,
  0x00, 0xFF, 0x8F, 0xF7, 0xF8, 0xFF, 0xC0, 0x3F, 0xE7, 0xFD, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF9, 0xFE, 0x7F, 0x9F, 0xF8, 0x03, 0xFE, 0xFF, 0x9F, 0xE7,
  0xFC, 0x00, 0xFF, 0xBF, 0xE7, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xF1, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x07,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFE,
  0x7F, 0xF0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF,
  0xBF, 0xE0, 0x3F, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC,
  0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0x1F, 0xF9, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0xFE, 0x03, 0xFE, 0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0x83, 0x83, 0xFF, 0x80, 0x20, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x83, 0xFF, 0x80, 0x60, 0xFF,
  0xF0, 0x78, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x81, 0xFF, 0xC0, 0x07, 0xF8,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xBF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83,
  0xFF, 0x3F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7,
  0xFF, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x20, 0xFF, 0xE0, 0x06, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC2, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xBF,
  0xE0, 0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x8F,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x08, 0x00, 0x3F, 0xF8, 0x07, 0x00, 0x1F, 0xFC, 0x03, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x3F, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF3,
  0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x07, 0xFE,
  0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0x87, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xF9, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xE0, 0x3F, 0xEF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF,
  0xE1, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x03,
  0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x03,
  0xFF, 0x9F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x07, 0xFE, 0x02, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x02, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFF,
  0x9F, 0xF0, 0x1F, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0x00, 0x06, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xF0,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFC, 0x3E, 0x0F, 0xFC, 0x06,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF1, 0x00, 0x1F, 0xF8, 0xE0, 0x1F, 0xFC, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x30, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0,
  0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x07,
  0xFE, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFD,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x7F,
  0xE0, 0xFF, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFE, 0x07, 0xFC, 0xFE, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xF7, 0xF3,
  0xFF, 0x01, 0xFF, 0x7F, 0xBF, 0x9F, 0xF0, 0x0F, 0xFB, 0xF9, 0xFD, 0xFF,
  0x80, 0x7F, 0xDF, 0xCF, 0xEF, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0x7F, 0xC0,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 42, 17, 0, -41 },
  { 101, 24, 15, 26, 5, -41 },
  { 146, 36, 41, 35, 0, -41 },
  { 331, 31, 47, 31, 1, -44 },
  { 514, 47, 43, 51, 3, -42 },
  { 767, 40, 43, 40, 0, -42 },
  { 982, 12, 15, 14, 5, -41 },
  { 1005, 23, 52, 20, 1, -43 },
  { 1155, 22, 52, 20, -4, -43 },
  { 1298, 27, 29, 29, 4, -45 },
  { 1396, 27, 29, 32, 3, -35 },
  { 1494, 15, 15, 17, -3, -7 },
  { 1523, 17, 9, 19, 1, -20 },
  { 1543, 11, 11, 17, 0, -10 },
  { 1559, 33, 43, 26, -3, -42 },
  { 1737, 29, 43, 31, 2, -42 },
  { 1893, 25, 41, 31, 5, -41 },
  { 2022, 32, 42, 31, -2, -42 },
  { 2190, 30, 43, 31, 0, -42 },
  { 2352, 31, 41, 31, 0, -41 },
  { 2511, 31, 42, 31, 1, -41 },
  { 2674, 30, 43, 31, 2, -42 },
  { 2836, 33, 41, 31, 1, -41 },
  { 3006, 30, 43, 31, 1, -42 },
  { 3168, 29, 43, 31, 2, -42 },
  { 3324, 17, 33, 17, 0, -32 },
  { 3395, 20, 40, 17, -3, -32 },
  { 3495, 28, 30, 32, 2, -36 },
  { 3600, 27, 21, 32, 3, -31 },
  { 3671, 27, 30, 32, 3, -36 },
  { 3773, 25, 43, 26, 3, -42 },
  { 3908, 45, 47, 48, 2, -42 },
  { 4173, 35, 41, 36, -3, -41 },
  { 4353, 34, 41, 34, 0, -41 },
  { 4528, 33, 43, 33, 3, -42 },
  { 4706, 36, 41, 37, 0, -41 },
  { 4891, 32, 41, 30, 0, -41 },
  { 5055, 32, 41, 30, 0, -41 },
  { 5219, 35, 43, 37, 3, -42 },
  { 5408, 39, 41, 38, 0, -41 },
  { 5608, 29, 41, 24, -2, -41 },
  { 5757, 30, 54, 20, -9, -41 },
  { 5960, 40, 41, 35, 0, -41 },
  { 6165, 25, 41, 28, 0, -41 },
  { 6294, 50, 41, 49, 0, -41 },
  { 6551, 43, 41, 42, 0, -41 },
  { 6772, 35, 43, 39, 3, -42 },
  { 6961, 33, 41, 33, 0, -41 },
  { 7131, 35, 52, 39, 3, -42 },
  { 7359, 33, 41, 35, 0, -41 },
  { 7529, 31, 43, 29, 0, -42 },
  { 7696, 29, 41, 29, 4, -41 },
  { 7845, 36, 42, 37, 3, -41 },
  { 8034, 33, 41, 34, 5, -41 },
  { 8204, 50, 41, 50, 5, -41 },
  { 8461, 42, 41, 35, -3, -41 },
  { 8677, 33, 41, 33, 5, -41 },
  { 8847, 36, 41, 29, -3, -41 },
  { 9032, 25, 53, 19, -2, -43 },
  { 9198, 15, 43, 26, 6, -42 },
  { 9279, 25, 53, 19, -4, -43 },
  { 9445, 30, 27, 30, -1, -41 },
  { 9547, 26, 7, 25, -5, 4 },
  { 9570, 14, 9, 20, 8, -44 },
  { 9586, 31, 34, 33, 2, -33 },
  { 9718, 31, 45, 33, 0, -44 },
  { 9893, 26, 34, 27, 2, -33 },
  { 10004, 33, 45, 33, 2, -44 },
  { 10190, 28, 34, 31, 2, -33 },
  { 10309, 34, 58, 22, -6, -44 },
  { 10556, 33, 47, 33, 0, -33 },
  { 10750, 31, 44, 33, 0, -44 },
  { 10921, 19, 45, 17, 0, -45 },
  { 11028, 27, 59, 17, -7, -45 },
  { 11228, 36, 44, 33, 0, -44 },
  { 11426, 20, 44, 17, 0, -44 },
  { 11536, 47, 33, 49, 0, -33 },
  { 11730, 31, 33, 33, 0, -33 },
  { 11858, 29, 34, 32, 2, -33 },
  { 11982, 34, 47, 33, -3, -33 },
  { 12182, 31, 47, 33, 2, -33 },
  { 12365, 26, 33, 24, 0, -33 },
  { 12473, 25, 34, 27, 1, -33 },
  { 12580, 23, 40, 24, 2, -39 },
  { 12695, 31, 33, 33, 2, -32 },
  { 12823, 30, 32, 30, 3, -32 },
  { 12943, 45, 32, 45, 3, -32 },
  { 13123, 37, 32, 31, -3, -32 },
  { 13271, 37, 46, 30, -4, -32 },
  { 13484, 30, 32, 26, -2, -32 },
  { 13604, 25, 50, 21, 0, -41 },
  { 13761, 7, 57, 29, 11, -44 },
  { 13811, 24, 50, 21, -3, -41 },
  { 13961, 28, 11, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC58PT7B_H_
