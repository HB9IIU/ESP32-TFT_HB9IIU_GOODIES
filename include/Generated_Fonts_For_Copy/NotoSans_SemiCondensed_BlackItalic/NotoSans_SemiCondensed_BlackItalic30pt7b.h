#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x00, 0x7D, 0xFF, 0x9F, 0xF9, 0xEF, 0x9E, 0xF3, 0xEF,
  0x3C, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3,
  0x80, 0x3C, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC0, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x07, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE0, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0x9E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x07, 0xC0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xF7, 0x1F, 0x62, 0x3F, 0xC0, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xBE, 0x83,
  0x7D, 0xE7, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x08, 0x1F, 0x80, 0xF0, 0x3F, 0xC0,
  0xF0, 0x7F, 0xC1, 0xE0, 0x7B, 0xC3, 0xC0, 0xF3, 0xC3, 0xC0, 0xF3, 0xC7,
  0x80, 0xF3, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xF7, 0x9E, 0x7C, 0xFF, 0xBC,
  0xFE, 0xFF, 0x7D, 0xFE, 0x7E, 0x7B, 0xFF, 0x1C, 0xF3, 0xCF, 0x01, 0xF7,
  0xCF, 0x01, 0xE7, 0x8F, 0x03, 0xC7, 0x9E, 0x07, 0xC7, 0x9E, 0x07, 0x87,
  0xBE, 0x0F, 0x07, 0xFC, 0x1F, 0x03, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xDF, 0x00, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF9, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xE7, 0xFF, 0xFE, 0xFC, 0xFF, 0xCF,
  0xCF, 0xFC, 0xFC, 0x7F, 0x8F, 0xC7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFE, 0xFE, 0x7F, 0xEF, 0xBE, 0xF3, 0xCF, 0x00, 0x03,
  0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0x00, 0x03, 0xA0, 0x0F, 0x00, 0x3C, 0x18, 0xF0, 0x7B, 0x81,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0xFF, 0x07, 0xDE, 0x1F, 0x78,
  0x19, 0xF0, 0x23, 0x00, 0x10, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F,
  0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F, 0xBF, 0xDF, 0xFF, 0xE0,
  0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xE7, 0xEF, 0xCF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xDF, 0x0F, 0xBE, 0x3F, 0x7C, 0x7E, 0xF8, 0xF9, 0xFB,
  0xF3, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x3F, 0xE3, 0xFF, 0x7F, 0xF9, 0xF7, 0xC7, 0x7E, 0x23, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x38, 0xFC, 0x18, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0C, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x80, 0xFC, 0xE1, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x7C, 0x1F, 0x7C, 0x1E,
  0x7C, 0x3C, 0xFC, 0x78, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x19, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x80, 0xFC, 0xE1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7D, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFE, 0xFC, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8,
  0xFC, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xF1, 0xF7, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0xBE, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3E, 0x3E,
  0x7C, 0x7E, 0xF8, 0xFD, 0xF1, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFF, 0x07,
  0xF8, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xCF, 0xDF, 0x9F, 0xBE, 0x3F, 0x7C, 0x7E, 0xF8, 0xFD, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0xC7, 0xEF, 0x87, 0xBE, 0x00, 0x7C, 0x01, 0xF1, 0x0F, 0xE3,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x80, 0x00, 0x04, 0x00,
  0x30, 0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x60, 0x00, 0x07, 0x03, 0xFE, 0xFF, 0xF7, 0xFF, 0x7F, 0xF6,
  0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xDF,
  0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xCF, 0x8F, 0xE7, 0x9E, 0x3F, 0xEF,
  0x78, 0xFF, 0x8E, 0xF3, 0xCF, 0x1D, 0xC7, 0x9E, 0x3F, 0x9E, 0x3C, 0xFF,
  0x3C, 0x79, 0xFE, 0x79, 0xE3, 0xBC, 0xE3, 0xCF, 0x79, 0xEF, 0xBC, 0xF3,
  0xFF, 0xF9, 0xE7, 0xEF, 0xE3, 0xC3, 0x87, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x10, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C,
  0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0x8F, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x3F, 0x0F, 0x8F, 0xC3, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x07, 0xE0, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x04, 0x1F, 0xCE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0x9F, 0xC3, 0xE3, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F,
  0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x87,
  0xE3, 0xE1, 0xF9, 0xF8, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF0, 0x63, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x9F, 0xE7, 0xC7, 0xF9, 0xF1, 0xFE, 0xFC, 0xFF, 0xBF, 0x3F,
  0xCF, 0xC1, 0xF3, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0xCF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x83, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x7C, 0x00,
  0x07, 0xC3, 0xF8, 0x7E, 0x3F, 0x03, 0xF3, 0xF8, 0x1F, 0x1F, 0x80, 0xF9,
  0xF8, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE1, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83,
  0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF,
  0x07, 0xFC, 0xF7, 0xC3, 0xEF, 0x3D, 0xF0, 0xFB, 0xDE, 0xF8, 0x3E, 0xF7,
  0xBE, 0x0F, 0xBF, 0xCF, 0x83, 0xEF, 0xF3, 0xE1, 0xF3, 0xFC, 0xF8, 0x7C,
  0xFE, 0x7C, 0x1F, 0x3F, 0x9F, 0x07, 0xCF, 0xC7, 0xC1, 0xF3, 0xF1, 0xF0,
  0xF8, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x3F, 0xC1, 0xF0, 0xFF, 0x07,
  0xC3, 0xFC, 0x3E, 0x0F, 0xF0, 0xF8, 0x3F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87,
  0xFE, 0x3E, 0x1F, 0xF9, 0xF0, 0x7D, 0xF7, 0xC3, 0xE7, 0xDF, 0x0F, 0x9F,
  0x7C, 0x3E, 0x7D, 0xE0, 0xF8, 0xFF, 0x83, 0xE3, 0xFE, 0x1F, 0x0F, 0xF8,
  0x7C, 0x3F, 0xE1, 0xF0, 0x7F, 0x07, 0xC1, 0xFC, 0x1F, 0x07, 0xF0, 0xF8,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xEF,
  0xC0, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F, 0xEF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3F, 0x3F,
  0x1F, 0x1F, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0xFD, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFC, 0x7C, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF9, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E,
  0x3F, 0x3F, 0x1F, 0x3F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x81, 0xF7, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F,
  0x0F, 0xCF, 0x87, 0xEF, 0xC3, 0xF8, 0x00, 0xF0, 0x03, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x8C, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x40, 0xF8, 0xFB, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xFD, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xFC, 0x0F, 0xDF, 0x07, 0xE7, 0xC1,
  0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0,
  0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x07, 0xFF, 0x87, 0xE1,
  0xFB, 0xF0, 0xFC, 0x3E, 0x7E, 0x1F, 0x87, 0xCF, 0xC7, 0xF1, 0xF9, 0xF8,
  0xFE, 0x3E, 0x3E, 0x3F, 0xCF, 0xC7, 0xC7, 0xF9, 0xF0, 0xF9, 0xFF, 0x3E,
  0x0F, 0x3D, 0xEF, 0x81, 0xE7, 0xFD, 0xF0, 0x3D, 0xFF, 0xBE, 0x07, 0xBD,
  0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80,
  0x7F, 0x9F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x0F,
  0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFE, 0x0F, 0xC0, 0xF8, 0x3F, 0xF8, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0x7C,
  0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x10, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE,
  0x07, 0x9E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xF3, 0xE0, 0xFF, 0x81, 0xFE,
  0x03, 0xC0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFC, 0xF8, 0xF8,
  0xF1, 0xE0, 0x07, 0x9F, 0x0F, 0xDF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0xFD, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xB8, 0x1F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0xFB, 0xF0, 0x03, 0xF0,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x63, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xE3, 0xF1, 0xF1,
  0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFB, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE3, 0xE7, 0xEF, 0xCF, 0xDF, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3,
  0xF8, 0x07, 0xC0, 0x0F, 0xC1, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x90,
  0x07, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x4F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xCF, 0x83, 0xF7, 0xC3, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E,
  0x3F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x7E, 0xF8, 0x1E, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x18, 0x3F, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xBC, 0x1F, 0x7E,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x3F,
  0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E,
  0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x03,
  0x80, 0x00, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x82, 0x7E, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F,
  0x1F, 0x83, 0xE7, 0xE0, 0x7D, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xF3,
  0xF0, 0x3E, 0x7E, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC0, 0x07,
  0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1,
  0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC0, 0x0F, 0x3C, 0x1C, 0x0F, 0xBF, 0x3F, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xF8, 0xFC, 0xF8, 0xFC,
  0x7C, 0x7C, 0x7E, 0x7E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x9F,
  0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3, 0xE3, 0xF1, 0xF1,
  0xF1, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0xFC, 0x7C, 0x00, 0x0F, 0x3C,
  0x1F, 0x7E, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x1F, 0x3F, 0x1F,
  0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E,
  0x7C, 0x7E, 0x7C, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xF7, 0xEF, 0xCF, 0xDF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFB, 0xE1, 0xF7, 0xC7, 0xEF, 0xCF, 0x9F, 0xFF, 0x1F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0x9C, 0x07, 0xDF, 0x83, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F,
  0x8F, 0xCF, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFB, 0xF8, 0x7C, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x9F, 0x0F, 0xDF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x7E, 0xFC, 0x7C, 0xFC,
  0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFD, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7E, 0xF8, 0x3D, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x3C, 0x7D, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0x43, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x30, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0xC3, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC8, 0xFF, 0x87, 0xF8, 0x7F, 0x83,
  0xF8, 0x3F, 0x1F, 0x3F, 0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xFC,
  0xFC, 0xFD, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0xFC,
  0x3F, 0x7C, 0x3F, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0xFC, 0x7F,
  0xF1, 0xF8, 0xFB, 0xE7, 0xF1, 0xF7, 0xCF, 0xE7, 0xCF, 0x9F, 0xCF, 0x9F,
  0x7F, 0xBE, 0x3E, 0xFF, 0x7C, 0x7D, 0xDE, 0xF8, 0xFF, 0xBF, 0xE1, 0xFF,
  0x77, 0xC3, 0xDC, 0xEF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0x0F, 0xC7,
  0xF0, 0xFC, 0x7E, 0x07, 0xCF, 0xC0, 0x7E, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFB, 0xE0, 0x3F, 0x3E, 0x07,
  0xE3, 0xF0, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x3F,
  0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x03, 0xF8, 0x3F,
  0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 21, 9, 0, -21 },
  { 28, 12, 7, 14, 3, -21 },
  { 39, 19, 21, 18, 0, -21 },
  { 89, 15, 25, 16, 1, -23 },
  { 136, 24, 22, 26, 2, -22 },
  { 202, 20, 22, 21, 0, -22 },
  { 257, 6, 7, 7, 3, -21 },
  { 263, 11, 27, 10, 1, -22 },
  { 301, 11, 27, 10, -2, -22 },
  { 339, 14, 15, 15, 2, -23 },
  { 366, 15, 15, 17, 1, -18 },
  { 395, 8, 8, 9, -2, -4 },
  { 403, 9, 4, 10, 0, -10 },
  { 408, 6, 5, 9, 0, -5 },
  { 412, 17, 22, 13, -1, -22 },
  { 459, 15, 22, 16, 1, -22 },
  { 501, 13, 21, 16, 2, -21 },
  { 536, 17, 22, 16, -1, -22 },
  { 583, 16, 22, 16, 0, -22 },
  { 627, 16, 21, 16, 0, -21 },
  { 669, 16, 21, 16, 0, -21 },
  { 711, 16, 22, 16, 1, -22 },
  { 755, 17, 21, 16, 1, -21 },
  { 800, 15, 22, 16, 1, -22 },
  { 842, 15, 22, 16, 1, -22 },
  { 884, 9, 17, 9, 0, -17 },
  { 904, 11, 21, 9, -2, -17 },
  { 933, 14, 16, 17, 1, -19 },
  { 961, 15, 11, 17, 1, -16 },
  { 982, 15, 16, 17, 1, -19 },
  { 1012, 12, 22, 13, 2, -22 },
  { 1045, 23, 25, 25, 1, -22 },
  { 1117, 19, 21, 19, -2, -21 },
  { 1167, 18, 21, 18, 0, -21 },
  { 1215, 18, 22, 17, 1, -22 },
  { 1265, 18, 21, 19, 0, -21 },
  { 1313, 16, 21, 15, 0, -21 },
  { 1355, 16, 21, 15, 0, -21 },
  { 1397, 18, 22, 19, 1, -22 },
  { 1447, 20, 21, 20, 0, -21 },
  { 1500, 15, 21, 12, -1, -21 },
  { 1540, 16, 28, 10, -5, -21 },
  { 1596, 21, 21, 18, 0, -21 },
  { 1652, 13, 21, 14, 0, -21 },
  { 1687, 26, 21, 25, 0, -21 },
  { 1756, 22, 21, 22, 0, -21 },
  { 1814, 19, 22, 20, 1, -22 },
  { 1867, 17, 21, 17, 0, -21 },
  { 1912, 19, 27, 20, 1, -22 },
  { 1977, 17, 21, 18, 0, -21 },
  { 2022, 16, 22, 15, 0, -22 },
  { 2066, 15, 21, 15, 2, -21 },
  { 2106, 18, 21, 19, 2, -21 },
  { 2154, 18, 21, 17, 2, -21 },
  { 2202, 27, 21, 26, 2, -21 },
  { 2273, 22, 21, 18, -2, -21 },
  { 2331, 16, 21, 17, 3, -21 },
  { 2373, 18, 21, 15, -1, -21 },
  { 2421, 13, 27, 10, -1, -22 },
  { 2465, 8, 22, 13, 3, -22 },
  { 2487, 13, 27, 10, -2, -22 },
  { 2531, 15, 14, 15, 0, -21 },
  { 2558, 14, 4, 13, -3, 2 },
  { 2565, 7, 5, 10, 4, -23 },
  { 2570, 16, 17, 17, 1, -17 },
  { 2604, 16, 23, 17, 0, -23 },
  { 2650, 14, 17, 14, 1, -17 },
  { 2680, 17, 23, 17, 1, -23 },
  { 2729, 15, 17, 16, 1, -17 },
  { 2761, 17, 30, 11, -3, -23 },
  { 2825, 17, 24, 17, 0, -17 },
  { 2876, 16, 23, 17, 0, -23 },
  { 2922, 10, 23, 9, 0, -23 },
  { 2951, 14, 30, 9, -4, -23 },
  { 3004, 19, 23, 17, 0, -23 },
  { 3059, 10, 23, 9, 0, -23 },
  { 3088, 25, 17, 26, 0, -17 },
  { 3142, 16, 17, 17, 0, -17 },
  { 3176, 15, 17, 17, 1, -17 },
  { 3208, 17, 24, 17, -1, -17 },
  { 3259, 16, 24, 17, 1, -17 },
  { 3307, 14, 17, 12, 0, -17 },
  { 3337, 14, 17, 14, 0, -17 },
  { 3367, 12, 20, 12, 1, -20 },
  { 3397, 16, 17, 17, 1, -17 },
  { 3431, 16, 17, 15, 1, -17 },
  { 3465, 23, 17, 23, 2, -17 },
  { 3514, 20, 17, 16, -2, -17 },
  { 3557, 19, 24, 15, -2, -17 },
  { 3614, 15, 17, 14, -1, -17 },
  { 3646, 13, 26, 11, 0, -21 },
  { 3689, 5, 30, 15, 5, -23 },
  { 3708, 13, 26, 11, -2, -21 },
  { 3751, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC30PT7B_H_
