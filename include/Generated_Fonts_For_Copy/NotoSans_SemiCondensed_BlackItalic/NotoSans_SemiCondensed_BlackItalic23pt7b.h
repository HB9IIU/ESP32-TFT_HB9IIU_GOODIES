#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x7B, 0xDC, 0xEF, 0x7B, 0xDE, 0xE7, 0x39,
  0xC0, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x3F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xC3, 0x38, 0x1C, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x39, 0xC0,
  0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x01, 0x00, 0xFC, 0x1F, 0xF3, 0xFE, 0x7A,
  0x47, 0xA0, 0x7E, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0xDC, 0xCF,
  0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x87, 0xE0,
  0xE1, 0xFC, 0x38, 0x3B, 0x8F, 0x07, 0x71, 0xC1, 0xEE, 0x70, 0x39, 0xDE,
  0x07, 0x3B, 0xBC, 0xFE, 0xEF, 0xCF, 0xBD, 0xFC, 0xE7, 0x73, 0x81, 0xCE,
  0x70, 0x79, 0xDE, 0x0E, 0x3B, 0x83, 0x87, 0xF0, 0xF0, 0xFC, 0x3C, 0x0F,
  0x00, 0x01, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x7F, 0xDE, 0x7B, 0xFE, 0xF3,
  0xFC, 0xF1, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0x7C, 0x7B,
  0xBD, 0xEE, 0x70, 0x07, 0x87, 0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE0, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x00, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x00, 0x08, 0x03, 0xC8, 0xE3, 0xB8, 0xFF, 0xFF, 0xF1, 0xFC,
  0xF8, 0xF7, 0x1D, 0xC2, 0x78, 0x10, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3D, 0xE7,
  0x9C, 0xF3, 0x80, 0x7E, 0xFF, 0xFF, 0xE0, 0x77, 0xFD, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9F, 0xF7, 0xDE, 0xF3, 0xDE, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xCF, 0xF9, 0xEF, 0x3D, 0xEF, 0x3F, 0xE3, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xE3, 0xF9, 0xFE, 0xFF, 0x9B, 0xC4, 0xF0, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x01, 0xC0,
  0x3F, 0x87, 0xFE, 0x3F, 0xF0, 0xC7, 0x84, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF9, 0xFF, 0x8F, 0xFC,
  0xFF, 0xE0, 0x03, 0x81, 0xFE, 0x3F, 0xF1, 0xFF, 0x10, 0xF0, 0x0F, 0x01,
  0xE0, 0xFC, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xEC, 0x3E, 0xFF,
  0xCF, 0xFC, 0xFF, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0xE0,
  0xFE, 0x1D, 0xE3, 0xDE, 0x3B, 0xC7, 0x3C, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1C, 0x03,
  0xF8, 0x3F, 0xC3, 0xFE, 0x3F, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0xC3, 0xEF,
  0xFC, 0xFF, 0x8F, 0xF0, 0x01, 0xE0, 0xFF, 0x1F, 0xE3, 0xFE, 0x3C, 0x07,
  0x80, 0x7B, 0x8F, 0xFC, 0xFF, 0xCF, 0xBE, 0xF3, 0xEF, 0x3E, 0xF3, 0xCF,
  0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0x80,
  0xFE, 0x1F, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x1F, 0xF1, 0xFE, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0x9E, 0xF1, 0xEF, 0x9E, 0x7F, 0xE7, 0xFC, 0x3F, 0x80,
  0x07, 0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0x9F, 0xF3, 0xFE, 0x7F, 0xDF, 0xFF,
  0xEF, 0xFD, 0xFF, 0x09, 0xE0, 0x79, 0x1F, 0x3F, 0xC7, 0xF0, 0xFC, 0x00,
  0x1C, 0x7C, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0x8F, 0x00,
  0x0E, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0x78, 0x70, 0xF0, 0xE0, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xE7, 0xE1, 0xF0,
  0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xC1, 0xF9, 0xFC, 0xFE, 0x1F, 0x03, 0x80, 0x40,
  0x00, 0x0E, 0x0F, 0xE7, 0xFD, 0xFF, 0x23, 0xC0, 0xF0, 0x78, 0x7E, 0x3E,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x83, 0xE0, 0x70, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1E, 0x38, 0x03, 0x9C, 0x7E,
  0x67, 0x3F, 0x9F, 0x9C, 0xE7, 0xE7, 0x39, 0xBB, 0x8C, 0x6E, 0xE7, 0x3B,
  0xB9, 0xCE, 0xEF, 0xFF, 0x39, 0xEF, 0x8E, 0x31, 0x81, 0xC0, 0x20, 0x7E,
  0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xEE, 0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0x83, 0xCE, 0x1E, 0x38, 0x7F, 0xE3,
  0xFF, 0xCF, 0xFF, 0x7F, 0xFD, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x87, 0x9F, 0x1E, 0x78, 0xF9, 0xE3, 0xFF, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C, 0x79, 0xF1, 0xFF, 0x87, 0xFE,
  0x3F, 0xE0, 0x01, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x61, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0x9F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xF7,
  0xC7, 0x9E, 0x3E, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x1F, 0xF8,
  0xFF, 0x87, 0xFC, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0x87, 0xFC, 0x3F,
  0xC1, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0x87,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3E, 0x09, 0xF0,
  0x07, 0x80, 0x1E, 0x7E, 0xFB, 0xFB, 0xCF, 0xEF, 0x3F, 0x3C, 0x3C, 0xF8,
  0xF3, 0xE3, 0xC7, 0xFF, 0x1F, 0xF8, 0x1F, 0xC0, 0x1F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8,
  0x78, 0xF0, 0xF0, 0xF0, 0x1F, 0xF1, 0xFE, 0x0F, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x07,
  0xF0, 0xFF, 0x8F, 0xF0, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x89, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E, 0xF8, 0x1E, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0,
  0x79, 0xF0, 0x79, 0xF0, 0x78, 0xF0, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x7F,
  0xDF, 0xF7, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x9D, 0xC3, 0xF9, 0xFC,
  0x3F, 0xBB, 0xC3, 0xBB, 0xBC, 0x7B, 0xF3, 0xC7, 0xBF, 0x38, 0x7B, 0xF7,
  0x87, 0xBE, 0x78, 0x73, 0xE7, 0x8F, 0x3C, 0x78, 0x1F, 0x87, 0x8F, 0xC3,
  0xC7, 0xE1, 0xC3, 0xF1, 0xE1, 0xFC, 0xF1, 0xFE, 0x78, 0xFF, 0x3C, 0x7B,
  0x9C, 0x3D, 0xFE, 0x1C, 0xFF, 0x1E, 0x7F, 0x8F, 0x1F, 0x87, 0x8F, 0xC3,
  0xC7, 0xE1, 0xC3, 0xF1, 0xE0, 0xF8, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFF, 0x3E, 0x7D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1E, 0xF8, 0xFB, 0xE7, 0xC7, 0xFF, 0x1F, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7,
  0xFE, 0x3F, 0xF1, 0xFE, 0x1F, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7D, 0xF0,
  0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF8,
  0xFB, 0xE7, 0xC7, 0xFE, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3C, 0xF1, 0xE7, 0x9F,
  0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xF8, 0xF3, 0xC7, 0x9E,
  0x3C, 0xF9, 0xE3, 0xDE, 0x1F, 0x03, 0x80, 0xFF, 0x1F, 0xF3, 0xFE, 0x3C,
  0x23, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x83,
  0xCE, 0x7C, 0xFF, 0xCF, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0x3E, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0x1E,
  0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xF3, 0xE3, 0xCF, 0x0F,
  0x3C, 0x7C, 0xFB, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0xF0, 0xFF, 0x87,
  0xBC, 0x3D, 0xE3, 0xCF, 0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0xF0, 0xF7, 0x87,
  0xBC, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF0,
  0xF1, 0xFF, 0x1F, 0x1E, 0xF1, 0xF1, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xCF,
  0x3F, 0x78, 0xF7, 0xF7, 0x8F, 0x7F, 0x78, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0,
  0xEE, 0xEE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x87, 0x8F, 0x03, 0xCF, 0x81, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x03, 0xE7, 0xC1, 0xE1, 0xE1, 0xF0,
  0xF8, 0xF0, 0xFF, 0xCF, 0x9E, 0x78, 0xF7, 0x87, 0xBC, 0x3F, 0xC1, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x07, 0xC3, 0xF0, 0xFC, 0x38,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0xF1, 0xC7,
  0x1C, 0x71, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x1C, 0x07,
  0xC3, 0xF0, 0xFC, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x87, 0xE1, 0xF0,
  0xFC, 0x00, 0x03, 0x80, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xDC, 0x3C,
  0xE3, 0x8E, 0x70, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xE3, 0x8F,
  0x1E, 0xF3, 0xFF, 0x7F, 0xE7, 0xFE, 0xF9, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0x80, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0x78,
  0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0x7F, 0xEF, 0xFC, 0xF7, 0x80, 0x0F, 0x8F,
  0xF3, 0xF9, 0xF6, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x4F, 0xF1,
  0xFC, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE1, 0xEF, 0x1F,
  0xF9, 0xFF, 0x8F, 0xFC, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8F, 0x3C,
  0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0x7B, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF7, 0xF8, 0xF0, 0x1E, 0x13, 0xFE, 0x3F, 0xC3,
  0xF0, 0x00, 0x60, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3C, 0x03, 0xF8, 0x7F,
  0x83, 0xFC, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x08, 0x00, 0x0F, 0x78, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xCF,
  0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0xDF, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFC, 0x01, 0xE2, 0x0F, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x04, 0x00, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xEF, 0x3C,
  0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0x79, 0xEF, 0x1E, 0xF3,
  0xE0, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x01, 0xC0, 0x3C, 0x0F, 0x80,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0xE1,
  0xF8, 0x3E, 0x01, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x3C, 0xF9, 0xE3, 0xCF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC1, 0xEF, 0x87, 0x9E, 0x3C, 0x78, 0xF1, 0xF0, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0x1D, 0xE3, 0xC3, 0xFE, 0xF8, 0xFF, 0xFF, 0x9F, 0x7F,
  0xF3, 0xCF, 0x9E, 0x79, 0xE7, 0xDF, 0x3C, 0xF3, 0xC7, 0x9E, 0x79, 0xF3,
  0xCF, 0x3C, 0x79, 0xE7, 0x9F, 0x78, 0xF3, 0xCF, 0x3E, 0x78, 0x1D, 0xE1,
  0xFF, 0x3F, 0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0x79, 0xF7,
  0x9E, 0x79, 0xEF, 0x1E, 0xF3, 0xE0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xDE, 0x7B, 0xFE, 0x3F, 0xC3, 0xE0,
  0x0E, 0xF0, 0x7F, 0xC7, 0xFE, 0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0xF9, 0xE7, 0x8F, 0xFC, 0xFF, 0xC7, 0xBC, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0xF3, 0xFF, 0x7F, 0xE7,
  0xFE, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x7C, 0xFF, 0xCF,
  0xFC, 0x7F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x1C, 0xC7, 0xF3, 0xFC, 0xFF, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x00, 0x0F, 0x8F, 0xF3, 0xFD, 0xF2, 0x7C, 0x0F,
  0xC3, 0xF8, 0x7E, 0x07, 0xA1, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0x1E, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFB, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x4F,
  0xE7, 0xF1, 0xF8, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x9E,
  0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0x7C, 0xFF, 0xCF, 0xFC, 0x7B, 0xC0, 0xF0,
  0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0x73, 0xC7, 0x78, 0x77, 0x87, 0x70, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x00, 0xF1, 0xE3, 0xFC, 0xF9, 0xEF,
  0x3E, 0x7B, 0xCF, 0x9E, 0xF7, 0xEF, 0x3D, 0xFB, 0xCF, 0x6F, 0xE3, 0xFB,
  0xF8, 0xFE, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF0,
  0x00, 0x1E, 0x3C, 0x79, 0xF1, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xDE, 0x1E, 0x78, 0xF9, 0xF0,
  0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x1C, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x1F, 0xF1,
  0xFF, 0x1F, 0xE1, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x7F, 0xC7, 0xFC, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0xF8, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0xF8, 0xFC, 0x3C, 0x0F, 0x81, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0F, 0x83, 0xC7, 0xE3, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0xF8, 0x7C,
  0x3C, 0x18, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 16, 7, 0, -16 },
  { 17, 10, 6, 10, 2, -16 },
  { 25, 14, 16, 14, 0, -16 },
  { 53, 12, 18, 12, 1, -17 },
  { 80, 19, 17, 20, 1, -17 },
  { 121, 16, 17, 16, 0, -17 },
  { 155, 5, 6, 6, 2, -16 },
  { 159, 9, 21, 8, 1, -17 },
  { 183, 9, 21, 8, -2, -17 },
  { 207, 10, 12, 12, 2, -18 },
  { 222, 11, 11, 13, 1, -14 },
  { 238, 6, 6, 7, -1, -3 },
  { 243, 7, 4, 7, 0, -8 },
  { 247, 5, 4, 7, 0, -4 },
  { 250, 13, 17, 10, -1, -17 },
  { 278, 11, 17, 12, 1, -17 },
  { 302, 10, 16, 12, 2, -16 },
  { 322, 13, 17, 12, -1, -17 },
  { 350, 12, 17, 12, 0, -17 },
  { 376, 12, 16, 12, 0, -16 },
  { 400, 12, 16, 12, 0, -16 },
  { 424, 12, 17, 12, 1, -17 },
  { 450, 14, 16, 12, 0, -16 },
  { 478, 12, 17, 12, 0, -17 },
  { 504, 11, 17, 12, 1, -17 },
  { 528, 7, 13, 7, 0, -13 },
  { 540, 8, 16, 7, -1, -13 },
  { 556, 11, 12, 13, 1, -14 },
  { 573, 11, 8, 13, 1, -12 },
  { 584, 11, 12, 13, 1, -14 },
  { 601, 10, 17, 10, 1, -17 },
  { 623, 18, 19, 19, 1, -17 },
  { 666, 14, 16, 14, -1, -16 },
  { 694, 14, 16, 14, 0, -16 },
  { 722, 13, 17, 13, 1, -17 },
  { 750, 14, 16, 15, 0, -16 },
  { 778, 13, 16, 12, 0, -16 },
  { 804, 13, 16, 12, 0, -16 },
  { 830, 14, 17, 15, 1, -17 },
  { 860, 16, 16, 15, 0, -16 },
  { 892, 12, 16, 9, -1, -16 },
  { 916, 12, 21, 8, -4, -16 },
  { 948, 16, 16, 14, 0, -16 },
  { 980, 10, 16, 11, 0, -16 },
  { 1000, 20, 16, 20, 0, -16 },
  { 1040, 17, 16, 17, 0, -16 },
  { 1074, 14, 17, 16, 1, -17 },
  { 1104, 13, 16, 13, 0, -16 },
  { 1130, 14, 21, 16, 1, -17 },
  { 1167, 13, 16, 14, 0, -16 },
  { 1193, 12, 17, 12, 0, -17 },
  { 1219, 11, 16, 12, 2, -16 },
  { 1241, 14, 16, 15, 1, -16 },
  { 1269, 13, 16, 13, 2, -16 },
  { 1295, 20, 16, 20, 2, -16 },
  { 1335, 17, 16, 14, -1, -16 },
  { 1369, 13, 16, 13, 2, -16 },
  { 1395, 14, 16, 12, -1, -16 },
  { 1423, 10, 21, 8, -1, -17 },
  { 1450, 6, 17, 10, 2, -17 },
  { 1463, 10, 21, 8, -2, -17 },
  { 1490, 12, 10, 12, 0, -16 },
  { 1505, 10, 3, 10, -2, 1 },
  { 1509, 6, 4, 8, 3, -18 },
  { 1512, 12, 13, 13, 1, -13 },
  { 1532, 12, 17, 13, 0, -17 },
  { 1558, 10, 13, 11, 1, -13 },
  { 1575, 13, 17, 13, 1, -17 },
  { 1603, 11, 13, 12, 1, -13 },
  { 1621, 13, 24, 9, -2, -18 },
  { 1660, 13, 19, 13, 0, -13 },
  { 1691, 12, 17, 13, 0, -17 },
  { 1717, 8, 18, 7, 0, -18 },
  { 1735, 11, 24, 7, -3, -18 },
  { 1768, 14, 17, 13, 0, -17 },
  { 1798, 8, 17, 7, 0, -17 },
  { 1815, 19, 13, 20, 0, -13 },
  { 1846, 12, 13, 13, 0, -13 },
  { 1866, 11, 13, 13, 1, -13 },
  { 1884, 13, 19, 13, -1, -13 },
  { 1915, 12, 19, 13, 1, -13 },
  { 1944, 10, 13, 9, 0, -13 },
  { 1961, 10, 13, 11, 0, -13 },
  { 1978, 9, 15, 10, 1, -15 },
  { 1995, 12, 13, 13, 1, -13 },
  { 2015, 12, 13, 12, 1, -13 },
  { 2035, 18, 13, 18, 1, -13 },
  { 2065, 14, 13, 12, -1, -13 },
  { 2088, 14, 19, 12, -1, -13 },
  { 2122, 12, 13, 10, -1, -13 },
  { 2142, 10, 20, 8, 0, -16 },
  { 2167, 3, 23, 12, 4, -18 },
  { 2176, 9, 20, 8, -1, -16 },
  { 2199, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC23PT7B_H_
