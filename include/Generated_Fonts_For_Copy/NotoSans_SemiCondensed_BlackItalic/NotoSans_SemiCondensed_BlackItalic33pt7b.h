#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xC0, 0x7E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE0, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xE7,
  0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x07, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xCF, 0x01, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0x0F, 0x9E, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x7F, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0xC4, 0x3E, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xBE, 0x41, 0xDF, 0x38, 0xEF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x07, 0xF0, 0x0F, 0x83, 0xFE, 0x07,
  0xC1, 0xFF, 0x81, 0xE0, 0x7D, 0xE0, 0xF0, 0x3E, 0x78, 0x7C, 0x0F, 0x9E,
  0x1E, 0x03, 0xC7, 0x8F, 0x00, 0xF1, 0xE7, 0xC0, 0x3C, 0xF9, 0xE0, 0x0F,
  0x3C, 0xF3, 0xFB, 0xFF, 0x7D, 0xFF, 0xFF, 0x9E, 0xFF, 0xDF, 0xCF, 0x3F,
  0xF3, 0xE7, 0xDF, 0x3C, 0x01, 0xE7, 0xCF, 0x00, 0xF1, 0xE3, 0xC0, 0x7C,
  0x78, 0xF0, 0x1E, 0x1E, 0x7C, 0x0F, 0x07, 0x9E, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0x7F, 0xC0, 0xF0, 0x0F, 0xF0, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x08, 0x7F, 0xE7, 0xE1, 0xFF, 0x8F, 0xC7, 0xFF,
  0xBF, 0x1F, 0xFF, 0x7E, 0x3F, 0x7F, 0xF8, 0xFC, 0x7F, 0xF1, 0xF8, 0x7F,
  0xC3, 0xF0, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFC, 0x7E, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E,
  0x7C, 0xF0, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x41, 0xE0, 0x31, 0xE0, 0x7D, 0xE0, 0x7F, 0xDF, 0xFF, 0xFF,
  0x3F, 0xFF, 0x07, 0xFF, 0x0F, 0xE3, 0x3F, 0xE0, 0x7E, 0xF0, 0x3C, 0xF8,
  0x1C, 0xF8, 0x08, 0xF0, 0x00, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFE, 0xFF, 0x80, 0x38, 0xFB, 0xFF, 0xEF, 0xDF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xFD, 0xF8, 0xFC, 0x7C,
  0x7E, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC3,
  0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F,
  0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFB, 0xF1, 0xCF, 0xC2, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xF7, 0xF0, 0x30, 0xFC, 0x08, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x30,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x81, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xA0, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF,
  0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFB, 0xF0, 0x3C, 0xF8, 0x1E, 0x7E, 0x0F, 0x9F, 0x87, 0xC7,
  0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x03, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xCC, 0x07, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x30, 0x3F, 0x7E,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF8, 0xFD, 0xF8,
  0x7E, 0xFC, 0x7F, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8,
  0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0xBF, 0x0F, 0xFF, 0x03, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFB, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7C, 0x3F, 0x3E, 0x1F, 0x9F, 0x9F, 0xCF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFF, 0x3F, 0x3F, 0x7F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xBE, 0x1F, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0xEF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0x0F, 0x87, 0xF1, 0xFC, 0x7E, 0x1F, 0x83, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F, 0xE3, 0xF8, 0xFC,
  0x3E, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0xE3, 0xF2, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x03, 0xE1, 0xF0,
  0x70, 0x78, 0xF8, 0xFF, 0xDE, 0x3C, 0x7F, 0xE3, 0xDF, 0x3F, 0xF8, 0xF7,
  0x8F, 0x1E, 0x3D, 0xE7, 0xC7, 0x8F, 0xF9, 0xE3, 0xE7, 0xBC, 0x78, 0xF1,
  0xEF, 0x3E, 0x3C, 0x7B, 0xCF, 0x9F, 0x3C, 0xF3, 0xE7, 0xCF, 0x3C, 0xFF,
  0xFF, 0x8F, 0x1F, 0xFF, 0xC3, 0xE3, 0xE7, 0xE0, 0x78, 0x20, 0x40, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xBF, 0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0x01, 0xF3, 0xF0, 0x3F,
  0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0x03, 0xF7,
  0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x07, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x9F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF7, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7,
  0xE3, 0xF9, 0xF8, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xC7, 0x87, 0xF0, 0x21, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x18, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFD, 0xFF, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF3, 0xF8, 0x7F,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xC7, 0x8F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF9, 0xFF, 0x7E, 0x3F, 0xEF, 0xC7, 0xFD, 0xF9, 0xFF, 0x3F, 0x3F,
  0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7F,
  0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x07, 0xDE, 0x3D, 0xF0, 0x3E, 0xF3, 0xEF, 0x81, 0xF7, 0x9F, 0xFC,
  0x1F, 0xBC, 0xF7, 0xE0, 0xFD, 0xEF, 0xBF, 0x07, 0xEF, 0x79, 0xF0, 0x3E,
  0x7F, 0xCF, 0x81, 0xF3, 0xFC, 0xFC, 0x1F, 0x9F, 0xE7, 0xE0, 0xFC, 0xFE,
  0x3F, 0x07, 0xC7, 0xF1, 0xF0, 0x3E, 0x3F, 0x8F, 0x81, 0xF1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC7, 0xE0, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0x07, 0xF8,
  0x1F, 0x07, 0xF8, 0x3F, 0x0F, 0xF8, 0x3F, 0x0F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x3E, 0x0F, 0xFC, 0x7E, 0x0F, 0xFC, 0x7E, 0x1F, 0x7C, 0x7E, 0x1F, 0x7E,
  0x7C, 0x1F, 0x7E, 0x7C, 0x1F, 0x3E, 0xFC, 0x3F, 0x3E, 0xFC, 0x3F, 0x3F,
  0xF8, 0x3F, 0x3F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F,
  0xF0, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xBF, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x9F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E,
  0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xF7, 0xE0, 0xFE, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xF1, 0xC1, 0xF8, 0x10,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x20, 0x1F,
  0x86, 0x0F, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xF8,
  0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x83, 0xF8,
  0x7E, 0xF8, 0x3F, 0x87, 0xEF, 0x87, 0xF8, 0xFC, 0xF8, 0x7F, 0x8F, 0xCF,
  0x87, 0xF8, 0xFC, 0xF8, 0xFF, 0x9F, 0x8F, 0x8F, 0xF9, 0xF8, 0xF9, 0xFF,
  0x9F, 0x0F, 0x9F, 0xFB, 0xF0, 0xFB, 0xEF, 0x3E, 0x0F, 0xBE, 0xF7, 0xE0,
  0xFB, 0xCF, 0x7E, 0x0F, 0xFC, 0xF7, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x01,
  0xF9, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0xFC, 0x7E, 0x7F, 0x1F, 0x9F,
  0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF8, 0x3C,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xBE, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3D, 0xF0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0xF9, 0xF9, 0xF1, 0xE0, 0x01, 0x00, 0x41, 0xFB, 0xE0, 0xFE, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xEF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xDF, 0x03, 0xE7, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0xC0, 0x3E, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0x7F, 0x1F, 0x9F, 0xC7, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3E, 0x1F, 0x8F, 0x87, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0x87, 0xFF, 0xE3, 0xEF, 0xF0, 0xF9, 0xF8, 0x00, 0x00, 0x40, 0x0F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xF3, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x82, 0x3F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x63, 0xF0, 0x3F, 0x7C, 0x0F, 0xEF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xDF, 0xC7, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFB, 0xE0, 0x3E, 0x7C, 0x00, 0x00, 0x60, 0x03,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x7E, 0x3F, 0x7E,
  0x3F, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC,
  0x04, 0xFE, 0x18, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xE8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x04, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x20, 0x7E, 0xF8, 0x1F,
  0xDF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xBF, 0x8F, 0xE7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7D, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0x01, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x40, 0x3E, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7F, 0x7F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x00, 0x00, 0x80, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x21, 0xF8, 0xFE, 0x0F, 0x8F, 0xE0,
  0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x81, 0xF0, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x00, 0x0C, 0x02, 0x01, 0xF7, 0xE3, 0xF8,
  0x3F, 0xFE, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xBF,
  0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x87, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE1, 0xF8,
  0xFC, 0xFC, 0x7E, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x9F, 0x87, 0xE3, 0xF3, 0xF1, 0xF8, 0x7E, 0x00, 0x00, 0x04,
  0x03, 0xEF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF7, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7E, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC7, 0xE0, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFE, 0xFE, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x3E, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7,
  0xF0, 0x7C, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0x00, 0x41, 0xFB, 0xE0, 0xFE, 0xF8, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xEF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xEF, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0x1F, 0x7C, 0x3F, 0xF0, 0xFB, 0xE1,
  0xFF, 0xC3, 0xFF, 0x87, 0xF9, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE3,
  0xFF, 0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x1F, 0x90, 0x3F, 0x38, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xFF,
  0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xDF, 0x00, 0xFC, 0x3F, 0xFE,
  0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1,
  0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x7F, 0x1F, 0xFC, 0x3F, 0x8F, 0xBE, 0x3F, 0x8F, 0xDF, 0x1F, 0xC7,
  0xEF, 0x9F, 0xE7, 0xE7, 0xCF, 0xF3, 0xF3, 0xE7, 0xF9, 0xF1, 0xF7, 0xFD,
  0xF8, 0xFB, 0xDE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3,
  0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8,
  0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x07, 0xDF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xFC,
  0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0x80,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x80, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 24, 10, 0, -24 },
  { 34, 14, 9, 15, 3, -24 },
  { 50, 21, 24, 20, 0, -24 },
  { 113, 17, 27, 18, 1, -25 },
  { 171, 26, 24, 29, 2, -24 },
  { 249, 23, 24, 23, 0, -24 },
  { 318, 7, 9, 8, 3, -24 },
  { 326, 13, 29, 11, 1, -24 },
  { 374, 12, 29, 11, -2, -24 },
  { 418, 16, 16, 17, 2, -25 },
  { 450, 16, 16, 18, 1, -20 },
  { 482, 9, 8, 10, -2, -4 },
  { 491, 10, 5, 11, 0, -11 },
  { 498, 7, 6, 10, 0, -6 },
  { 504, 19, 24, 15, -2, -24 },
  { 561, 17, 24, 18, 1, -24 },
  { 612, 14, 24, 18, 3, -24 },
  { 654, 18, 24, 18, -1, -24 },
  { 708, 17, 24, 18, 0, -24 },
  { 759, 18, 24, 18, 0, -24 },
  { 813, 18, 24, 18, 0, -24 },
  { 867, 17, 24, 18, 1, -24 },
  { 918, 18, 24, 18, 1, -24 },
  { 972, 17, 24, 18, 1, -24 },
  { 1023, 16, 24, 18, 1, -24 },
  { 1071, 10, 18, 10, 0, -18 },
  { 1094, 12, 22, 10, -2, -18 },
  { 1127, 16, 18, 18, 1, -21 },
  { 1163, 16, 11, 18, 1, -17 },
  { 1185, 16, 18, 18, 1, -21 },
  { 1221, 14, 24, 15, 2, -24 },
  { 1263, 26, 27, 27, 1, -24 },
  { 1351, 20, 24, 21, -2, -24 },
  { 1411, 19, 24, 20, 0, -24 },
  { 1468, 19, 24, 19, 1, -24 },
  { 1525, 20, 24, 21, 0, -24 },
  { 1585, 18, 24, 17, 0, -24 },
  { 1639, 18, 24, 17, 0, -24 },
  { 1693, 19, 24, 21, 2, -24 },
  { 1750, 22, 24, 22, 0, -24 },
  { 1816, 16, 24, 13, -1, -24 },
  { 1864, 17, 31, 11, -5, -24 },
  { 1930, 23, 24, 20, 0, -24 },
  { 1999, 14, 24, 16, 0, -24 },
  { 2041, 29, 24, 28, 0, -24 },
  { 2128, 24, 24, 24, 0, -24 },
  { 2200, 21, 24, 22, 1, -24 },
  { 2263, 19, 24, 19, 0, -24 },
  { 2320, 21, 30, 22, 1, -24 },
  { 2399, 19, 24, 20, 0, -24 },
  { 2456, 18, 24, 17, 0, -24 },
  { 2510, 16, 24, 17, 3, -24 },
  { 2558, 20, 24, 21, 2, -24 },
  { 2618, 19, 24, 19, 3, -24 },
  { 2675, 28, 24, 29, 3, -24 },
  { 2759, 24, 24, 20, -2, -24 },
  { 2831, 18, 24, 19, 3, -24 },
  { 2885, 20, 24, 17, -1, -24 },
  { 2945, 14, 30, 11, -1, -24 },
  { 2998, 9, 24, 15, 3, -24 },
  { 3025, 14, 30, 11, -2, -24 },
  { 3078, 17, 16, 17, 0, -24 },
  { 3112, 15, 4, 14, -3, 2 },
  { 3120, 7, 5, 11, 5, -25 },
  { 3125, 18, 19, 19, 1, -19 },
  { 3168, 18, 25, 19, 0, -25 },
  { 3225, 15, 19, 15, 1, -19 },
  { 3261, 19, 25, 19, 1, -25 },
  { 3321, 16, 19, 18, 1, -19 },
  { 3359, 19, 33, 12, -3, -25 },
  { 3438, 19, 27, 19, 0, -19 },
  { 3503, 18, 25, 19, 0, -25 },
  { 3560, 11, 26, 10, 0, -26 },
  { 3596, 15, 34, 10, -4, -26 },
  { 3660, 21, 25, 19, 0, -25 },
  { 3726, 11, 25, 10, 0, -25 },
  { 3761, 27, 19, 28, 0, -19 },
  { 3826, 18, 19, 19, 0, -19 },
  { 3869, 16, 19, 18, 1, -19 },
  { 3907, 20, 27, 19, -2, -19 },
  { 3975, 18, 27, 19, 1, -19 },
  { 4036, 15, 19, 13, 0, -19 },
  { 4072, 15, 19, 15, 0, -19 },
  { 4108, 13, 22, 14, 1, -22 },
  { 4144, 18, 18, 19, 1, -18 },
  { 4185, 17, 18, 17, 2, -18 },
  { 4224, 25, 18, 25, 2, -18 },
  { 4281, 21, 18, 17, -2, -18 },
  { 4329, 21, 26, 17, -2, -18 },
  { 4398, 17, 18, 15, -1, -18 },
  { 4437, 14, 29, 12, 0, -24 },
  { 4488, 5, 33, 17, 6, -25 },
  { 4509, 14, 29, 12, -2, -24 },
  { 4560, 16, 7, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC33PT7B_H_
