#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x7F, 0xCF, 0xFB, 0xFC,
  0x7F, 0x9F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3,
  0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFD, 0xE3, 0x80,
  0xFF, 0x38, 0x10, 0x1F, 0xE7, 0x00, 0x03, 0xFD, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x73, 0xFC, 0x20, 0x0E, 0x7F, 0x87, 0x03, 0xCF, 0xF0, 0xF8, 0x7B, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x10, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF,
  0x3F, 0x8F, 0xF0, 0xFE, 0x7F, 0x3F, 0x8F, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF,
  0xFF, 0x3F, 0xFF, 0x9F, 0xCF, 0xFF, 0xCF, 0xFF, 0x9F, 0xCF, 0xFF, 0xE7,
  0xFF, 0x8F, 0xE7, 0xFF, 0xF9, 0xFF, 0x8F, 0xE7, 0xF9, 0xFC, 0x3F, 0x0F,
  0xE3, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x03, 0xFC,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x03, 0xFB,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x20, 0x3F, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F,
  0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0x3F, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xCF, 0xF3, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x02, 0x03, 0xF0, 0x07, 0x0F, 0xE0, 0x1F, 0x1F,
  0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0x7F, 0x01,
  0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xE1, 0xFE, 0x01, 0x83, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F,
  0xE7, 0xFE, 0x1F, 0xF3, 0xFE, 0x0F, 0xFB, 0xFF, 0x07, 0xFD, 0xFF, 0x83,
  0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE,
  0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFF, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0xC7, 0xFC, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xF7, 0xF8, 0x3F, 0x3F,
  0xE0, 0xF8, 0xFF, 0x81, 0xC3, 0xFE, 0x04, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0xE0, 0x1E,
  0x07, 0xFC, 0x03, 0x80, 0xFF, 0x80, 0x20, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xE0, 0x7F, 0xE0, 0x10, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x40, 0x00, 0xFF, 0x8C, 0x00, 0x3F, 0xF1, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xEF, 0xF8,
  0x03, 0xF9, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xF1,
  0xFF, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC2,
  0x00, 0x1F, 0xF8, 0x60, 0x07, 0xFF, 0x0F, 0x81, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFC, 0x03, 0xFD,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF,
  0xCF, 0xFC, 0x3F, 0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0,
  0xFF, 0xCF, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xFE, 0x3F,
  0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xC3, 0xFE, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF,
  0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF,
  0x1F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xEF, 0xFC, 0x1F, 0xF7, 0xFC, 0x0F,
  0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xE3,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xF8, 0x1F, 0xF7, 0xFC, 0x07,
  0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x04, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x03, 0xF8, 0x0F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1E,
  0x0F, 0xFC, 0x60, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0xFF, 0xC3, 0xF8, 0xFE, 0x07, 0xFF, 0xE7, 0xF1, 0xF8, 0x3F, 0xFF,
  0xC7, 0xE7, 0xF0, 0xFF, 0xFF, 0x8F, 0xCF, 0xC1, 0xFF, 0xFE, 0x1F, 0xBF,
  0x87, 0xF8, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xF8, 0x7E, 0xFC, 0x3F, 0x87,
  0xF0, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xFF, 0xE1, 0xFC, 0x1F, 0x83, 0xFF,
  0xC3, 0xF0, 0x7F, 0x0F, 0xFF, 0x8F, 0xE0, 0xFE, 0x1F, 0xBF, 0x1F, 0xC1,
  0xF8, 0x3F, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0xFC, 0x7F, 0x0F, 0xE1, 0xF9,
  0xF8, 0xFE, 0x3F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0xBF, 0xFC, 0x1F, 0xC3, 0xFF, 0x7F, 0xF0,
  0x3F, 0x83, 0xF8, 0x7F, 0x80, 0x3F, 0x00, 0x80, 0x38, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0,
  0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x7F, 0xF0, 0x06, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0xC0, 0x3F, 0xFC, 0x7E, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xF0, 0x1F, 0xFE,
  0x00, 0x60, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE1, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0x07, 0xFF,
  0xE3, 0xFE, 0x1F, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0x1F, 0xF8, 0x7F, 0xFE,
  0x3F, 0xF0, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0x8F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFB, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x07, 0xF7,
  0xF8, 0x07, 0xFB, 0xF0, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0x0F, 0xEF, 0xF8,
  0x07, 0xFB, 0xF0, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF3, 0xF1, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x9F, 0xDF, 0xF0, 0x0F, 0xF3,
  0xFB, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xBF, 0x9F, 0xE0, 0x1F, 0xF3, 0xFF,
  0xF1, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0x3F, 0xE0, 0x1F, 0xE3, 0xFF, 0xE3,
  0xFE, 0x01, 0xFE, 0x3F, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xC3, 0xFC,
  0x03, 0xFE, 0x3F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0xC7, 0xFC, 0x03,
  0xFC, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xF8, 0x07,
  0xFB, 0xFC, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0xFF, 0x80, 0x7F, 0xBF, 0xE3,
  0xFE, 0x01, 0xFE, 0xFF, 0x8F, 0xF0, 0x07, 0xF9, 0xFE, 0x3F, 0xC0, 0x3F,
  0xE7, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xF7, 0xFC, 0x03, 0xFC, 0x7F, 0xDF,
  0xF0, 0x0F, 0xF0, 0xFF, 0x7F, 0x80, 0x7F, 0xC3, 0xFD, 0xFE, 0x01, 0xFF,
  0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFD, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0x80,
  0x60, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0x00, 0x1F, 0xF8, 0x30, 0x03,
  0xFF, 0x07, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0x80, 0xFF, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01,
  0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF9, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x87, 0xFC,
  0x1F, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF,
  0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF, 0xF8,
  0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0xFE, 0xFE, 0x7F,
  0xC0, 0x3F, 0xCF, 0xF7, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x3F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xF9, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xCF, 0xEF, 0xF8, 0x03,
  0xFD, 0xFC, 0x7F, 0x7F, 0x80, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xFB, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07,
  0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xEF, 0xC0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x87, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x0F, 0xFE, 0xFF,
  0x03, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xF1,
  0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x83,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x70, 0x01, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC,
  0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x9F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xF7, 0xFF,
  0xC1, 0xFE, 0x7F, 0xE0, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xF0,
  0x30, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x04, 0x1F,
  0xF8, 0x78, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x0E, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xF7,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0x9F, 0xF0,
  0x7F, 0xCF, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x87, 0xFC, 0x01, 0x83,
  0xFF, 0x87, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC4, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x3F, 0xFB, 0xFC, 0x03, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF9,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00,
  0x7F, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x80, 0x0F, 0xFC, 0x07, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x70,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF8, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07,
  0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F,
  0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0xCF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0,
  0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0xFE, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0x9F,
  0xFC, 0x7F, 0xF0, 0x0F, 0xEF, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x7F, 0x1F, 0xF0, 0x0F, 0xE7, 0xFF, 0x01, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFE, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF8,
  0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFF, 0x9F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFE,
  0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F,
  0xCF, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xF8, 0x01, 0xFD, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFE,
  0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xC0, 0x7F, 0xCF,
  0xF8, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xF0, 0x20, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x0F, 0xFE, 0xFF, 0x03,
  0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFC, 0xFF, 0x80, 0x04, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x30, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFC, 0x3C, 0x1F, 0xF8, 0x10, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x88, 0x01, 0xFF, 0x1C, 0x03, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC2, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x03, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0x80, 0xFF, 0xCF, 0xF0, 0x0F, 0xF1,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF,
  0xF8, 0x1F, 0xFB, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3,
  0xFE, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F,
  0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xF0, 0xFF,
  0x9F, 0xE1, 0xFF, 0xE1, 0xFF, 0x3F, 0xC3, 0xFF, 0xC7, 0xFC, 0x7F, 0x8F,
  0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xFE, 0x7F,
  0xC3, 0xFC, 0xFF, 0xFC, 0xFF, 0x07, 0xF9, 0xFB, 0xFB, 0xFE, 0x0F, 0xF3,
  0xF7, 0xF7, 0xF8, 0x1F, 0xEF, 0xEF, 0xCF, 0xF0, 0x3F, 0xDF, 0x9F, 0xBF,
  0xC0, 0x7F, 0xBF, 0x3F, 0x7F, 0x80, 0xFF, 0xFE, 0x7E, 0xFF, 0x01, 0xFF,
  0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xFF,
  0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x8F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xF8, 0x01, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 37, 15, 0, -36 },
  { 80, 21, 13, 23, 5, -36 },
  { 115, 32, 36, 31, 0, -36 },
  { 259, 27, 42, 28, 1, -39 },
  { 401, 41, 37, 45, 3, -37 },
  { 591, 35, 38, 35, 0, -37 },
  { 758, 10, 13, 12, 5, -36 },
  { 775, 20, 45, 17, 1, -37 },
  { 888, 20, 45, 17, -4, -37 },
  { 1001, 23, 25, 26, 4, -39 },
  { 1073, 24, 24, 28, 2, -30 },
  { 1145, 14, 13, 15, -3, -6 },
  { 1168, 15, 8, 16, 1, -18 },
  { 1183, 10, 10, 15, 0, -9 },
  { 1196, 29, 38, 22, -3, -37 },
  { 1334, 25, 38, 28, 2, -37 },
  { 1453, 22, 36, 28, 4, -36 },
  { 1552, 27, 37, 28, -1, -37 },
  { 1677, 27, 38, 28, 0, -37 },
  { 1806, 27, 36, 28, 0, -36 },
  { 1928, 27, 37, 28, 1, -36 },
  { 2053, 26, 38, 28, 2, -37 },
  { 2177, 29, 36, 28, 1, -36 },
  { 2308, 26, 38, 28, 1, -37 },
  { 2432, 25, 38, 28, 2, -37 },
  { 2551, 15, 30, 15, 0, -29 },
  { 2608, 18, 36, 15, -3, -29 },
  { 2689, 24, 27, 28, 2, -32 },
  { 2770, 24, 18, 28, 2, -27 },
  { 2824, 24, 27, 28, 2, -32 },
  { 2905, 22, 38, 23, 3, -37 },
  { 3010, 39, 41, 42, 2, -37 },
  { 3210, 32, 36, 32, -3, -36 },
  { 3354, 30, 36, 30, 0, -36 },
  { 3489, 29, 38, 29, 2, -37 },
  { 3627, 31, 36, 32, 0, -36 },
  { 3767, 28, 36, 26, 0, -36 },
  { 3893, 28, 36, 26, 0, -36 },
  { 4019, 31, 38, 33, 2, -37 },
  { 4167, 35, 36, 34, 0, -36 },
  { 4325, 26, 36, 21, -2, -36 },
  { 4442, 26, 47, 17, -8, -36 },
  { 4595, 36, 36, 31, 0, -36 },
  { 4757, 22, 36, 24, 0, -36 },
  { 4856, 44, 36, 43, 0, -36 },
  { 5054, 38, 36, 37, 0, -36 },
  { 5225, 32, 38, 35, 2, -37 },
  { 5377, 29, 36, 29, 0, -36 },
  { 5508, 32, 46, 35, 2, -37 },
  { 5692, 29, 36, 30, 0, -36 },
  { 5823, 27, 38, 26, 0, -37 },
  { 5952, 25, 36, 26, 4, -36 },
  { 6065, 31, 37, 33, 3, -36 },
  { 6209, 30, 36, 30, 4, -36 },
  { 6344, 45, 36, 44, 4, -36 },
  { 6547, 38, 36, 31, -3, -36 },
  { 6718, 29, 36, 29, 4, -36 },
  { 6849, 31, 36, 26, -2, -36 },
  { 6989, 23, 46, 17, -2, -37 },
  { 7122, 14, 38, 22, 5, -37 },
  { 7189, 23, 46, 17, -4, -37 },
  { 7322, 26, 24, 26, 0, -36 },
  { 7400, 24, 6, 22, -5, 3 },
  { 7418, 12, 8, 18, 7, -39 },
  { 7430, 27, 30, 29, 2, -29 },
  { 7532, 27, 40, 29, 0, -39 },
  { 7667, 23, 30, 24, 2, -29 },
  { 7754, 29, 40, 29, 2, -39 },
  { 7899, 25, 30, 27, 2, -29 },
  { 7993, 29, 51, 19, -5, -39 },
  { 8178, 29, 41, 29, 0, -29 },
  { 8327, 27, 39, 29, 0, -39 },
  { 8459, 17, 40, 15, 0, -40 },
  { 8544, 24, 52, 15, -7, -40 },
  { 8700, 32, 39, 29, 0, -39 },
  { 8856, 17, 39, 15, 0, -39 },
  { 8939, 42, 29, 43, 0, -29 },
  { 9092, 27, 29, 29, 0, -29 },
  { 9190, 25, 30, 29, 2, -29 },
  { 9284, 29, 41, 29, -2, -29 },
  { 9433, 27, 41, 29, 2, -29 },
  { 9572, 23, 29, 21, 0, -29 },
  { 9656, 23, 30, 23, 0, -29 },
  { 9743, 20, 35, 21, 2, -34 },
  { 9831, 27, 29, 29, 2, -28 },
  { 9929, 26, 28, 26, 3, -28 },
  { 10020, 39, 28, 39, 3, -28 },
  { 10157, 33, 28, 27, -3, -28 },
  { 10273, 32, 40, 26, -3, -28 },
  { 10433, 25, 28, 23, -1, -28 },
  { 10521, 22, 44, 18, 0, -36 },
  { 10642, 7, 51, 26, 9, -39 },
  { 10687, 21, 44, 18, -3, -36 },
  { 10803, 24, 10, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC51PT7B_H_
