#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1E,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0x7D,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xC7, 0x3C, 0xF3, 0xC0, 0x01, 0xCF,
  0x01, 0xE7, 0x00, 0xF3, 0x80, 0x73, 0xC0, 0x39, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x0F, 0x38, 0x07, 0x3C, 0x03, 0x9E, 0x1F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x73, 0x80, 0x79, 0xC0, 0x39, 0xE0, 0x1C, 0xF0,
  0x1E, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x3E, 0x03, 0xFF, 0x1F, 0xF8,
  0xFF, 0xE3, 0xD9, 0x0F, 0x60, 0x3F, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x6F, 0x31, 0xBC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC,
  0x1F, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x21, 0xF8,
  0x1E, 0x1F, 0xE0, 0xE0, 0xFF, 0x0F, 0x0F, 0x78, 0xF0, 0x7B, 0xC7, 0x03,
  0x9E, 0x78, 0x1C, 0xF7, 0x80, 0xE7, 0x38, 0xE7, 0xFB, 0xDF, 0xBF, 0xBD,
  0xFE, 0xF9, 0xCF, 0xF1, 0x1E, 0xF3, 0x81, 0xE7, 0xBC, 0x0E, 0x39, 0xE0,
  0xF1, 0xCF, 0x0F, 0x0E, 0x70, 0x70, 0x7F, 0x87, 0x83, 0xF8, 0x78, 0x0F,
  0x80, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0x3E,
  0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFD, 0xF1,
  0xFE, 0x7D, 0xFF, 0x9F, 0x7D, 0xFF, 0xBE, 0x7F, 0xCF, 0x8F, 0xF3, 0xE3,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x7E, 0x7D, 0xE7,
  0x9E, 0x79, 0xCF, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x83,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x06, 0x00, 0x78, 0x07, 0x86,
  0x78, 0x7F, 0x1F, 0xFF, 0x7F, 0xF1, 0xFF, 0x3F, 0x87, 0xF8, 0xFB, 0xC3,
  0x3E, 0x11, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0x3E, 0xF9, 0xE3, 0xCF, 0x1E, 0x38, 0x00, 0x7F, 0x7F, 0x7F, 0xFE,
  0x37, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x80, 0x3F, 0x83, 0xFC, 0x3F,
  0xF3, 0xFF, 0x9F, 0x3D, 0xF1, 0xEF, 0x8F, 0x7C, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0xFB, 0xE7, 0xDF, 0x7E, 0xFF, 0xE7, 0xFE, 0x1F,
  0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x0F, 0xE3, 0xFE, 0x7F, 0xEF, 0xFE,
  0x7B, 0xC2, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x40, 0x07, 0xF0,
  0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xC7, 0xC1, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x80,
  0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x21, 0xF0, 0x07, 0xC0, 0x3E,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xA0, 0x7E, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xDE, 0x07, 0xFC,
  0x1E, 0xF8, 0x79, 0xE0, 0xE3, 0xC3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0x47, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x20,
  0x7E, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x30, 0x0F,
  0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xC8, 0xF8, 0x07, 0xC0, 0x1F, 0x78, 0x7B,
  0xF3, 0xFF, 0xCF, 0xFF, 0xBF, 0x7E, 0xF8, 0xFB, 0xE3, 0xEF, 0x9F, 0x3E,
  0x7C, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x7F, 0x87,
  0xFE, 0x7F, 0xF3, 0xE7, 0x9F, 0x3C, 0xF9, 0xE7, 0xDF, 0x3F, 0xF0, 0xFE,
  0x07, 0xF8, 0xFF, 0xCF, 0xDF, 0x7C, 0xFB, 0xC3, 0xDE, 0x3E, 0xFB, 0xF7,
  0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x7F, 0xF7,
  0xFF, 0xBE, 0x7D, 0xF3, 0xEF, 0x1F, 0x78, 0xFB, 0xEF, 0xDF, 0xFE, 0xFF,
  0xF3, 0xEF, 0x0C, 0xF8, 0x07, 0x80, 0x7C, 0xFF, 0xC7, 0xFC, 0x3F, 0xC1,
  0xF8, 0x00, 0x0E, 0x1F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x78, 0xF8, 0xF8, 0xF8, 0x03, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0xFF, 0x1F, 0xE3, 0xF8, 0x1F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0xFF, 0x3F,
  0xE1, 0xFC, 0x0F, 0x00, 0x60, 0x00, 0x04, 0x07, 0xFB, 0xFF, 0x3F, 0xF7,
  0xFE, 0x87, 0xC0, 0xF8, 0x3E, 0x1F, 0xC7, 0xE0, 0xF8, 0x3E, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x18,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0xC1, 0xF0, 0x0F, 0x1E,
  0x00, 0x38, 0xE3, 0xFD, 0xEF, 0x3F, 0xEF, 0x73, 0xEE, 0x3F, 0x9E, 0x71,
  0xFD, 0xE3, 0x9F, 0xCF, 0x3C, 0xEE, 0x71, 0xE7, 0x73, 0x8E, 0x7B, 0x9F,
  0xFF, 0x9C, 0xFD, 0xF8, 0xF3, 0xCF, 0x87, 0x80, 0x00, 0x1E, 0x00, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07,
  0xDE, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7C, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xFF, 0x03,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC0, 0x00, 0x60, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFC, 0x3F, 0x04, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x3F,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xF1, 0xF3, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x80,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x84, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x38, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8,
  0x10, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0x3E, 0x7F, 0x3F, 0x3F, 0x9F,
  0x3F, 0xCF, 0x9F, 0xE7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F,
  0x87, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0x87, 0xE1, 0xF1,
  0xF0, 0x3E, 0x7E, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x0F, 0xC3, 0xE1, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xEF, 0x0F, 0xF3, 0xFE, 0x3F, 0xE7,
  0xFC, 0x7F, 0xDE, 0xF0, 0xF7, 0xBD, 0xE1, 0xEF, 0xF7, 0xC3, 0xDF, 0xEF,
  0x8F, 0xBF, 0x9E, 0x1F, 0x7F, 0x3C, 0x3C, 0xFC, 0xF8, 0x79, 0xF9, 0xF0,
  0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0x80, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F,
  0xE1, 0xE1, 0xFE, 0x1E, 0x1F, 0xE3, 0xE1, 0xFE, 0x3E, 0x1F, 0xF3, 0xE1,
  0xFF, 0x3C, 0x3E, 0xF3, 0xC3, 0xEF, 0x7C, 0x3C, 0xFF, 0xC3, 0xCF, 0xFC,
  0x3C, 0x7F, 0x87, 0xC7, 0xF8, 0x7C, 0x7F, 0x87, 0x87, 0xF8, 0x78, 0x3F,
  0x07, 0x83, 0xF0, 0xF8, 0x3F, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xFC, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB,
  0xE0, 0xF9, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x1F,
  0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xF1, 0xF8, 0xFC, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xFF, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xE0, 0xF9, 0xF8,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x3F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3E, 0xF0, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7E, 0x00,
  0x40, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFC, 0x23, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC8,
  0x1F, 0x38, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x7F, 0xFD,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x7C,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0x87, 0xC7,
  0xC3, 0xE3, 0xF3, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0,
  0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xF8, 0x78, 0xF8, 0x79, 0xF0, 0x79, 0xF0, 0x7B, 0xE0, 0x7B, 0xE0, 0x7B,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E,
  0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x7C, 0xF9, 0xFC, 0x78, 0xF9, 0xFC, 0xF8,
  0xF9, 0xFC, 0xF8, 0xFB, 0xFD, 0xF0, 0xFB, 0xFD, 0xF0, 0xFF, 0xBD, 0xE0,
  0xFF, 0xBF, 0xE0, 0xF7, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFB, 0xE0, 0x1F,
  0xBE, 0x01, 0xF3, 0xF0, 0x3F, 0x1F, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0x80,
  0xF8, 0x3F, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7D, 0xF0, 0x3D, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8, 0xF0,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0xEF, 0x07, 0x9C, 0x3C, 0x78, 0xF1, 0xE7, 0x87, 0xBC, 0x0F, 0x7F,
  0xFB, 0xFF, 0xBF, 0xFC, 0xFB, 0xE7, 0xCF, 0x1C, 0x0F, 0x3C, 0x7E, 0xF3,
  0xFF, 0xDF, 0xFE, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0x87, 0xDE, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x7C, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1F, 0x7C, 0xF9, 0xFF, 0xE7, 0xFF, 0x3F, 0xFC, 0xF3, 0xC0,
  0x07, 0xE1, 0xFF, 0x3F, 0xE7, 0xFE, 0x7C, 0x27, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x4F, 0xFC, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x83, 0xDF,
  0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F,
  0x1F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x07, 0xDE, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0xFD, 0xF7, 0xCF, 0xBC,
  0x7F, 0xFF, 0xDF, 0xFC, 0xFF, 0xC7, 0xC0, 0x3E, 0x09, 0xF9, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xF2, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0x9E,
  0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE,
  0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xF1, 0xC7, 0xC3, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xFC, 0xFC, 0xF9, 0xF1,
  0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xF9, 0xF1,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x80, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x20,
  0x00, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x40, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x7E, 0x3E, 0x7E, 0x1F, 0x7E, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E,
  0xFC, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xC0, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x80, 0x1E, 0x78, 0xF8, 0x7F,
  0xF7, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x3E, 0x7C, 0xF8, 0xF9,
  0xF3, 0xE7, 0xC7, 0xCF, 0x1F, 0x1F, 0x7C, 0x7C, 0xF9, 0xF1, 0xF3, 0xE7,
  0xC7, 0x8F, 0x9F, 0x3E, 0x3E, 0x78, 0xF8, 0xFB, 0xE3, 0xE7, 0xCF, 0x8F,
  0x9F, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF3, 0xF3, 0xE7,
  0xC7, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xE7,
  0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE,
  0x7F, 0xF7, 0xCF, 0xBE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x7D, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0x7C, 0x1F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x8F, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF9, 0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x1F, 0x78,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0xDF, 0xFE, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F,
  0xBE, 0x3E, 0xF8, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF,
  0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x71, 0xEF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0xE1, 0xFF, 0x3F, 0xF3, 0xE6, 0x3E, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x83, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x00, 0x07,
  0x01, 0xE0, 0x7C, 0x1F, 0xFF, 0xFD, 0xFF, 0xBF, 0xF1, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0,
  0x3E, 0x3C, 0xF9, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3E, 0xF8, 0xFB, 0xE7, 0xCF, 0x9F, 0x3F, 0xFC, 0xFF, 0xF3, 0xFB,
  0xC7, 0xDE, 0x00, 0xF8, 0x7F, 0xE1, 0xF7, 0x8F, 0x9E, 0x3E, 0x79, 0xF1,
  0xE7, 0xC7, 0xBE, 0x1E, 0xF8, 0x7B, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0xF8, 0xFB, 0xC7, 0xC7, 0xDE,
  0x7E, 0x3C, 0xF3, 0xF3, 0xE7, 0x9F, 0x9E, 0x3D, 0xFD, 0xF1, 0xEE, 0xEF,
  0x0F, 0xF7, 0x78, 0x7F, 0x3F, 0xC3, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0, 0xFC,
  0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F,
  0xC3, 0xE7, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7D,
  0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0x8F, 0x87,
  0xC3, 0xC7, 0xC1, 0xE3, 0xE0, 0xF3, 0xE0, 0x79, 0xF0, 0x3D, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0xFE,
  0x0F, 0x00, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x7F,
  0x03, 0xE0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 19, 8, 0, -19 },
  { 23, 12, 7, 12, 2, -19 },
  { 34, 17, 19, 16, 0, -19 },
  { 75, 14, 23, 15, 1, -21 },
  { 116, 21, 20, 24, 2, -20 },
  { 169, 18, 20, 18, 0, -20 },
  { 214, 6, 7, 6, 2, -19 },
  { 220, 10, 24, 9, 1, -20 },
  { 250, 11, 24, 9, -2, -20 },
  { 283, 12, 13, 14, 2, -21 },
  { 303, 13, 13, 15, 1, -16 },
  { 325, 7, 7, 8, -1, -3 },
  { 332, 8, 4, 9, 0, -9 },
  { 336, 5, 5, 8, 0, -5 },
  { 340, 15, 20, 12, -1, -20 },
  { 378, 13, 20, 15, 1, -20 },
  { 411, 12, 19, 15, 2, -19 },
  { 440, 15, 20, 15, -1, -20 },
  { 478, 14, 20, 15, 0, -20 },
  { 513, 15, 19, 15, 0, -19 },
  { 549, 15, 19, 15, 0, -19 },
  { 585, 14, 20, 15, 1, -20 },
  { 620, 15, 19, 15, 1, -19 },
  { 656, 13, 20, 15, 1, -20 },
  { 689, 13, 20, 15, 1, -20 },
  { 722, 8, 15, 8, 0, -15 },
  { 737, 10, 19, 8, -2, -15 },
  { 761, 13, 14, 15, 1, -17 },
  { 784, 13, 9, 15, 1, -14 },
  { 799, 13, 14, 15, 1, -17 },
  { 822, 11, 20, 12, 2, -20 },
  { 850, 21, 22, 22, 1, -20 },
  { 908, 17, 19, 17, -2, -19 },
  { 949, 16, 19, 16, 0, -19 },
  { 987, 16, 20, 15, 1, -20 },
  { 1027, 17, 19, 17, 0, -19 },
  { 1068, 15, 19, 14, 0, -19 },
  { 1104, 15, 19, 14, 0, -19 },
  { 1140, 17, 20, 17, 1, -20 },
  { 1183, 18, 19, 18, 0, -19 },
  { 1226, 14, 19, 11, -1, -19 },
  { 1260, 14, 25, 9, -4, -19 },
  { 1304, 19, 19, 17, 0, -19 },
  { 1350, 12, 19, 13, 0, -19 },
  { 1379, 23, 19, 23, 0, -19 },
  { 1434, 20, 19, 20, 0, -19 },
  { 1482, 17, 20, 18, 1, -20 },
  { 1525, 16, 19, 15, 0, -19 },
  { 1563, 17, 25, 18, 1, -20 },
  { 1617, 16, 19, 16, 0, -19 },
  { 1655, 14, 20, 14, 0, -20 },
  { 1690, 14, 19, 14, 2, -19 },
  { 1724, 17, 19, 17, 1, -19 },
  { 1765, 16, 19, 16, 2, -19 },
  { 1803, 24, 19, 23, 2, -19 },
  { 1860, 20, 19, 16, -2, -19 },
  { 1908, 16, 19, 15, 2, -19 },
  { 1946, 16, 19, 14, -1, -19 },
  { 1984, 12, 25, 9, -1, -20 },
  { 2022, 7, 20, 12, 3, -20 },
  { 2040, 12, 25, 9, -2, -20 },
  { 2078, 14, 12, 14, 0, -19 },
  { 2099, 13, 3, 12, -3, 2 },
  { 2104, 6, 5, 9, 4, -21 },
  { 2108, 14, 15, 15, 1, -15 },
  { 2135, 14, 21, 15, 0, -21 },
  { 2172, 12, 15, 13, 1, -15 },
  { 2195, 15, 21, 15, 1, -21 },
  { 2235, 13, 15, 14, 1, -15 },
  { 2260, 16, 27, 10, -3, -21 },
  { 2314, 15, 21, 15, 0, -15 },
  { 2354, 15, 21, 16, 0, -21 },
  { 2394, 9, 21, 8, 0, -21 },
  { 2418, 12, 27, 8, -3, -21 },
  { 2459, 17, 21, 15, 0, -21 },
  { 2504, 9, 21, 8, 0, -21 },
  { 2528, 22, 15, 23, 0, -15 },
  { 2570, 15, 15, 16, 0, -15 },
  { 2599, 13, 15, 15, 1, -15 },
  { 2624, 15, 21, 15, -1, -15 },
  { 2664, 14, 21, 15, 1, -15 },
  { 2701, 12, 15, 11, 0, -15 },
  { 2724, 12, 15, 12, 0, -15 },
  { 2747, 11, 18, 11, 1, -18 },
  { 2772, 14, 15, 16, 1, -15 },
  { 2799, 14, 15, 14, 1, -15 },
  { 2826, 21, 15, 21, 1, -15 },
  { 2866, 18, 15, 14, -2, -15 },
  { 2900, 17, 21, 14, -2, -15 },
  { 2945, 14, 15, 12, -1, -15 },
  { 2972, 12, 23, 10, 0, -19 },
  { 3007, 4, 27, 14, 5, -21 },
  { 3021, 12, 23, 10, -2, -19 },
  { 3056, 13, 5, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC27PT7B_H_
