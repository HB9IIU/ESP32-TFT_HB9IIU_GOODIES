#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xF7, 0xFC, 0x7F, 0xDF, 0xF1, 0xFF, 0x7F, 0xC7, 0xF9, 0xFE, 0x1F, 0xE7,
  0xF8, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xCF, 0xF0,
  0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xDE, 0x7C, 0x0F, 0xF9, 0xE0, 0xC0, 0xFF, 0xBC, 0x00, 0x0F, 0xFB, 0xC0,
  0x00, 0xFF, 0xBC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0E, 0xFF, 0x80, 0x01, 0xE7, 0xF8, 0x80, 0x1E,
  0x7F, 0x86, 0x01, 0xE7, 0xF8, 0x7C, 0x1E, 0xFF, 0x87, 0xF9, 0xDF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0xFF, 0x00, 0x0F, 0xF1,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF1,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x3F, 0x81, 0xE0, 0xFE, 0x3F, 0xCF, 0xE1,
  0xFF, 0x1F, 0xEF, 0xF3, 0xFC, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xC7, 0xFF, 0xF7, 0xFF, 0xE7, 0xF9, 0xFF, 0xFE, 0x7F,
  0xF8, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE, 0x3F, 0x8F, 0xF3, 0xF8, 0x7F, 0x0F,
  0xF3, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x87,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x07, 0xF1, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF1, 0xFF,
  0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0xFF, 0xC0,
  0x7F, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x02, 0x03, 0xFC, 0x01, 0xC1,
  0xFC, 0x00, 0xF8, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x07, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF8, 0x0F, 0xFD, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFC, 0x7F, 0x80, 0x1E, 0x1F, 0xE0, 0x06, 0x0F, 0xC0, 0x01, 0x07,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x02, 0x03, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0xFF, 0xCF, 0xF0, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF3, 0xFF, 0x07, 0xFE,
  0x7F, 0xE0, 0xFF, 0xCF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF,
  0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F,
  0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF3, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0x87, 0xFB, 0xFF, 0x0F,
  0xE7, 0xFE, 0x0F, 0x0F, 0xF8, 0x0C, 0x3F, 0xF0, 0x10, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xFC, 0x01, 0xF8,
  0x3F, 0xF0, 0x03, 0x80, 0xFF, 0xC0, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0xF0, 0x0C,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC8, 0x00, 0x1F, 0xFC,
  0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF,
  0xC0, 0x0F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00,
  0xFF, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x04, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x88, 0x00, 0x3F, 0xF8, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x1F, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF,
  0xE0, 0x7F, 0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0xFF, 0xE1,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3,
  0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xF1, 0xFF,
  0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xCF, 0xFC,
  0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0xC1, 0xFF, 0x7F, 0xE0, 0x7F, 0xDF,
  0xF8, 0x1F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF,
  0xDF, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFB, 0xFE, 0x0F,
  0xFD, 0xFF, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0x87, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0x07, 0xFE, 0x38, 0x07, 0xFC, 0x40, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xF8, 0xFE, 0x1F, 0xE0,
  0xFF, 0xFF, 0x1F, 0x87, 0xF0, 0x7F, 0xFF, 0xC7, 0xE3, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFC, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F,
  0xDF, 0xC3, 0xF8, 0x3F, 0x87, 0xF7, 0xF1, 0xFE, 0x0F, 0xC1, 0xF9, 0xF8,
  0x7F, 0x07, 0xF0, 0x7E, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xBF, 0x8F, 0xE0,
  0x7F, 0x0F, 0xEF, 0xE3, 0xF8, 0x1F, 0x83, 0xFB, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFC, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x3F, 0x0F, 0xE1, 0xFE, 0x1F, 0x8F,
  0xC3, 0xF8, 0x7F, 0x8F, 0xE3, 0xF0, 0xFF, 0x7F, 0xEF, 0xF0, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xE1, 0xFF, 0xDF,
  0xFF, 0x03, 0xF8, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8,
  0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xC3, 0xF0, 0x1F, 0xFE, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x40, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x20, 0x1F,
  0xFE, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xC0,
  0x0E, 0x03, 0xFF, 0xC0, 0x01, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0x1F, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF,
  0xE2, 0x0F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x41, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x3F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F,
  0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F,
  0x7F, 0xC0, 0x1F, 0xF7, 0xF1, 0xFE, 0xFF, 0x80, 0x3F, 0xCF, 0xE3, 0xF9,
  0xFF, 0x00, 0xFF, 0x9F, 0xCF, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0x9F, 0xCF,
  0xF8, 0x03, 0xFE, 0x7F, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0xFE, 0xFF, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFD, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xF9, 0xFF,
  0x00, 0x7F, 0xC7, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC,
  0x01, 0xFF, 0x1F, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xFE, 0x3F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x03,
  0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFD, 0xFF,
  0x0F, 0xF8, 0x07, 0xFD, 0xFF, 0x0F, 0xF8, 0x07, 0xFD, 0xFF, 0x1F, 0xF0,
  0x07, 0xF9, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x9F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0xFF, 0x9F, 0xF0, 0x0F, 0xF8, 0xFF, 0xDF,
  0xE0, 0x0F, 0xF8, 0x7F, 0xDF, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F,
  0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0xFF,
  0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xC0,
  0x3F, 0xF0, 0x0E, 0x01, 0xFF, 0x80, 0x20, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x04, 0x00, 0x3F, 0xF0,
  0x38, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xEF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE3,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xE3, 0xFE, 0x01, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0x7F, 0x9F, 0xF8, 0x07, 0xF9,
  0xFE, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFD, 0xFE, 0x7F, 0xC0, 0x1F, 0xEF,
  0xF3, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xE7, 0xFB, 0xFE, 0x00, 0x7F, 0xBF,
  0xCF, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01,
  0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xDF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xBF, 0xE0, 0x3F, 0xF3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0x00, 0x3F, 0xEF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xF8, 0x1F, 0xF3,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x3F, 0xF8,
  0x08, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x20, 0xFF, 0xC0, 0x60, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xFB,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFD, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xE1, 0xFF, 0x3F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF7, 0xFE,
  0x0F, 0xFD, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x02, 0x0F, 0xFC, 0x03, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x88, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x87, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x01,
  0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x02, 0x00,
  0x1F, 0xF8, 0x0E, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x3F, 0xEF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x02, 0x1F, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC,
  0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xCF, 0xFE, 0x1F, 0xFC,
  0x03, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x7F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x1F,
  0xFE, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE7, 0xFF, 0x00, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF9, 0xFF, 0x81, 0xFF,
  0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0,
  0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB,
  0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x3F, 0xF9, 0xFF, 0x87,
  0xFE, 0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x7F, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0xC0,
  0x1F, 0xFB, 0xFF, 0x80, 0x1F, 0xF9, 0xFE, 0x00, 0x1F, 0xF8, 0x20, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xDF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xEF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x02, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0x03, 0xFC,
  0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xFD, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0x84, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF8,
  0x1C, 0x1F, 0xF8, 0x04, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0xC0, 0x0F, 0xFC, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0xBF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFB, 0xFC, 0x03, 0xFF, 0x9F, 0xE0, 0x0F, 0xF8, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFE,
  0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0x83, 0xFE,
  0x07, 0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0x7F,
  0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xFD, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xEF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFF, 0x87,
  0xFC, 0x3F, 0xE3, 0xFF, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0xF8, 0xFF, 0x83,
  0xFE, 0x7F, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xFF, 0x9F, 0xF0, 0x3F, 0xEF,
  0xEF, 0xE7, 0xFC, 0x0F, 0xFB, 0xFB, 0xFB, 0xFE, 0x03, 0xFE, 0xFE, 0xFE,
  0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xBF, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x4F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 40, 16, 0, -39 },
  { 91, 22, 14, 24, 5, -39 },
  { 130, 34, 39, 33, 0, -39 },
  { 296, 28, 44, 29, 1, -41 },
  { 450, 43, 39, 47, 3, -39 },
  { 660, 37, 40, 37, 0, -39 },
  { 845, 11, 14, 13, 5, -39 },
  { 865, 21, 49, 18, 1, -40 },
  { 994, 21, 49, 18, -4, -40 },
  { 1123, 25, 26, 27, 4, -41 },
  { 1205, 26, 26, 30, 2, -32 },
  { 1290, 14, 14, 16, -3, -7 },
  { 1315, 16, 9, 17, 1, -19 },
  { 1333, 11, 11, 16, 0, -10 },
  { 1349, 31, 40, 24, -3, -39 },
  { 1504, 27, 40, 29, 2, -39 },
  { 1639, 23, 39, 29, 4, -39 },
  { 1752, 30, 39, 29, -2, -39 },
  { 1899, 28, 40, 29, 0, -39 },
  { 2039, 29, 39, 29, 0, -39 },
  { 2181, 28, 40, 29, 1, -39 },
  { 2321, 28, 40, 29, 2, -39 },
  { 2461, 31, 39, 29, 1, -39 },
  { 2613, 28, 40, 29, 1, -39 },
  { 2753, 26, 40, 29, 2, -39 },
  { 2883, 16, 31, 16, 0, -30 },
  { 2945, 19, 37, 16, -3, -30 },
  { 3033, 26, 29, 30, 2, -34 },
  { 3128, 26, 20, 30, 2, -29 },
  { 3193, 26, 29, 30, 2, -34 },
  { 3288, 23, 40, 24, 3, -39 },
  { 3403, 42, 44, 45, 2, -39 },
  { 3634, 33, 39, 34, -3, -39 },
  { 3795, 32, 39, 32, 0, -39 },
  { 3951, 31, 40, 31, 2, -39 },
  { 4106, 33, 39, 34, 0, -39 },
  { 4267, 30, 39, 28, 0, -39 },
  { 4414, 29, 39, 28, 0, -39 },
  { 4556, 33, 40, 35, 2, -39 },
  { 4721, 37, 39, 36, 0, -39 },
  { 4902, 27, 39, 22, -2, -39 },
  { 5034, 28, 51, 18, -9, -39 },
  { 5213, 38, 39, 33, 0, -39 },
  { 5399, 23, 39, 26, 0, -39 },
  { 5512, 47, 39, 46, 0, -39 },
  { 5742, 40, 39, 39, 0, -39 },
  { 5937, 34, 40, 37, 2, -39 },
  { 6107, 31, 39, 31, 0, -39 },
  { 6259, 34, 48, 37, 2, -39 },
  { 6463, 31, 39, 32, 0, -39 },
  { 6615, 29, 40, 27, 0, -39 },
  { 6760, 27, 39, 27, 4, -39 },
  { 6892, 33, 40, 35, 3, -39 },
  { 7057, 32, 39, 31, 4, -39 },
  { 7213, 47, 39, 47, 4, -39 },
  { 7443, 40, 39, 33, -3, -39 },
  { 7638, 30, 39, 30, 5, -39 },
  { 7785, 32, 39, 27, -2, -39 },
  { 7941, 24, 49, 18, -2, -40 },
  { 8088, 14, 40, 24, 6, -39 },
  { 8158, 24, 49, 18, -4, -40 },
  { 8305, 27, 26, 27, 0, -39 },
  { 8393, 25, 6, 23, -5, 4 },
  { 8412, 12, 8, 19, 8, -41 },
  { 8424, 28, 31, 30, 2, -30 },
  { 8533, 29, 42, 30, 0, -41 },
  { 8686, 24, 31, 25, 2, -30 },
  { 8779, 31, 42, 30, 2, -41 },
  { 8942, 26, 31, 29, 2, -30 },
  { 9043, 32, 54, 20, -6, -41 },
  { 9259, 30, 43, 30, 0, -30 },
  { 9421, 29, 41, 31, 0, -41 },
  { 9570, 18, 42, 16, 0, -42 },
  { 9665, 25, 55, 16, -7, -42 },
  { 9837, 34, 41, 31, 0, -41 },
  { 10012, 18, 41, 16, 0, -41 },
  { 10105, 44, 30, 46, 0, -30 },
  { 10270, 29, 30, 31, 0, -30 },
  { 10379, 27, 31, 30, 2, -30 },
  { 10484, 32, 43, 30, -3, -30 },
  { 10656, 28, 43, 30, 2, -30 },
  { 10807, 24, 30, 22, 0, -30 },
  { 10897, 24, 31, 25, 0, -30 },
  { 10990, 21, 37, 22, 2, -36 },
  { 11088, 29, 31, 31, 2, -30 },
  { 11201, 28, 30, 28, 3, -30 },
  { 11306, 42, 30, 42, 3, -30 },
  { 11464, 35, 30, 28, -3, -30 },
  { 11596, 34, 43, 28, -3, -30 },
  { 11779, 28, 30, 24, -2, -30 },
  { 11884, 23, 48, 19, 0, -39 },
  { 12022, 7, 53, 27, 10, -41 },
  { 12069, 22, 48, 19, -3, -39 },
  { 12201, 26, 10, 30, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC54PT7B_H_
