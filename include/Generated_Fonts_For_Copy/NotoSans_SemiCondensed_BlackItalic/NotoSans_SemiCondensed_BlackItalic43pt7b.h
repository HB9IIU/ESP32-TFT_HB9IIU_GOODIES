#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x04, 0x00, 0x7F, 0x9F, 0xDF,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF3, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x7C, 0x7E,
  0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x11, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xB9, 0xE1, 0xFD,
  0xC1, 0x07, 0xF7, 0x00, 0x1F, 0xDC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xDF, 0xC0, 0x07, 0x7F, 0x30, 0x1D,
  0xFC, 0xF0, 0xE7, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0x0F,
  0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0x7E, 0x7C, 0x07, 0xC0,
  0x1F, 0x8F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x0F,
  0x80, 0x0F, 0x87, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x3F, 0x00, 0x0F, 0xC7, 0xE7, 0xE3, 0xE1, 0xF9, 0xF9, 0xF9, 0xFF, 0x1F,
  0xFF, 0x7E, 0x7F, 0xF3, 0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xF3, 0xF3, 0xFF,
  0xE7, 0xFC, 0xFC, 0xFC, 0xFC, 0x7F, 0x1F, 0x9F, 0x9F, 0x80, 0x07, 0xE7,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x7E, 0x00, 0x7E, 0x0F, 0x8F, 0xC0,
  0x1F, 0x81, 0xF1, 0xF8, 0x07, 0xE0, 0x3F, 0xFE, 0x00, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF,
  0x1F, 0xFF, 0x87, 0xF1, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFC, 0x7F, 0x87, 0xFF, 0xE3, 0xFC, 0x1F,
  0xFE, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x30, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0xF8, 0x07,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x3F,
  0x01, 0xF3, 0xF0, 0x0E, 0x3F, 0x80, 0x41, 0xE0, 0x00, 0x10, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xDF,
  0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xFB, 0xFF, 0xC0, 0x04, 0x1F, 0x9F, 0xDF,
  0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0,
  0xFF, 0x3F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE,
  0x7F, 0x87, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF,
  0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x3F,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xF7, 0xF1, 0xFD, 0xFE, 0x1F, 0x3F, 0xC1, 0xC7,
  0xF0, 0x21, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF0, 0xFF, 0x01, 0xC1, 0xFE, 0x01, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xF8, 0xFF, 0x80, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x40, 0x07, 0xF8, 0xF0,
  0x3F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0x7F, 0x80, 0x7E, 0xFE,
  0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xF8, 0x1F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0,
  0xFC, 0x3F, 0x83, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x30, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x20, 0x07, 0xF8, 0xE0, 0x7F, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xC0, 0x87,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x40, 0x1F, 0xEF,
  0xE0, 0x7F, 0x7F, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFE,
  0x0F, 0xF3, 0xF8, 0x3F, 0xCF, 0xE1, 0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0x3F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3,
  0xFE, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x3F, 0xCF,
  0xF8, 0xFE, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xDF, 0xC0, 0xF9, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x81, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x03, 0xF0, 0x7F, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0,
  0xFF, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xCF, 0xF8, 0xC0, 0xFF, 0x10, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0x87, 0xE0, 0xFF, 0xF3, 0xE1, 0xF8,
  0x7F, 0xFC, 0xFC, 0xFC, 0x3F, 0xFF, 0x3F, 0x3E, 0x1F, 0xCF, 0x87, 0xCF,
  0x8F, 0xC3, 0xE1, 0xF7, 0xE3, 0xF1, 0xF8, 0xFD, 0xF1, 0xF8, 0x7E, 0x3F,
  0x7C, 0x7E, 0x1F, 0x0F, 0x9F, 0x1F, 0x07, 0xC3, 0xE7, 0xC7, 0xC3, 0xF0,
  0xFB, 0xF3, 0xF0, 0xFC, 0x7C, 0xFC, 0xFC, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F,
  0x8F, 0x8F, 0xC7, 0xFF, 0xFF, 0xE1, 0xF1, 0xFF, 0xFF, 0xF0, 0x7C, 0x3F,
  0xDF, 0xF8, 0x1F, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0,
  0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xE7, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xCF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFB, 0xF0, 0x3F, 0xF0, 0x38, 0x1F, 0xF0, 0x04, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xC0, 0xFF, 0xC3,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFF,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x18, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3,
  0xFF, 0xC7, 0xF8, 0xFF, 0xF3, 0xFC, 0x3F, 0xFC, 0xFF, 0x0F, 0xFF, 0x3F,
  0xC7, 0xFF, 0x8F, 0xF1, 0xFF, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0x8F, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xCF, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F,
  0xDF, 0x07, 0xFF, 0xC0, 0xFE, 0xF8, 0x7E, 0xFE, 0x07, 0xF7, 0xC3, 0xFF,
  0xE0, 0x3F, 0xBE, 0x3F, 0x7F, 0x01, 0xFD, 0xF1, 0xFB, 0xF8, 0x1F, 0xCF,
  0x9F, 0x9F, 0xC0, 0xFE, 0x7C, 0xFD, 0xFE, 0x07, 0xF3, 0xEF, 0xCF, 0xE0,
  0x3F, 0x9F, 0x7E, 0x7F, 0x01, 0xFC, 0xFF, 0xE3, 0xF8, 0x1F, 0xE7, 0xFF,
  0x3F, 0xC0, 0xFE, 0x3F, 0xF9, 0xFC, 0x07, 0xF1, 0xFF, 0x8F, 0xE0, 0x3F,
  0x8F, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFE, 0x3F,
  0xC0, 0xFE, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x81, 0xFE,
  0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xC1, 0xFC,
  0x07, 0xFF, 0xC1, 0xFC, 0x0F, 0xEF, 0xE3, 0xF8, 0x0F, 0xEF, 0xE3, 0xF8,
  0x0F, 0xEF, 0xE3, 0xF8, 0x0F, 0xEF, 0xE3, 0xF8, 0x0F, 0xE7, 0xF3, 0xF8,
  0x1F, 0xC7, 0xF7, 0xF0, 0x1F, 0xC7, 0xF7, 0xF0, 0x1F, 0xC7, 0xF7, 0xF0,
  0x1F, 0xC3, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xE0,
  0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xC0,
  0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF,
  0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8,
  0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xEF, 0xFE, 0x0F, 0xF1, 0xFF, 0x07,
  0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x9F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x18, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x10, 0x07, 0xF8, 0x30, 0x0F, 0xF0, 0x7E, 0x7F, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0,
  0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC,
  0x0F, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x7F, 0x9F, 0xC0, 0x7F, 0x81, 0xFE,
  0x7F, 0x03, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0xC3, 0xFC, 0x1F, 0xC7, 0xFF,
  0x0F, 0xE0, 0x7F, 0x1F, 0xFC, 0x7F, 0x81, 0xFC, 0xFF, 0xF1, 0xFE, 0x07,
  0xF3, 0xFF, 0xC7, 0xF0, 0x1F, 0xDF, 0xFF, 0x3F, 0xC0, 0x7E, 0x7E, 0xFC,
  0xFE, 0x01, 0xF9, 0xFB, 0xF3, 0xF8, 0x07, 0xEF, 0xEF, 0xDF, 0xC0, 0x1F,
  0xBF, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0xFD, 0xFC, 0x01, 0xFF, 0xE3, 0xFF,
  0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07,
  0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0x9F,
  0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0x7E, 0x01, 0xFC, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x1F,
  0xBF, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE,
  0x1F, 0x83, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x07, 0xF9, 0xFC, 0x1F, 0xFB,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFB, 0xF0, 0x0F, 0xE7,
  0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xBF, 0xF8, 0x7F, 0x7F, 0xE0, 0xFC, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0xE1, 0xC3, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0x07, 0xF8, 0x70, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xCF, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE7, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFB, 0xFC,
  0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xFB, 0xFC, 0x7F, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x06, 0x1F, 0xF1, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x10, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x01, 0xFF,
  0x7F, 0x03, 0xFF, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xF3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC1,
  0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xCF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xEF, 0xE0, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x80, 0x1F, 0xC0, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07,
  0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xE3, 0xF8,
  0x3F, 0x80, 0xFC, 0xFF, 0x8F, 0xF8, 0x1F, 0xBF, 0xF3, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0xE7, 0xF8, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xF8,
  0x1F, 0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xCF, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF,
  0x0F, 0xF1, 0xFC, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0xFD, 0xFF, 0x00, 0x7E, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0x80,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x07,
  0xFD, 0xFC, 0x1F, 0xFB, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xF9, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x07,
  0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE,
  0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xE3,
  0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xF6, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x87, 0xF8, 0x20,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x98,
  0x0F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC7, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x21, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFD, 0xF8, 0x1F, 0xF3, 0xF0,
  0x1F, 0xCF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF,
  0xC1, 0xFE, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xDF, 0xE0,
  0x7F, 0x7F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xC3, 0xFE, 0x1F, 0xDF, 0xE3, 0xFF,
  0x0F, 0xEF, 0xF1, 0xFF, 0x8F, 0xF3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFC, 0xFF,
  0xE7, 0xF8, 0xFE, 0x7F, 0xF3, 0xF8, 0x7F, 0x3F, 0xF1, 0xFC, 0x3F, 0xBF,
  0xF9, 0xFC, 0x1F, 0xDF, 0x7C, 0xFE, 0x0F, 0xDF, 0xBE, 0xFE, 0x07, 0xEF,
  0xDF, 0x7F, 0x03, 0xF7, 0xCF, 0xBF, 0x81, 0xFF, 0xE7, 0xFF, 0x80, 0xFF,
  0xE3, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0xFF,
  0x8F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFD,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0,
  0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 32, 12, 0, -31 },
  { 57, 18, 11, 19, 4, -31 },
  { 82, 27, 31, 26, 0, -31 },
  { 187, 22, 36, 23, 1, -33 },
  { 286, 35, 31, 38, 2, -31 },
  { 422, 29, 31, 29, 0, -31 },
  { 535, 9, 11, 10, 4, -31 },
  { 548, 17, 39, 15, 1, -32 },
  { 631, 17, 39, 15, -3, -32 },
  { 714, 20, 21, 22, 3, -33 },
  { 767, 20, 21, 24, 2, -26 },
  { 820, 11, 11, 12, -2, -5 },
  { 836, 13, 7, 14, 0, -15 },
  { 848, 9, 9, 12, 0, -8 },
  { 859, 24, 31, 19, -2, -31 },
  { 952, 22, 31, 23, 1, -31 },
  { 1038, 19, 31, 23, 3, -31 },
  { 1112, 23, 31, 23, -1, -31 },
  { 1202, 23, 31, 23, 0, -31 },
  { 1292, 23, 31, 23, 0, -31 },
  { 1382, 22, 31, 23, 1, -31 },
  { 1468, 22, 31, 23, 2, -31 },
  { 1554, 24, 31, 23, 1, -31 },
  { 1647, 22, 31, 23, 1, -31 },
  { 1733, 21, 31, 23, 2, -31 },
  { 1815, 12, 25, 13, 0, -24 },
  { 1853, 15, 30, 13, -3, -24 },
  { 1910, 20, 23, 24, 2, -27 },
  { 1968, 20, 15, 24, 2, -23 },
  { 2006, 20, 23, 24, 2, -27 },
  { 2064, 19, 32, 19, 2, -31 },
  { 2140, 34, 35, 36, 1, -31 },
  { 2289, 27, 31, 27, -3, -31 },
  { 2394, 25, 31, 25, 0, -31 },
  { 2491, 25, 31, 25, 2, -31 },
  { 2588, 26, 31, 27, 0, -31 },
  { 2689, 24, 31, 22, 0, -31 },
  { 2782, 23, 31, 22, 0, -31 },
  { 2872, 26, 31, 28, 2, -31 },
  { 2973, 29, 31, 28, 0, -31 },
  { 3086, 22, 31, 18, -2, -31 },
  { 3172, 22, 41, 14, -7, -31 },
  { 3285, 30, 31, 26, 0, -31 },
  { 3402, 19, 31, 21, 0, -31 },
  { 3476, 37, 31, 36, 0, -31 },
  { 3620, 32, 31, 31, 0, -31 },
  { 3744, 26, 31, 29, 2, -31 },
  { 3845, 25, 31, 25, 0, -31 },
  { 3942, 26, 38, 29, 2, -31 },
  { 4066, 25, 31, 26, 0, -31 },
  { 4163, 23, 31, 22, 0, -31 },
  { 4253, 22, 31, 22, 3, -31 },
  { 4339, 27, 31, 28, 2, -31 },
  { 4444, 25, 31, 25, 3, -31 },
  { 4541, 38, 31, 37, 3, -31 },
  { 4689, 32, 31, 26, -3, -31 },
  { 4813, 24, 31, 24, 4, -31 },
  { 4906, 26, 31, 22, -2, -31 },
  { 5007, 19, 39, 14, -2, -32 },
  { 5100, 12, 31, 19, 4, -31 },
  { 5147, 19, 39, 14, -3, -32 },
  { 5240, 22, 21, 22, 0, -31 },
  { 5298, 20, 5, 18, -4, 3 },
  { 5311, 10, 7, 15, 6, -33 },
  { 5320, 23, 24, 24, 1, -24 },
  { 5389, 23, 33, 24, 0, -33 },
  { 5484, 20, 24, 20, 1, -24 },
  { 5544, 25, 33, 24, 1, -33 },
  { 5648, 21, 24, 23, 1, -24 },
  { 5711, 26, 43, 16, -5, -33 },
  { 5851, 24, 34, 24, 0, -24 },
  { 5953, 23, 33, 25, 0, -33 },
  { 6048, 14, 33, 13, 0, -33 },
  { 6106, 21, 43, 13, -6, -33 },
  { 6219, 27, 33, 24, 0, -33 },
  { 6331, 15, 33, 13, 0, -33 },
  { 6393, 35, 24, 37, 0, -24 },
  { 6498, 23, 24, 25, 0, -24 },
  { 6567, 22, 24, 24, 1, -24 },
  { 6633, 25, 34, 24, -2, -24 },
  { 6740, 23, 34, 24, 1, -24 },
  { 6838, 19, 24, 17, 0, -24 },
  { 6895, 19, 24, 20, 0, -24 },
  { 6952, 17, 29, 18, 2, -29 },
  { 7014, 23, 24, 25, 2, -24 },
  { 7083, 22, 24, 22, 2, -24 },
  { 7149, 33, 24, 33, 2, -24 },
  { 7248, 27, 24, 23, -2, -24 },
  { 7329, 27, 34, 22, -3, -24 },
  { 7444, 21, 24, 19, -1, -24 },
  { 7507, 18, 38, 15, 0, -31 },
  { 7593, 6, 43, 22, 8, -33 },
  { 7626, 18, 38, 15, -3, -31 },
  { 7712, 20, 8, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC43PT7B_H_
