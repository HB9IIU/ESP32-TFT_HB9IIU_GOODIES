#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5C, 0x80, 0xF8, 0x3F, 0x6F, 0xA0, 0x74, 0x6A, 0xE0, 0x6A, 0xCD,
  0xCB, 0x4C, 0x72, 0x9F, 0x6F, 0x00, 0xC0, 0x6A, 0x49, 0x80, 0x24, 0x93,
  0x80, 0x6F, 0x60, 0x4F, 0x40, 0xC0, 0xC0, 0x80, 0x32, 0x44, 0x80, 0x67,
  0xFA, 0xE0, 0x79, 0x2C, 0x67, 0x24, 0xE0, 0x73, 0x62, 0xE0, 0x36, 0x6F,
  0x60, 0x74, 0x62, 0xE0, 0x74, 0xFE, 0x60, 0x73, 0x24, 0xC0, 0x77, 0x6A,
  0xE0, 0x6F, 0xF2, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3,
  0xC0, 0x65, 0x0C, 0x39, 0xDB, 0x6E, 0xC0, 0xC0, 0x35, 0x5F, 0x90, 0x75,
  0x6F, 0xE0, 0x74, 0xCC, 0x60, 0x75, 0x5D, 0xE0, 0x74, 0x6C, 0xE0, 0x74,
  0x6C, 0x80, 0x7A, 0x3D, 0xA7, 0x00, 0x5A, 0x9D, 0xAB, 0x00, 0x69, 0x2C,
  0x24, 0xB7, 0xA0, 0x5B, 0x99, 0xCB, 0x00, 0x49, 0x6E, 0x6D, 0xB7, 0xFE,
  0xA8, 0x6B, 0x5B, 0xE9, 0x00, 0x72, 0xF7, 0xA7, 0x00, 0x75, 0x7C, 0x80,
  0x72, 0xF7, 0xA7, 0x18, 0x75, 0x7E, 0xB0, 0x74, 0x62, 0xE0, 0xFA, 0x48,
  0x5A, 0x95, 0xA6, 0x00, 0xBA, 0xCC, 0xC0, 0xAF, 0xAF, 0xBC, 0xB0, 0x5B,
  0x98, 0xCB, 0x00, 0xBE, 0xC8, 0x80, 0x72, 0x6C, 0xE0, 0x69, 0x49, 0x80,
  0xAA, 0xC0, 0x69, 0x25, 0x00, 0x26, 0xB0, 0xF0, 0xC0, 0x7F, 0xEE, 0x47,
  0x7F, 0xE0, 0x7A, 0x70, 0x17, 0xFE, 0xE0, 0x6F, 0xCE, 0x37, 0x22, 0x64,
  0xC0, 0x7F, 0xEE, 0xAC, 0x47, 0x7F, 0xA0, 0x57, 0x80, 0x24, 0xB4, 0xB0,
  0x45, 0x6E, 0xB0, 0x57, 0x80, 0x7D, 0xFF, 0xAA, 0x77, 0xFA, 0x6F, 0xFE,
  0x77, 0xFE, 0x88, 0x7F, 0xEE, 0x26, 0x6B, 0x40, 0x79, 0xF0, 0x5D, 0x6C,
  0x57, 0xFE, 0xFE, 0x64, 0xFF, 0xED, 0xB4, 0xF6, 0x6A, 0xF6, 0x64, 0xC8,
  0x7D, 0x70, 0x6B, 0x6D, 0x80, 0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 1, -5 },
  { 19, 3, 6, 2, 0, -5 },
  { 22, 3, 6, 2, -1, -5 },
  { 25, 4, 3, 4, 0, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 1, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 1, 1, 2, 0, -1 },
  { 32, 4, 5, 3, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 1, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 3, 4, 0, -4 },
  { 73, 3, 5, 3, 0, -5 },
  { 75, 6, 6, 6, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 5, 5, 5, 0, -5 },
  { 102, 5, 5, 5, 0, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 3, 7, 2, -1, -5 },
  { 111, 5, 5, 4, 0, -5 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 6, 5, 6, 0, -5 },
  { 121, 5, 5, 5, 0, -5 },
  { 125, 5, 5, 5, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 5, 6, 5, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 3, 5, 4, 1, -5 },
  { 144, 5, 5, 5, 0, -5 },
  { 148, 4, 5, 4, 1, -5 },
  { 151, 6, 5, 6, 1, -5 },
  { 155, 5, 5, 4, 0, -5 },
  { 159, 4, 5, 4, 1, -5 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 3, 6, 2, 0, -5 },
  { 168, 2, 5, 3, 1, -5 },
  { 170, 3, 6, 2, 0, -5 },
  { 173, 4, 3, 4, 0, -5 },
  { 175, 4, 1, 3, -1, 0 },
  { 176, 2, 1, 2, 1, -5 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 4, 5, 4, 0, -5 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 4, 5, 4, 0, -5 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 4, 7, 3, -1, -5 },
  { 193, 4, 6, 4, 0, -4 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 2, 5, 2, 0, -5 },
  { 201, 3, 7, 2, -1, -5 },
  { 204, 4, 5, 4, 0, -5 },
  { 207, 2, 5, 2, 0, -5 },
  { 209, 6, 4, 6, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -4 },
  { 219, 4, 6, 4, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 3, 5, 3, 0, -5 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 4, 4, 0, -4 },
  { 232, 6, 4, 5, 0, -4 },
  { 235, 4, 4, 4, 0, -4 },
  { 237, 4, 6, 4, 0, -4 },
  { 240, 3, 4, 3, 0, -4 },
  { 242, 3, 6, 2, 0, -5 },
  { 245, 1, 7, 4, 1, -5 },
  { 246, 2, 6, 2, 0, -5 },
  { 248, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC7PT7B_H_
