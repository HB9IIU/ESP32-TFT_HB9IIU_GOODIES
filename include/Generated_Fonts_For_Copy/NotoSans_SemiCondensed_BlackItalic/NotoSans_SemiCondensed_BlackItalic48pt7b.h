#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x08, 0x00, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xF7, 0xF8, 0xFE, 0x7F, 0x8F, 0xE7,
  0xF1, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC,
  0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x8F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x03, 0xF9, 0xC1, 0x83,
  0xFC, 0xE0, 0x01, 0xFE, 0x70, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7B, 0xF8, 0x00, 0x39, 0xFC, 0x20, 0x1C, 0xFE, 0x1C, 0x0E,
  0x7F, 0x1F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0x00, 0x7E,
  0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xF3, 0xF0, 0x1F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x7E, 0x00, 0xFE, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE3,
  0xF0, 0xFC, 0x3F, 0x3F, 0x9F, 0xCF, 0xFC, 0xFF, 0xFE, 0x7E, 0x7F, 0xFB,
  0xFF, 0xF3, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0xCF, 0xFF, 0xDF, 0xFC, 0xFE,
  0x7F, 0xFF, 0x3F, 0xE3, 0xF1, 0xF8, 0xFC, 0x1E, 0x1F, 0xCF, 0xE3, 0xF0,
  0x00, 0xFE, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x1F, 0xC7,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x7E, 0x00, 0xFE, 0x07, 0xF3, 0xF8, 0x03, 0xF0, 0x1F,
  0xCF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFE, 0x3F,
  0xC3, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0x7F, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF,
  0xF0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF,
  0xF8, 0x3F, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x3F, 0xCF, 0xF3, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x20, 0x3F, 0x00, 0xE0, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xEF, 0x80,
  0x7F, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF,
  0x81, 0xFF, 0x7E, 0x03, 0xFD, 0xFC, 0x07, 0xE3, 0xF0, 0x07, 0x0F, 0xE0,
  0x0C, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE,
  0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFE, 0x7F, 0xFC, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xBF, 0xEF,
  0xF9, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF,
  0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1,
  0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE,
  0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xBF, 0xC7, 0xF3, 0xFC, 0x3E,
  0x7F, 0xC3, 0x87, 0xFC, 0x10, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0xC0,
  0x38, 0x1F, 0xF0, 0x0C, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xF7,
  0xFF, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x20, 0x01, 0xFF,
  0x9C, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80,
  0x3F, 0xBF, 0xE0, 0x1F, 0xCF, 0xF8, 0x07, 0xE3, 0xFC, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0xC0, 0xFE, 0x1F, 0xF0, 0x3F, 0x07, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x40,
  0x07, 0xFE, 0x38, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x0C, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x7C, 0x03, 0xFE, 0xFF, 0x81,
  0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFC, 0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x83,
  0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1,
  0xFF, 0x1F, 0xE0, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE1, 0xFF, 0x1F,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xFB, 0xFF, 0x3F, 0xE3, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFB, 0xFE,
  0x0F, 0xF7, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0, 0xFF, 0xBF, 0xE3,
  0xFF, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x01, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x04, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xF9, 0xFF, 0x3C, 0x0F, 0xF1, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x01, 0xF0,
  0x1F, 0x87, 0xF0, 0x7F, 0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xE3, 0xF3, 0xF0,
  0x7F, 0xFF, 0x1F, 0x9F, 0x87, 0xFF, 0xF8, 0xFD, 0xF8, 0x7F, 0x9F, 0x87,
  0xEF, 0xC3, 0xF0, 0xFC, 0x3F, 0x7E, 0x3F, 0x87, 0xE1, 0xFF, 0xE1, 0xF8,
  0x3F, 0x0F, 0xFF, 0x1F, 0xC3, 0xF0, 0x7D, 0xF8, 0xFC, 0x1F, 0x87, 0xEF,
  0xC7, 0xE0, 0xFC, 0x3F, 0x7C, 0x3F, 0x0F, 0xE1, 0xF3, 0xE1, 0xF8, 0x7E,
  0x1F, 0x9F, 0x0F, 0xC3, 0xF0, 0xFC, 0xF8, 0x7E, 0x3F, 0x9F, 0xC7, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xFF, 0xC1, 0xF8, 0x7F, 0xEF, 0xFC,
  0x0F, 0xC1, 0xFE, 0x7F, 0xC0, 0x7F, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x01,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F,
  0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0x81, 0xFF, 0xC0, 0x10, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x08, 0x07, 0xFE, 0x07,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC3, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x0F, 0xFE,
  0x0F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xC0, 0xFF, 0xE0, 0x02,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xFC, 0x7F, 0xC3,
  0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x3F, 0xF1, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF,
  0x8F, 0xF8, 0x7F, 0xFC, 0x7F, 0xC3, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F,
  0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFC, 0x1F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x01,
  0xFD, 0xF8, 0x7F, 0x7F, 0x80, 0xFF, 0x7E, 0x1F, 0xFF, 0xC0, 0x3F, 0xDF,
  0x87, 0xEF, 0xF0, 0x0F, 0xF7, 0xE3, 0xFB, 0xFC, 0x03, 0xFD, 0xF8, 0xFC,
  0xFF, 0x00, 0xFF, 0x7E, 0x7F, 0x7F, 0xC0, 0x7F, 0x9F, 0x9F, 0x9F, 0xE0,
  0x1F, 0xE7, 0xEF, 0xE7, 0xF8, 0x07, 0xF9, 0xFB, 0xF9, 0xFE, 0x01, 0xFE,
  0x7F, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xFF,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0xF0, 0xFF,
  0x00, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF,
  0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0x03, 0xF8, 0x07,
  0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0x87, 0xF8, 0x07, 0xF7, 0xF8, 0x7F,
  0x80, 0x7F, 0x7F, 0x87, 0xF8, 0x0F, 0xF7, 0xF8, 0xFF, 0x00, 0xFF, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFC, 0xFF, 0x01, 0xFE, 0x1F, 0xEF, 0xE0, 0x1F, 0xE1, 0xFE, 0xFE,
  0x01, 0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0xFE, 0x01, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xC0, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8,
  0x07, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xF8, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xCF,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x0E, 0x03, 0xFE, 0x00, 0x80,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x10, 0x01, 0xFE, 0x07, 0x00, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xBF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0xFF, 0x07, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF,
  0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFC, 0x1F,
  0xE0, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFF, 0xC3, 0xFC, 0x0F,
  0xF1, 0xFF, 0xF1, 0xFF, 0x03, 0xFC, 0xFE, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xBF, 0x1F, 0xE0, 0x3F, 0xCF, 0xEF, 0xCF, 0xF0, 0x0F, 0xF7, 0xF7, 0xF3,
  0xFC, 0x03, 0xFD, 0xFD, 0xFD, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0x7F, 0x80,
  0x3F, 0xFF, 0x9F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE7, 0xFF, 0xF0, 0x03, 0xFF,
  0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF9, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF9, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF9, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0xC0, 0x7F, 0xCF, 0xF0,
  0x3F, 0xFB, 0xF8, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F,
  0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xDF, 0xFC, 0x0F,
  0xF7, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFE, 0x1C, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x21, 0xFF, 0x03, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xC7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF9, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xFC, 0xFF, 0x9F, 0xF0, 0xFF, 0x7F, 0xC1,
  0xFE, 0xFF, 0x87, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0x0F, 0xF8, 0x1E, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC4, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x1F, 0xF3, 0xFC, 0x07, 0xFF, 0x7F, 0x01, 0xFF, 0xEF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7, 0xFC,
  0x1F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x30, 0x07, 0xFC, 0x07, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFC, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0x83, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xF8, 0x7C, 0x03, 0xF0, 0x07, 0xF3, 0xFE, 0x1F, 0xF0,
  0x1F, 0xCF, 0xFE, 0x7F, 0xF0, 0x3F, 0xBF, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x07,
  0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F,
  0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7F, 0xC0, 0x7F, 0x3F, 0xF8,
  0x1F, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0,
  0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F,
  0xF7, 0xF8, 0x7F, 0xCF, 0xF9, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xEF, 0xF8, 0x01, 0xFD, 0xFF, 0xC0, 0x1F,
  0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0xCF, 0xF0,
  0x3F, 0xFB, 0xF8, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F,
  0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x07,
  0xF7, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x1F, 0x07, 0xFC,
  0x08, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x30, 0x0F, 0xF8, 0xF8, 0x7F,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE1, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x82, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7,
  0xFC, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xF8,
  0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF7, 0xF0, 0x3F, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE7,
  0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF3, 0xFE,
  0x03, 0xF9, 0xFE, 0x01, 0xFD, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF,
  0x07, 0xFD, 0xFE, 0x1F, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0xC3, 0xFE, 0x7F,
  0x8F, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xF0, 0xFF, 0x1F, 0xE3, 0xFF, 0x8F,
  0xF0, 0xFF, 0x3F, 0xFC, 0x7F, 0x87, 0xF9, 0xFF, 0xE7, 0xFC, 0x3F, 0xCF,
  0xFF, 0x3F, 0xC1, 0xFE, 0xFD, 0xF9, 0xFE, 0x0F, 0xF7, 0xEF, 0xDF, 0xE0,
  0x7F, 0xFF, 0x7E, 0xFF, 0x03, 0xFB, 0xF3, 0xF7, 0xF0, 0x1F, 0xDF, 0x9F,
  0xFF, 0x80, 0xFE, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F,
  0xFE, 0x3F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x3F, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x80, 0x0F, 0xF9, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 35, 14, 0, -34 },
  { 71, 20, 12, 22, 4, -34 },
  { 101, 30, 34, 29, 0, -34 },
  { 229, 25, 39, 26, 1, -36 },
  { 351, 38, 35, 42, 3, -35 },
  { 518, 33, 35, 33, 0, -35 },
  { 663, 10, 12, 11, 4, -34 },
  { 678, 19, 43, 16, 1, -35 },
  { 781, 18, 43, 16, -3, -35 },
  { 878, 22, 24, 24, 3, -37 },
  { 944, 23, 24, 27, 2, -29 },
  { 1013, 13, 12, 14, -3, -6 },
  { 1033, 15, 8, 15, 0, -17 },
  { 1048, 10, 9, 14, 0, -8 },
  { 1060, 27, 35, 21, -2, -35 },
  { 1179, 25, 35, 26, 1, -35 },
  { 1289, 20, 34, 26, 4, -34 },
  { 1374, 26, 35, 26, -1, -35 },
  { 1488, 25, 35, 26, 0, -35 },
  { 1598, 26, 34, 26, 0, -34 },
  { 1709, 25, 34, 26, 1, -34 },
  { 1816, 25, 35, 26, 2, -35 },
  { 1926, 27, 34, 26, 1, -34 },
  { 2041, 25, 35, 26, 1, -35 },
  { 2151, 23, 35, 26, 2, -35 },
  { 2252, 14, 28, 14, 0, -27 },
  { 2301, 17, 33, 14, -3, -27 },
  { 2372, 23, 25, 27, 2, -30 },
  { 2444, 23, 17, 27, 2, -25 },
  { 2493, 23, 25, 27, 2, -30 },
  { 2565, 20, 36, 21, 3, -35 },
  { 2655, 37, 39, 40, 2, -35 },
  { 2836, 30, 34, 30, -3, -34 },
  { 2964, 28, 34, 28, 0, -34 },
  { 3083, 28, 35, 27, 2, -35 },
  { 3206, 29, 34, 30, 0, -34 },
  { 3330, 26, 34, 24, 0, -34 },
  { 3441, 26, 34, 24, 0, -34 },
  { 3552, 29, 35, 31, 2, -35 },
  { 3679, 33, 34, 32, 0, -34 },
  { 3820, 25, 34, 20, -2, -34 },
  { 3927, 25, 45, 16, -8, -34 },
  { 4068, 33, 34, 29, 0, -34 },
  { 4209, 21, 34, 23, 0, -34 },
  { 4299, 42, 34, 41, 0, -34 },
  { 4478, 36, 34, 35, 0, -34 },
  { 4631, 30, 35, 33, 2, -35 },
  { 4763, 28, 34, 27, 0, -34 },
  { 4882, 30, 43, 33, 2, -35 },
  { 5044, 28, 34, 29, 0, -34 },
  { 5163, 26, 35, 24, 0, -35 },
  { 5277, 24, 34, 24, 4, -34 },
  { 5379, 30, 34, 31, 2, -34 },
  { 5507, 28, 34, 28, 4, -34 },
  { 5626, 42, 34, 42, 4, -34 },
  { 5805, 36, 34, 29, -3, -34 },
  { 5958, 27, 34, 27, 4, -34 },
  { 6073, 29, 34, 24, -2, -34 },
  { 6197, 21, 43, 16, -2, -35 },
  { 6310, 12, 35, 21, 5, -35 },
  { 6363, 21, 43, 16, -3, -35 },
  { 6476, 24, 22, 24, 0, -34 },
  { 6542, 21, 6, 20, -4, 3 },
  { 6558, 11, 8, 17, 7, -37 },
  { 6569, 26, 27, 27, 1, -27 },
  { 6657, 26, 36, 27, 0, -36 },
  { 6774, 21, 27, 22, 2, -27 },
  { 6845, 28, 36, 27, 1, -36 },
  { 6971, 23, 27, 26, 2, -27 },
  { 7049, 28, 49, 18, -5, -37 },
  { 7221, 27, 39, 27, 0, -27 },
  { 7353, 26, 36, 28, 0, -36 },
  { 7470, 16, 37, 14, 0, -37 },
  { 7544, 22, 49, 14, -6, -37 },
  { 7679, 30, 36, 27, 0, -36 },
  { 7814, 16, 36, 14, 0, -36 },
  { 7886, 39, 27, 41, 0, -27 },
  { 8018, 26, 27, 28, 0, -27 },
  { 8106, 23, 27, 27, 2, -27 },
  { 8184, 28, 39, 27, -2, -27 },
  { 8321, 26, 39, 27, 1, -27 },
  { 8448, 22, 27, 19, 0, -27 },
  { 8523, 22, 27, 22, 0, -27 },
  { 8598, 19, 32, 20, 2, -32 },
  { 8674, 25, 27, 28, 2, -27 },
  { 8759, 25, 27, 25, 2, -27 },
  { 8844, 37, 27, 37, 3, -27 },
  { 8969, 31, 27, 25, -3, -27 },
  { 9074, 30, 39, 25, -3, -27 },
  { 9221, 24, 27, 22, -1, -27 },
  { 9302, 21, 42, 17, 0, -34 },
  { 9413, 6, 48, 24, 9, -37 },
  { 9449, 20, 42, 17, -3, -34 },
  { 9554, 23, 10, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC48PT7B_H_
