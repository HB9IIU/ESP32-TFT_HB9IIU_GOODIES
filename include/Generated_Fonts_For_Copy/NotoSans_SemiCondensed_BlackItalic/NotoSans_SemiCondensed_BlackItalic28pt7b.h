#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F,
  0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3E, 0x1F, 0x00,
  0xFB, 0xFF, 0x7F, 0xEF, 0x79, 0xEF, 0x3D, 0xE7, 0xB9, 0xE0, 0x01, 0xE7,
  0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x03, 0x9E, 0x0F, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xCF, 0x00, 0xF3, 0x81, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x73, 0xC0, 0x3C, 0xE0,
  0x0F, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x7F,
  0xC7, 0xFF, 0x3F, 0xFC, 0xFE, 0xE3, 0xD8, 0x8F, 0x60, 0x3F, 0x80, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xE8, 0x6F, 0xB1, 0xBC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x1F, 0x01, 0xE0, 0xFE, 0x07, 0x07, 0xF8, 0x3C, 0x3C, 0xE1, 0xE0, 0xF3,
  0x87, 0x03, 0xCE, 0x3C, 0x0E, 0x79, 0xE0, 0x39, 0xE7, 0x00, 0xE7, 0xBD,
  0xFB, 0xFD, 0xEF, 0xEF, 0xE7, 0x7F, 0xDF, 0x3D, 0xEF, 0x01, 0xE7, 0x3C,
  0x0F, 0x3C, 0xF0, 0x3C, 0xF3, 0xC1, 0xE3, 0xCF, 0x0F, 0x0F, 0x78, 0x3C,
  0x3F, 0xE1, 0xE0, 0x7F, 0x0F, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xDF, 0x00, 0xF9, 0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x7C, 0xFF, 0x9F, 0x3F, 0xFB, 0xE7,
  0xDF, 0xF9, 0xF1, 0xFF, 0x3E, 0x3F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFF, 0xEF, 0x7B, 0x80,
  0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x04, 0x00,
  0x1E, 0x01, 0xE0, 0x8F, 0x07, 0x78, 0x7F, 0xBF, 0xFF, 0xE3, 0xFF, 0x1F,
  0xF9, 0xFC, 0x1F, 0xF0, 0xF7, 0x81, 0x1E, 0x00, 0xC0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x1E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x78, 0xF0, 0x7F, 0xBF, 0x9F, 0xCF, 0xEF, 0xF0, 0x3B, 0xEF,
  0xFE, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E,
  0x7D, 0xF9, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE,
  0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x9F, 0x3E, 0x7C, 0xFF, 0xE3, 0xFF, 0x87,
  0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFF, 0x3F, 0xEF, 0xFE,
  0x7F, 0xE7, 0x3E, 0x27, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x07,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0x3F, 0x04, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF8, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xC7, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x60, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF,
  0x83, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xBC, 0x0F, 0xF8, 0x3D, 0xF0, 0xF3, 0xE3,
  0xC7, 0xC7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x60, 0xFC, 0xFF,
  0xF9, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE3, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0xF8, 0x7B, 0xF1,
  0xFF, 0xF3, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C,
  0xFC, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F,
  0xFE, 0x1F, 0xF0, 0x3F, 0x03, 0xFE, 0x1F, 0xFC, 0xF9, 0xF3, 0xE3, 0xEF,
  0x0F, 0xBC, 0x3C, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x3F,
  0x7C, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x3E, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x06, 0x1F, 0x1F,
  0x1F, 0x1E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xF8, 0xFC, 0xF8,
  0xF8, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x8F, 0xF1,
  0xFE, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x01, 0xFC,
  0x1F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F,
  0xCF, 0xFE, 0x7F, 0xE7, 0xFE, 0x61, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xE0, 0x3C, 0x1E, 0x00, 0x78, 0xF0, 0xF8, 0xE3, 0x8F, 0xFB,
  0xDE, 0x7F, 0xCF, 0x73, 0xCF, 0x3F, 0xCF, 0x3C, 0xFF, 0x38, 0xE3, 0xB9,
  0xE3, 0x8E, 0xE7, 0x9E, 0x7B, 0x9E, 0x79, 0xCE, 0x7F, 0xFF, 0x3C, 0xFF,
  0xF8, 0xF1, 0xE7, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x20, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x0F, 0x8F, 0x81, 0xF7, 0xC0,
  0x7F, 0xF0, 0x1F, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0x8E, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x10, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFB, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3,
  0xF3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF8, 0xF8, 0xF9, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF1, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF1, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF8, 0x21, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0xFF, 0x3E, 0x7F, 0xBF, 0x3F, 0xDF, 0x9F, 0xCF,
  0xC3, 0xE7, 0xE1, 0xF3, 0xF0, 0xF8, 0xFC, 0x7C, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F,
  0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x83, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xF0, 0x00, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xCF, 0xC1,
  0xFB, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF8, 0x1F,
  0x3F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7C,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x1E, 0xE3, 0xFE, 0x1E, 0xE7, 0xBC, 0x3E,
  0xE7, 0xBC, 0x3E, 0xE7, 0x7C, 0x3E, 0xEF, 0x7C, 0x3C, 0xEF, 0x7C, 0x3C,
  0xFE, 0x78, 0x7C, 0xFE, 0xF8, 0x7C, 0xFC, 0xF8, 0x7C, 0xFC, 0xF8, 0x78,
  0xF8, 0xF8, 0x78, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0x0F, 0xC0, 0xF8, 0x7F,
  0x07, 0x83, 0xF8, 0x3C, 0x1F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF8, 0xF8,
  0x7F, 0xC7, 0x83, 0xDE, 0x7C, 0x1E, 0xF3, 0xE1, 0xF7, 0xDF, 0x0F, 0xBE,
  0xF8, 0x7C, 0xF7, 0x83, 0xC7, 0xBC, 0x1E, 0x3F, 0xE1, 0xF1, 0xFF, 0x0F,
  0x87, 0xF0, 0x7C, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xE1, 0xF0, 0x3F,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF3, 0xF9, 0xF9,
  0xF8, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0xFC, 0xF8, 0xFC, 0x7F,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xBF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x3F, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8,
  0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0, 0xFC, 0xF8, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFF, 0x1F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x7F,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8,
  0x7C, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7E, 0xF8, 0x3E, 0x03, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xF1, 0x87, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x20, 0x7E, 0x70, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xF8, 0x1F, 0xFC, 0x1F,
  0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC3, 0xC3, 0xE1, 0xE3, 0xE0, 0xF1,
  0xF0, 0x78, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x7C, 0x07, 0xBE, 0x03,
  0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x1F, 0xFC, 0x1F, 0x0F, 0xBE, 0x1F, 0x87,
  0xDF, 0x0F, 0xC7, 0xCF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF3, 0xE3, 0xE3, 0xF9,
  0xF1, 0xF3, 0xFC, 0xF8, 0xF9, 0xFE, 0xF8, 0x7D, 0xEF, 0x7C, 0x3E, 0xF7,
  0xBC, 0x1F, 0xFB, 0xBE, 0x0F, 0xF9, 0xDF, 0x07, 0xFD, 0xEF, 0x03, 0xFC,
  0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x1F, 0x80,
  0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0x00, 0xFC,
  0x3F, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x3D, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7, 0x07, 0x9E,
  0x1E, 0x78, 0xF1, 0xE7, 0xC3, 0x9E, 0x0F, 0xF0, 0x3C, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFC, 0xF8, 0xF0, 0xF0, 0x07, 0x00, 0x3F, 0x7C, 0xFF, 0xF1,
  0xFF, 0xE7, 0xEF, 0xCF, 0x8F, 0x9F, 0x1E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1,
  0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1E, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE6, 0x07,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x7E, 0xFC, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3,
  0xE7, 0x8F, 0xDF, 0x1F, 0x3E, 0x3E, 0x7C, 0xFC, 0xFF, 0xF1, 0xFF, 0xE7,
  0xFF, 0x8F, 0x3E, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xE6,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x07, 0x3E, 0x1F, 0xBE, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7E, 0xFC, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF9, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3D, 0xF0,
  0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7E, 0x7D, 0xF1, 0xEF, 0xCF,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFE, 0x0F, 0x80, 0x3E, 0x08, 0xFF, 0xE1, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFA,
  0x01, 0xF0, 0x01, 0xF2, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0xBF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x0F, 0xDF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0xC3, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE7, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x7F, 0xFC, 0xFC, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF,
  0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xE7, 0xC7, 0xCF,
  0x8F, 0x80, 0x03, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x3E, 0x1F,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x8F, 0x87, 0xC0, 0x00, 0x30, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xBF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC,
  0x07, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x7E, 0x3E, 0x7E, 0x1F, 0x7E, 0x1F, 0x3E,
  0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7D, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0x1F, 0x1F, 0x8F, 0x87, 0xC0,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x00, 0x00, 0x38, 0x38, 0x3D, 0xF9, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F,
  0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x7C, 0x00, 0x38, 0x3D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xE7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0x03, 0xC0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x7E, 0xFD, 0xF1, 0xF7, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3,
  0xEF, 0x8F, 0xBE, 0x7E, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x00,
  0x38, 0x0F, 0x7E, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xBF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x7D, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x3F,
  0x7C, 0xFF, 0xF1, 0xFF, 0xE7, 0xEF, 0xCF, 0x8F, 0x9F, 0x1E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1E, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x38, 0xF7, 0x87, 0xBC, 0x3F, 0xE1,
  0xFF, 0x1F, 0xC8, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0xFF, 0xCF, 0xFC,
  0x7F, 0xE3, 0xE2, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00,
  0xF9, 0x07, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x07, 0x01, 0xE0,
  0x3C, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x00,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x1F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF,
  0x0F, 0xDE, 0x1F, 0x3C, 0x00, 0xF8, 0x7E, 0xF0, 0xF9, 0xE3, 0xE3, 0xC7,
  0xC7, 0x9F, 0x0F, 0xBE, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF1, 0xF8,
  0xFF, 0x8F, 0xCF, 0xBC, 0xFE, 0x7D, 0xE7, 0xF3, 0xCF, 0x3F, 0xBE, 0x7B,
  0xFD, 0xE3, 0xDD, 0xFF, 0x1E, 0xEE, 0xF8, 0xFF, 0x77, 0x87, 0xF3, 0xFC,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF0, 0x00, 0x0F, 0xCF, 0xC1, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x8F, 0xC3, 0xE0,
  0x1F, 0x0F, 0xC3, 0xC3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0xFB, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x2F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xFC, 0x7F,
  0xF3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x7C, 0x0F, 0xC0,
  0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x10, 0x05, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFA, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 20, 8, 0, -20 },
  { 24, 11, 7, 13, 3, -20 },
  { 34, 18, 20, 17, 0, -20 },
  { 79, 14, 23, 15, 1, -21 },
  { 120, 22, 20, 25, 2, -20 },
  { 175, 19, 20, 19, 0, -20 },
  { 223, 5, 7, 7, 3, -20 },
  { 228, 11, 25, 10, 1, -21 },
  { 263, 11, 25, 10, -2, -21 },
  { 298, 13, 14, 14, 2, -22 },
  { 321, 13, 14, 16, 1, -17 },
  { 344, 8, 8, 8, -2, -4 },
  { 352, 9, 5, 9, 0, -10 },
  { 358, 6, 5, 8, 0, -5 },
  { 362, 15, 20, 12, -1, -20 },
  { 400, 14, 20, 15, 1, -20 },
  { 435, 12, 20, 15, 2, -20 },
  { 465, 16, 20, 15, -1, -20 },
  { 505, 15, 20, 15, 0, -20 },
  { 543, 15, 20, 15, 0, -20 },
  { 581, 15, 20, 15, 0, -20 },
  { 619, 15, 20, 15, 1, -20 },
  { 657, 15, 20, 15, 1, -20 },
  { 695, 14, 20, 15, 1, -20 },
  { 730, 14, 20, 15, 1, -20 },
  { 765, 8, 16, 8, 0, -16 },
  { 781, 10, 20, 8, -2, -16 },
  { 806, 13, 15, 16, 1, -18 },
  { 831, 13, 10, 16, 1, -15 },
  { 848, 14, 15, 16, 1, -18 },
  { 875, 12, 20, 13, 2, -20 },
  { 905, 22, 22, 23, 1, -20 },
  { 966, 18, 20, 17, -2, -20 },
  { 1011, 16, 20, 17, 0, -20 },
  { 1051, 16, 20, 16, 1, -20 },
  { 1091, 17, 20, 18, 0, -20 },
  { 1134, 15, 20, 14, 0, -20 },
  { 1172, 15, 20, 14, 0, -20 },
  { 1210, 17, 20, 18, 1, -20 },
  { 1253, 19, 20, 18, 0, -20 },
  { 1301, 14, 20, 11, -1, -20 },
  { 1336, 14, 26, 9, -4, -20 },
  { 1382, 19, 20, 17, 0, -20 },
  { 1430, 12, 20, 13, 0, -20 },
  { 1460, 24, 20, 24, 0, -20 },
  { 1520, 21, 20, 20, 0, -20 },
  { 1573, 17, 20, 19, 1, -20 },
  { 1616, 16, 20, 16, 0, -20 },
  { 1656, 17, 25, 19, 1, -20 },
  { 1710, 16, 20, 17, 0, -20 },
  { 1750, 15, 20, 14, 0, -20 },
  { 1788, 14, 20, 14, 2, -20 },
  { 1823, 18, 20, 18, 1, -20 },
  { 1868, 17, 20, 16, 2, -20 },
  { 1911, 25, 20, 24, 2, -20 },
  { 1974, 21, 20, 17, -2, -20 },
  { 2027, 16, 20, 16, 2, -20 },
  { 2067, 17, 20, 14, -1, -20 },
  { 2110, 12, 26, 9, -1, -21 },
  { 2149, 7, 20, 12, 3, -20 },
  { 2167, 12, 26, 9, -2, -21 },
  { 2206, 14, 13, 14, 0, -20 },
  { 2229, 13, 3, 12, -3, 2 },
  { 2234, 7, 4, 10, 4, -21 },
  { 2238, 15, 16, 16, 1, -16 },
  { 2268, 15, 21, 16, 0, -21 },
  { 2308, 13, 16, 13, 1, -16 },
  { 2334, 16, 21, 16, 1, -21 },
  { 2376, 14, 16, 15, 1, -16 },
  { 2404, 16, 28, 10, -3, -21 },
  { 2460, 16, 23, 16, 0, -16 },
  { 2506, 15, 21, 16, 0, -21 },
  { 2546, 9, 22, 8, 0, -22 },
  { 2571, 13, 29, 8, -4, -22 },
  { 2619, 17, 21, 16, 0, -21 },
  { 2664, 10, 21, 8, 0, -21 },
  { 2691, 23, 16, 24, 0, -16 },
  { 2737, 15, 16, 16, 0, -16 },
  { 2767, 14, 16, 16, 1, -16 },
  { 2795, 16, 23, 16, -1, -16 },
  { 2841, 15, 23, 16, 1, -16 },
  { 2885, 13, 16, 11, 0, -16 },
  { 2911, 13, 16, 13, 0, -16 },
  { 2937, 11, 19, 12, 1, -19 },
  { 2964, 15, 15, 16, 1, -15 },
  { 2993, 15, 15, 14, 1, -15 },
  { 3022, 21, 15, 22, 2, -15 },
  { 3062, 18, 15, 15, -2, -15 },
  { 3096, 18, 22, 14, -2, -15 },
  { 3146, 14, 15, 13, -1, -15 },
  { 3173, 12, 24, 10, 0, -20 },
  { 3209, 4, 27, 14, 5, -21 },
  { 3223, 12, 24, 10, -2, -20 },
  { 3259, 14, 6, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC28PT7B_H_
