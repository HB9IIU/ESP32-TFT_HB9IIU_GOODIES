#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x7F, 0x7E, 0xFC, 0xFD, 0xF9, 0xFB, 0xF3, 0xE7,
  0xC7, 0xCF, 0x9F, 0x9F, 0x3E, 0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F,
  0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x78, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1E, 0x3E, 0x00, 0x3C, 0x78,
  0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x78, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFD, 0x9C, 0x3F, 0x70, 0x87,
  0xEE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3B, 0xE0, 0x07, 0x7E, 0x60,
  0xEF, 0x8F, 0x9B, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0xFF, 0x00, 0x7C, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0,
  0x7C, 0x07, 0xCF, 0x83, 0xE0, 0x3E, 0x7C, 0x3E, 0x01, 0xE3, 0xE3, 0xE0,
  0x1F, 0x1F, 0x1F, 0x00, 0xF8, 0xF1, 0xF0, 0x07, 0xCF, 0x9F, 0x00, 0x3E,
  0x7C, 0xF8, 0xF1, 0xF7, 0xEF, 0x9F, 0xCF, 0xFE, 0xF9, 0xFF, 0x3F, 0xE7,
  0xDF, 0xFD, 0xFE, 0x7D, 0xFB, 0xE7, 0xE7, 0xCF, 0x9F, 0x00, 0x3E, 0x7C,
  0xF8, 0x03, 0xE7, 0xC7, 0xC0, 0x3E, 0x3E, 0x3E, 0x01, 0xF1, 0xF1, 0xE0,
  0x1F, 0x0F, 0x9F, 0x01, 0xF0, 0x7C, 0xF8, 0x0F, 0x83, 0xFF, 0x80, 0xF8,
  0x0F, 0xFC, 0x0F, 0x80, 0x7F, 0xC0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07,
  0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x10,
  0x7F, 0xE3, 0xF0, 0xFF, 0xE3, 0xF8, 0xFF, 0xF9, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0x7F, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xFE, 0x1F, 0xC3, 0xFE,
  0x0F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFD, 0xFE, 0x00, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x41, 0xE0, 0x63, 0xE0, 0x7B, 0xE0, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0,
  0xFE, 0xF0, 0x7C, 0xF8, 0x18, 0xFC, 0x08, 0xF0, 0x00, 0x40, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1F,
  0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0x3F, 0xEF, 0xFC, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xF7, 0xF1, 0xF8,
  0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xDF, 0xC3, 0xF7, 0xF0, 0xFD, 0xF8, 0x7F,
  0x7E, 0x1F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0xFE, 0x3F, 0xBF,
  0x8F, 0xEF, 0xC3, 0xF3, 0xF9, 0xFC, 0xFE, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0xFB, 0xF0, 0xC7, 0xE1, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0x87, 0xF0, 0x30, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0x3F, 0xC1, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x40,
  0x1F, 0xCE, 0x07, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xF9, 0xF8, 0x3E,
  0x7F, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0E, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x88, 0x03, 0xF8, 0xE0, 0x7F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xE0, 0x87, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xEF, 0xC1, 0xFB,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xCF, 0xE7, 0xF0,
  0xFC, 0xFE, 0x1F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xE7,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x9F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xE1, 0xFD, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3,
  0xFB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xF7, 0xF3, 0xF9, 0xFD, 0xFC, 0x3F, 0x7F,
  0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xFD, 0xFC, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0x7E, 0x1F, 0xBF, 0x80, 0x8F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x81, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0xF9, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF, 0xE7, 0x9F,
  0xCC, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xE1, 0xF0, 0xFF, 0x9F, 0x3E, 0x1F, 0xFD, 0xF3, 0xE3, 0xFF,
  0x8F, 0x7C, 0x7E, 0xF8, 0xF7, 0xCF, 0x8F, 0x8F, 0x78, 0xF8, 0xF8, 0xF7,
  0x8F, 0x0F, 0x1F, 0xF9, 0xF0, 0xF1, 0xFF, 0x9F, 0x1F, 0x1E, 0xF9, 0xF1,
  0xF3, 0xEF, 0x9F, 0x3E, 0x3C, 0xF9, 0xFF, 0xFF, 0xCF, 0x9F, 0xFF, 0xF8,
  0xF8, 0xFE, 0xFF, 0x07, 0x87, 0xC7, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x81, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x0F, 0xDF,
  0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF7, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x3F, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0xC7, 0xF3, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xC0, 0xC3, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x10, 0xFF, 0x0E, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x07, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3,
  0xF0, 0x7F, 0x0F, 0xC3, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0x80, 0x87, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0xEF, 0xE3, 0xFF, 0x7F, 0x1F, 0xF3, 0xF1, 0xFF, 0x9F,
  0x8F, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x83, 0xF1, 0xFC, 0x1F,
  0x8F, 0xF0, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x04, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07,
  0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0x78, 0x7F, 0xF0,
  0x3E, 0xF0, 0xFF, 0xE0, 0xFD, 0xE3, 0xEF, 0xC1, 0xFB, 0xC7, 0xDF, 0x83,
  0xF7, 0x9F, 0x7E, 0x07, 0xEF, 0x3E, 0xFC, 0x1F, 0x9E, 0xF9, 0xF8, 0x3F,
  0x3F, 0xF3, 0xF0, 0x7E, 0x7F, 0xEF, 0xE0, 0xFC, 0xFF, 0x9F, 0x81, 0xF9,
  0xFF, 0x3F, 0x07, 0xE3, 0xFC, 0x7E, 0x0F, 0xC7, 0xF8, 0xFC, 0x1F, 0x8F,
  0xE3, 0xF0, 0x3F, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0xFF, 0x81, 0xF8, 0x1F, 0xF0, 0x3F,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0xFC, 0x1F, 0x83, 0xFF,
  0x87, 0xE0, 0x7F, 0xF0, 0xFC, 0x0F, 0xFE, 0x1F, 0x81, 0xF7, 0xE3, 0xF0,
  0x3E, 0xFC, 0x7C, 0x0F, 0xDF, 0x9F, 0x81, 0xFB, 0xF3, 0xF0, 0x3F, 0x3F,
  0x7E, 0x07, 0xE7, 0xEF, 0xC1, 0xF8, 0xFD, 0xF0, 0x3F, 0x1F, 0xBE, 0x07,
  0xE1, 0xFF, 0xC0, 0xFC, 0x3F, 0xF8, 0x1F, 0x87, 0xFF, 0x07, 0xE0, 0xFF,
  0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x3F, 0xE0, 0x7E,
  0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xE3, 0xFC,
  0x3F, 0x8F, 0xE0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x83,
  0xF8, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F,
  0x9F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0,
  0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC,
  0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0x83, 0xF8, 0xFF, 0x3F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF7, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x07,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F,
  0xE7, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x20, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x20, 0x3F, 0x87, 0x8F, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01,
  0xFD, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0xFE,
  0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x3F,
  0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xEF, 0xC1, 0xFC, 0x1F, 0xDF, 0x83, 0xF8,
  0x3F, 0x3F, 0x0F, 0xF0, 0xFE, 0x7E, 0x1F, 0xE1, 0xF8, 0xFC, 0x7F, 0xC3,
  0xF1, 0xF8, 0xFF, 0x8F, 0xE3, 0xF1, 0xFF, 0x1F, 0x87, 0xE7, 0xFE, 0x7F,
  0x0F, 0xCF, 0xFC, 0xFC, 0x1F, 0xBE, 0xF9, 0xF8, 0x3F, 0x7D, 0xF7, 0xE0,
  0x7F, 0xFB, 0xEF, 0xC0, 0xFF, 0xE7, 0xDF, 0x81, 0xFF, 0xCF, 0xFE, 0x03,
  0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0x7E, 0x0F, 0xE7, 0xE1, 0xFC, 0x7E, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F,
  0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x40, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0xF8, 0xF0, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xE0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x03,
  0xE3, 0xE1, 0xFE, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8,
  0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0xF8, 0x1F, 0x9F, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFC, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0x8F, 0xE7, 0xF1,
  0xFC, 0xFE, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xBF,
  0xC3, 0xE3, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0x84, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x04, 0xFE, 0x18, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x7C, 0xFC, 0x0F, 0xF7, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF0, 0x7F, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xDF, 0xCF, 0xC3, 0xF7, 0xF1, 0xFD, 0xFC,
  0x7E, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x63, 0xFE, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xD8, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xBF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x80, 0x7E, 0x0F, 0x9F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x17, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x7C, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFE, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3F, 0x8F, 0xE7,
  0xF1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F,
  0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x00,
  0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xDF,
  0xC0, 0x7E, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFC,
  0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0x8F, 0xC3,
  0xF0, 0x7D, 0xFE, 0x7F, 0x83, 0xEF, 0xFB, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF0,
  0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF9, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8,
  0xFE, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x3F, 0x8F, 0xE1, 0xF9,
  0xFC, 0x7F, 0x1F, 0xCF, 0xC3, 0xF8, 0xFE, 0x7E, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x3F, 0x3F, 0x8F, 0xE1, 0xF9, 0xFC, 0x7F, 0x1F, 0xC0, 0x0F, 0x9F,
  0x81, 0xF7, 0xF8, 0x3E, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xDF,
  0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFE,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xE7, 0xF7,
  0xF1, 0xFD, 0xFC, 0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xE7, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xE7, 0xE0, 0x1F, 0x7F,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF9, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xE3, 0xE1, 0xFE, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3,
  0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xBF, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x8F, 0x0F,
  0x9F, 0x0F, 0xBF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE2, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xDE, 0x3F,
  0x84, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0xC0, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xBF, 0x03, 0xF3, 0xE0, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0,
  0xFE, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE1, 0xF3, 0xF8, 0x7C, 0xFC,
  0x1F, 0x3F, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x7E, 0xFC, 0x7F, 0x8F, 0xEF,
  0xC7, 0xF8, 0xFC, 0xFC, 0x7F, 0x8F, 0xCF, 0xCF, 0xF9, 0xF8, 0xFC, 0xFF,
  0x9F, 0x8F, 0xDF, 0xFB, 0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDE, 0xFB, 0xE0,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0x7C, 0x0F, 0xFC,
  0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x07,
  0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFE, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0x84, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFA, 0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 26, 10, 0, -26 },
  { 40, 15, 10, 16, 3, -26 },
  { 59, 23, 26, 22, 0, -26 },
  { 134, 19, 29, 19, 1, -27 },
  { 203, 29, 26, 32, 2, -26 },
  { 298, 25, 26, 25, 0, -26 },
  { 380, 8, 10, 9, 3, -26 },
  { 390, 14, 32, 12, 1, -26 },
  { 446, 14, 32, 12, -3, -26 },
  { 502, 16, 18, 18, 3, -28 },
  { 538, 17, 17, 20, 2, -21 },
  { 575, 9, 10, 10, -2, -5 },
  { 587, 11, 5, 12, 0, -12 },
  { 594, 7, 6, 10, 0, -6 },
  { 600, 21, 26, 16, -2, -26 },
  { 669, 18, 26, 19, 1, -26 },
  { 728, 15, 26, 19, 3, -26 },
  { 777, 20, 26, 19, -1, -26 },
  { 842, 19, 26, 19, 0, -26 },
  { 904, 19, 26, 19, 0, -26 },
  { 966, 20, 26, 19, 0, -26 },
  { 1031, 19, 26, 19, 1, -26 },
  { 1093, 20, 26, 19, 1, -26 },
  { 1158, 18, 26, 19, 1, -26 },
  { 1217, 18, 26, 19, 1, -26 },
  { 1276, 10, 20, 11, 0, -20 },
  { 1301, 12, 25, 11, -2, -20 },
  { 1339, 17, 20, 20, 2, -23 },
  { 1382, 17, 13, 20, 2, -19 },
  { 1410, 17, 20, 20, 2, -23 },
  { 1453, 15, 26, 16, 2, -26 },
  { 1502, 28, 29, 30, 1, -26 },
  { 1604, 22, 26, 22, -2, -26 },
  { 1676, 21, 26, 21, 0, -26 },
  { 1745, 20, 26, 21, 2, -26 },
  { 1810, 22, 26, 23, 0, -26 },
  { 1882, 20, 26, 18, 0, -26 },
  { 1947, 20, 26, 18, 0, -26 },
  { 2012, 21, 26, 23, 2, -26 },
  { 2081, 24, 26, 24, 0, -26 },
  { 2159, 18, 26, 15, -1, -26 },
  { 2218, 19, 34, 12, -6, -26 },
  { 2299, 25, 26, 22, 0, -26 },
  { 2381, 16, 26, 17, 0, -26 },
  { 2433, 31, 26, 31, 0, -26 },
  { 2534, 27, 26, 26, 0, -26 },
  { 2622, 22, 26, 24, 2, -26 },
  { 2694, 21, 26, 21, 0, -26 },
  { 2763, 22, 32, 24, 2, -26 },
  { 2851, 21, 26, 21, 0, -26 },
  { 2920, 19, 26, 18, 0, -26 },
  { 2982, 18, 26, 18, 3, -26 },
  { 3041, 22, 26, 23, 2, -26 },
  { 3113, 21, 26, 21, 3, -26 },
  { 3182, 31, 26, 31, 3, -26 },
  { 3283, 26, 26, 22, -2, -26 },
  { 3368, 20, 26, 20, 3, -26 },
  { 3433, 22, 26, 18, -2, -26 },
  { 3505, 16, 32, 12, -1, -26 },
  { 3569, 9, 26, 16, 4, -26 },
  { 3599, 16, 32, 12, -3, -26 },
  { 3663, 18, 17, 18, 0, -26 },
  { 3702, 16, 5, 15, -3, 2 },
  { 3712, 9, 6, 12, 5, -28 },
  { 3719, 19, 20, 20, 1, -20 },
  { 3767, 19, 27, 20, 0, -27 },
  { 3832, 16, 20, 17, 1, -20 },
  { 3872, 21, 27, 20, 1, -27 },
  { 3943, 18, 20, 19, 1, -20 },
  { 3988, 21, 37, 13, -4, -28 },
  { 4086, 20, 29, 20, 0, -20 },
  { 4159, 19, 27, 21, 0, -27 },
  { 4224, 12, 28, 11, 0, -28 },
  { 4266, 17, 37, 11, -5, -28 },
  { 4345, 22, 27, 20, 0, -27 },
  { 4420, 12, 27, 11, 0, -27 },
  { 4461, 29, 20, 31, 0, -20 },
  { 4534, 19, 20, 21, 0, -20 },
  { 4582, 18, 20, 20, 1, -20 },
  { 4627, 21, 29, 20, -2, -20 },
  { 4704, 19, 29, 20, 1, -20 },
  { 4773, 16, 20, 15, 0, -20 },
  { 4813, 16, 20, 17, 0, -20 },
  { 4853, 15, 24, 15, 1, -24 },
  { 4898, 20, 20, 21, 1, -20 },
  { 4948, 18, 20, 18, 2, -20 },
  { 4993, 28, 20, 28, 2, -20 },
  { 5063, 23, 20, 19, -2, -20 },
  { 5121, 22, 29, 18, -2, -20 },
  { 5201, 18, 20, 16, -1, -20 },
  { 5246, 15, 32, 13, 0, -26 },
  { 5306, 4, 35, 18, 7, -27 },
  { 5324, 15, 32, 13, -2, -26 },
  { 5384, 17, 7, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC36PT7B_H_
