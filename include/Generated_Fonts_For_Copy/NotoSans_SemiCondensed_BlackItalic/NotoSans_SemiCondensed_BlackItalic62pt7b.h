#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F,
  0xE7, 0xFE, 0x3F, 0xF3, 0xFF, 0x1F, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0x87,
  0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xE1, 0xE0, 0x1F,
  0xF9, 0xE0, 0x20, 0x0F, 0xFC, 0xF0, 0x00, 0x07, 0xFE, 0x78, 0x00, 0x03,
  0xFF, 0x7C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0x0F, 0xBF,
  0xF0, 0x40, 0x07, 0x8F, 0xF8, 0x30, 0x03, 0xC7, 0xFC, 0x1E, 0x01, 0xE7,
  0xFE, 0x0F, 0xE1, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE3,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0x7F, 0x81, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F,
  0xF8, 0x7F, 0x9F, 0xF1, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xC7, 0xFC,
  0xFF, 0x8F, 0xF0, 0xFF, 0xE1, 0xFE, 0x3F, 0xE3, 0xFC, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF9, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xCF,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x3F, 0xE0, 0x03,
  0xC1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFF,
  0xF8, 0x0E, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0xF8, 0x7F, 0xE0,
  0x03, 0x83, 0xFE, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xC1, 0xFE,
  0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F,
  0xFE, 0x07, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE,
  0x03, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0,
  0x1F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x01,
  0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFE, 0x1F,
  0xF9, 0xFF, 0x81, 0xFE, 0x7F, 0xF0, 0x1F, 0x8F, 0xFE, 0x03, 0xC1, 0xFF,
  0xC0, 0x30, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x1E, 0x01, 0xFF,
  0xC0, 0x02, 0x00, 0x7F, 0xF0, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x78, 0x07,
  0xFF, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x7F,
  0xF8, 0xF8, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xDF, 0xF8, 0x00, 0x3F, 0xDF, 0xFC, 0x00, 0x3F, 0xEF, 0xFE, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0x80,
  0x1F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0,
  0x0F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0x81, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x80,
  0x00, 0xFF, 0xF0, 0x60, 0x00, 0x7F, 0xF8, 0x3E, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x10, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE3,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF,
  0xE0, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xDF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF,
  0xF1, 0xF0, 0x1F, 0xFC, 0x70, 0x07, 0xFF, 0x10, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0,
  0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x3F, 0xC1,
  0xFF, 0x8F, 0xF0, 0x7F, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x3F, 0x83,
  0xFC, 0x0F, 0xE0, 0x7F, 0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0x87,
  0xF8, 0x1F, 0xE0, 0xFF, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFE, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0xFF, 0x0F,
  0xF0, 0x7F, 0x81, 0xFC, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0xFF, 0x0F,
  0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0x83,
  0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFD, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7C, 0x07, 0xFF, 0xE0, 0x03, 0x00, 0xFF, 0xF8, 0x00, 0x20,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x04, 0x03, 0xFF, 0xE0, 0x03, 0x80,
  0x7F, 0xFE, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x8F, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F,
  0xFF, 0x80, 0x03, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xF8, 0x3F,
  0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x8F,
  0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xE3,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xDF, 0xE0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFE, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0x87,
  0xFD, 0xFF, 0x80, 0x1F, 0xF9, 0xFE, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xE7,
  0xF8, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0xE0, 0x07,
  0xFE, 0x7F, 0x9F, 0xF3, 0xFF, 0x00, 0x3F, 0xF9, 0xFE, 0x7F, 0x8F, 0xFC,
  0x00, 0xFF, 0xC7, 0xFB, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xEF, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF7,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xCF, 0xFC, 0x7F, 0xF0, 0x07, 0xFE, 0x3F,
  0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFF,
  0x9F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF9,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFE, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x07,
  0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xCF,
  0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFE,
  0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF,
  0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3,
  0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x3F, 0xF8,
  0x00, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x40, 0x00, 0xFF, 0xF0,
  0x38, 0x00, 0x7F, 0xF8, 0x1F, 0x00, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE3,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC3, 0xFD, 0xFF, 0x1F, 0xFC, 0x03, 0xFF,
  0x1F, 0xF7, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xDF, 0xF3, 0xFF, 0x80,
  0x3F, 0xF3, 0xFE, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xCF, 0xF9, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xE7, 0xFD, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x1F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x7F, 0xBF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE1, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x87, 0xFB, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x87,
  0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x3E, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFE, 0x7F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0xFF,
  0xFC, 0x07, 0xFE, 0x3F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xF0,
  0x78, 0x1F, 0xFE, 0x01, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x04, 0x0F, 0xFF, 0x01, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x00,
  0xFF, 0xF3, 0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF7,
  0xFC, 0x00, 0x3F, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF1, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0, 0xFF,
  0xF7, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x0F, 0xFF, 0x00,
  0x78, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0C,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0x00,
  0x3F, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x06, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x07,
  0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x67, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x20, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xF8, 0x3F, 0xFE, 0x00,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xF3, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xCF, 0xFF,
  0x80, 0x3F, 0xEF, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF9, 0xFF, 0xE0, 0xFF, 0xF3,
  0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF,
  0xC0, 0x7F, 0xF7, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xDF, 0xFC,
  0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x7F, 0xF1, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC, 0x07, 0xFE,
  0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01,
  0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0x08, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0x80, 0xE0, 0x7F, 0xF0,
  0x04, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x80, 0x0F, 0xFF,
  0x18, 0x01, 0xFF, 0xE3, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x40, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFE,
  0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x3F,
  0xE3, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x7F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE3, 0xFB, 0xF8, 0xFF, 0xE0, 0x7F, 0xE7, 0xFB, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFB, 0xF8, 0xFF, 0xC0, 0x7F, 0xE7, 0xF7, 0xF9, 0xFF,
  0xC0, 0x7F, 0xEF, 0xF7, 0xF9, 0xFF, 0x80, 0x7F, 0xEF, 0xF7, 0xF9, 0xFF,
  0x80, 0x7F, 0xEF, 0xE7, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xE7, 0xFB, 0xFF,
  0x00, 0x7F, 0xDF, 0xE7, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xC7, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00,
  0xFF, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x23, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x09, 0xFF, 0xE0, 0x00,
  0x5F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xA0, 0x00, 0xFF, 0xF9, 0x00, 0x00, 0x7F,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 21, 45, 18, 0, -44 },
  { 120, 25, 16, 28, 6, -44 },
  { 170, 39, 44, 37, 0, -44 },
  { 385, 33, 51, 34, 1, -47 },
  { 596, 50, 46, 55, 3, -45 },
  { 884, 42, 46, 42, 0, -45 },
  { 1126, 12, 16, 15, 6, -44 },
  { 1150, 24, 56, 21, 2, -46 },
  { 1318, 24, 56, 21, -4, -46 },
  { 1486, 29, 31, 31, 4, -48 },
  { 1599, 29, 30, 34, 3, -37 },
  { 1708, 16, 16, 18, -3, -8 },
  { 1740, 18, 9, 20, 1, -21 },
  { 1761, 12, 12, 18, 0, -11 },
  { 1779, 35, 46, 27, -3, -45 },
  { 1981, 31, 46, 34, 2, -45 },
  { 2160, 27, 44, 34, 5, -44 },
  { 2309, 34, 45, 34, -2, -45 },
  { 2501, 32, 46, 34, 0, -45 },
  { 2685, 33, 44, 34, 0, -44 },
  { 2867, 33, 45, 34, 1, -44 },
  { 3053, 33, 46, 34, 2, -45 },
  { 3243, 36, 44, 34, 1, -44 },
  { 3441, 32, 46, 34, 1, -45 },
  { 3625, 31, 46, 34, 2, -45 },
  { 3804, 18, 36, 18, 0, -35 },
  { 3885, 22, 43, 18, -4, -35 },
  { 4004, 29, 33, 34, 3, -39 },
  { 4124, 29, 22, 34, 3, -33 },
  { 4204, 29, 33, 34, 3, -39 },
  { 4324, 26, 46, 28, 4, -45 },
  { 4474, 48, 50, 51, 2, -45 },
  { 4774, 39, 44, 39, -4, -44 },
  { 4989, 36, 44, 37, 0, -44 },
  { 5187, 35, 46, 35, 3, -45 },
  { 5389, 38, 44, 39, 0, -44 },
  { 5598, 34, 44, 32, 0, -44 },
  { 5785, 34, 44, 32, 0, -44 },
  { 5972, 37, 46, 40, 3, -45 },
  { 6185, 42, 44, 41, 0, -44 },
  { 6416, 31, 44, 25, -2, -44 },
  { 6587, 32, 58, 21, -10, -44 },
  { 6819, 43, 44, 38, 0, -44 },
  { 7056, 27, 44, 30, 0, -44 },
  { 7205, 54, 44, 53, 0, -44 },
  { 7502, 46, 44, 45, 0, -44 },
  { 7755, 38, 46, 42, 3, -45 },
  { 7974, 36, 44, 35, 0, -44 },
  { 8172, 38, 56, 42, 3, -45 },
  { 8438, 36, 44, 37, 0, -44 },
  { 8636, 33, 46, 31, 0, -45 },
  { 8826, 31, 44, 31, 5, -44 },
  { 8997, 38, 45, 40, 3, -44 },
  { 9211, 36, 44, 36, 5, -44 },
  { 9409, 54, 44, 54, 5, -44 },
  { 9706, 46, 44, 37, -4, -44 },
  { 9959, 35, 44, 35, 5, -44 },
  { 10152, 38, 44, 31, -3, -44 },
  { 10361, 27, 56, 21, -2, -46 },
  { 10550, 17, 46, 27, 6, -45 },
  { 10648, 27, 56, 21, -4, -46 },
  { 10837, 32, 29, 32, -1, -44 },
  { 10953, 29, 7, 26, -6, 4 },
  { 10979, 14, 9, 21, 9, -47 },
  { 10995, 33, 36, 35, 2, -35 },
  { 11144, 33, 48, 35, 0, -47 },
  { 11342, 28, 36, 29, 2, -35 },
  { 11468, 36, 48, 35, 2, -47 },
  { 11684, 30, 36, 33, 2, -35 },
  { 11819, 37, 62, 23, -7, -47 },
  { 12106, 35, 50, 35, 0, -35 },
  { 12325, 33, 47, 36, 0, -47 },
  { 12519, 21, 48, 18, 0, -48 },
  { 12645, 29, 63, 18, -8, -48 },
  { 12874, 39, 47, 35, 0, -47 },
  { 13104, 21, 47, 18, 0, -47 },
  { 13228, 51, 35, 53, 0, -35 },
  { 13452, 33, 35, 36, 0, -35 },
  { 13597, 31, 36, 35, 2, -35 },
  { 13737, 36, 50, 35, -3, -35 },
  { 13962, 33, 50, 35, 2, -35 },
  { 14169, 28, 35, 25, 0, -35 },
  { 14292, 27, 36, 29, 1, -35 },
  { 14414, 25, 42, 26, 2, -41 },
  { 14546, 33, 35, 36, 2, -34 },
  { 14691, 32, 34, 32, 3, -34 },
  { 14827, 48, 34, 48, 3, -34 },
  { 15031, 39, 34, 33, -3, -34 },
  { 15197, 39, 49, 32, -4, -34 },
  { 15436, 31, 34, 28, -2, -34 },
  { 15568, 26, 54, 22, 0, -44 },
  { 15744, 9, 61, 31, 11, -47 },
  { 15813, 26, 54, 22, -4, -44 },
  { 15989, 29, 12, 34, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC62PT7B_H_
