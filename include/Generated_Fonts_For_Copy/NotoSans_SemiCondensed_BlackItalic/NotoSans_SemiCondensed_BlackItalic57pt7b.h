#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8, 0x7F,
  0x87, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFD, 0xFC, 0x07, 0xFC, 0xF0, 0xE0, 0x3F, 0xE7, 0x80, 0x80,
  0xFF, 0x9E, 0x00, 0x03, 0xFF, 0x78, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xDF, 0xF8, 0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x3C, 0xFF, 0x86,
  0x00, 0xF3, 0xFE, 0x1E, 0x03, 0xCF, 0xF0, 0x7F, 0x1E, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFE,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x87,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x03, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE3, 0xFC,
  0x3F, 0x83, 0xFC, 0x7F, 0x9F, 0xE3, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0x1F,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xE3, 0xFC, 0xFF, 0xFF,
  0xC7, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x00, 0xFF,
  0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0x9F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xE7, 0xFF, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF,
  0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x04, 0x07, 0xF8, 0x03, 0x81, 0xFC,
  0x00, 0xF8, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xFF, 0xE0, 0x37, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF7, 0xF0, 0x1F, 0xF9,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x1F, 0xF0, 0x07, 0x83, 0xFC, 0x00,
  0xE0, 0xFE, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC3,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3,
  0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0x7F, 0xE0,
  0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC,
  0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF,
  0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE7, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF, 0x3F, 0xF0, 0x3F, 0x1F, 0xF8,
  0x1E, 0x1F, 0xFC, 0x06, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xFF, 0x00,
  0x3C, 0x07, 0xFE, 0x00, 0x38, 0x07, 0xFE, 0x00, 0x10, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFC, 0x3F,
  0xFC, 0x03, 0x80, 0x7F, 0xF0, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x88, 0x00, 0x0F, 0xFE, 0x30,
  0x00, 0x7F, 0xF8, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x01,
  0xFE, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0x00, 0x7F,
  0x8F, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x80,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x08, 0x00, 0x1F, 0xFC, 0x30, 0x00, 0xFF, 0xF0, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x10, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xC0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xEF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x9F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE3,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x7F, 0xE3,
  0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0,
  0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFF, 0x07, 0xFF,
  0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0xC0, 0xFF, 0xEF, 0xFC, 0x07,
  0xF8, 0xFF, 0xC0, 0x04, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xC3, 0xFF, 0x8F, 0x01, 0xFF, 0x82, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xC7, 0xF1, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x87, 0xF3, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0x3F, 0x83, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x83,
  0xF8, 0x7F, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF7, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0x1F, 0xE1, 0xFC, 0xFE, 0x1F,
  0xC1, 0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xFC, 0x7F, 0x8F, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE1, 0xFF, 0xF7, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x7F, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0x01, 0xF0, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xCF,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x78, 0x1F, 0xFF, 0x00, 0x10, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0xFF, 0xF0, 0x03, 0x00, 0xFF, 0xFC,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF8, 0x07, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x40, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0x07,
  0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x08,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xEF, 0xF8,
  0x03, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xF7, 0xFE,
  0x01, 0xFF, 0x7F, 0x87, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0xC3, 0xFD, 0xFF,
  0x00, 0x7F, 0xDF, 0xE3, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xF1, 0xFE, 0xFF,
  0xC0, 0x3F, 0xF7, 0xF9, 0xFE, 0x7F, 0xE0, 0x1F, 0xFB, 0xFC, 0xFF, 0x3F,
  0xE0, 0x0F, 0xF9, 0xFE, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x7F, 0x9F,
  0xF8, 0x03, 0xFE, 0x7F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xC7,
  0xFE, 0x01, 0xFF, 0x9F, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xCF, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xC7, 0xFC,
  0x01, 0xFF, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0xFF, 0xC0, 0x3F,
  0xF1, 0xFF, 0xBF, 0xE0, 0x0F, 0xF8, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x0F,
  0xFB, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xEF,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF,
  0xCF, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF,
  0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x8F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0x80, 0x7F, 0xF0, 0x06, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC1, 0x00, 0x07, 0xFF, 0x06, 0x00, 0x1F, 0xF8, 0x1F, 0x00,
  0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xA0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07,
  0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF7, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x3F, 0xE0, 0x3F, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F,
  0xC3, 0xFF, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFD, 0xFE, 0x3F, 0xF0, 0x1F,
  0xF1, 0xFE, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x7F, 0x9F, 0xF8, 0x07,
  0xFC, 0xFF, 0x3F, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0x9F, 0xEF, 0xFC, 0x01,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xCF, 0xFB, 0xFE, 0x00,
  0x7F, 0xDF, 0xE7, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE3, 0xFD, 0xFF, 0x00,
  0x1F, 0xFF, 0xF1, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFE,
  0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFE, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x10, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x83, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFE, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xE0,
  0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x07, 0xFF,
  0x1F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x87,
  0xFE, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x9F, 0xFF,
  0x03, 0xFE, 0x3F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFE, 0x3E, 0x0F, 0xFF, 0x01, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x01, 0x03, 0xFF, 0x81, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x0F, 0xFC,
  0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xEF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7, 0xFF,
  0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x02, 0x0F, 0xFE, 0x00, 0xE0, 0xFF, 0xF0, 0x3E, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC6, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xF1, 0xFF,
  0x00, 0x7F, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xBF, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x80, 0x03, 0xFF, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x7F,
  0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE,
  0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xFC, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF,
  0xE7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0xE0, 0x1F,
  0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF,
  0x83, 0xFF, 0x3F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0x3F,
  0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F,
  0xFE, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x1F, 0xF7, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xDF, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x1F,
  0xF8, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81,
  0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xE3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFD, 0xFF, 0x80, 0x01, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xE7, 0xF8,
  0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x10, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0xFC, 0x1F,
  0xF8, 0x1C, 0x0F, 0xFC, 0x02, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE2, 0x00, 0x7F, 0xF1, 0x80, 0x3F,
  0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x10, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x28, 0x00, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x07,
  0xFE, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x87, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x3F,
  0xF0, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0,
  0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0x8F, 0xFC, 0x3F, 0xFE, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0xFE, 0xFE, 0x7F, 0xE0, 0xFF, 0xCF, 0xEF,
  0xE7, 0xFE, 0x0F, 0xFD, 0xFE, 0xFE, 0x7F, 0xC0, 0x7F, 0xDF, 0xDF, 0xEF,
  0xFC, 0x07, 0xFD, 0xFD, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xDF, 0xEF, 0xF8,
  0x07, 0xFB, 0xF9, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0x9F, 0xDF, 0xF0, 0x07,
  0xFB, 0xF9, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x11, 0xFF, 0x80, 0x03, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xEE, 0x00, 0x7F, 0xFC, 0x80,
  0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 42, 16, 0, -41 },
  { 101, 24, 15, 26, 5, -41 },
  { 146, 36, 41, 34, 0, -41 },
  { 331, 30, 46, 31, 1, -43 },
  { 504, 46, 42, 50, 3, -41 },
  { 746, 39, 42, 39, 0, -41 },
  { 951, 12, 15, 14, 5, -41 },
  { 974, 23, 51, 19, 1, -42 },
  { 1121, 22, 51, 19, -4, -42 },
  { 1262, 26, 28, 29, 4, -44 },
  { 1353, 26, 28, 32, 3, -34 },
  { 1444, 15, 15, 16, -3, -7 },
  { 1473, 16, 9, 18, 1, -20 },
  { 1491, 11, 11, 16, 0, -10 },
  { 1507, 32, 42, 25, -3, -41 },
  { 1675, 28, 42, 31, 2, -41 },
  { 1822, 25, 41, 31, 4, -41 },
  { 1951, 32, 41, 31, -2, -41 },
  { 2115, 30, 42, 31, 0, -41 },
  { 2273, 31, 41, 31, 0, -41 },
  { 2432, 30, 42, 31, 1, -41 },
  { 2590, 30, 42, 31, 2, -41 },
  { 2748, 33, 41, 31, 1, -41 },
  { 2918, 30, 42, 31, 1, -41 },
  { 3076, 28, 42, 31, 2, -41 },
  { 3223, 16, 33, 17, 0, -32 },
  { 3289, 19, 40, 17, -3, -32 },
  { 3384, 27, 31, 32, 2, -36 },
  { 3489, 26, 20, 32, 3, -30 },
  { 3554, 27, 31, 32, 3, -36 },
  { 3659, 25, 42, 25, 3, -41 },
  { 3791, 44, 46, 47, 2, -41 },
  { 4044, 35, 41, 36, -3, -41 },
  { 4224, 33, 41, 34, 0, -41 },
  { 4394, 32, 42, 33, 3, -41 },
  { 4562, 35, 41, 36, 0, -41 },
  { 4742, 31, 41, 29, 0, -41 },
  { 4901, 31, 41, 29, 0, -41 },
  { 5060, 34, 42, 37, 3, -41 },
  { 5239, 39, 41, 38, 0, -41 },
  { 5439, 29, 41, 23, -2, -41 },
  { 5588, 29, 54, 19, -9, -41 },
  { 5784, 40, 41, 35, 0, -41 },
  { 5989, 25, 41, 27, 0, -41 },
  { 6118, 49, 41, 48, 0, -41 },
  { 6370, 42, 41, 41, 0, -41 },
  { 6586, 35, 42, 39, 3, -41 },
  { 6770, 33, 41, 33, 0, -41 },
  { 6940, 35, 51, 39, 3, -41 },
  { 7164, 33, 41, 34, 0, -41 },
  { 7334, 30, 42, 29, 0, -41 },
  { 7492, 29, 41, 29, 4, -41 },
  { 7641, 35, 42, 37, 3, -41 },
  { 7825, 33, 41, 33, 5, -41 },
  { 7995, 49, 41, 49, 5, -41 },
  { 8247, 42, 41, 34, -3, -41 },
  { 8463, 32, 41, 32, 5, -41 },
  { 8627, 34, 41, 29, -2, -41 },
  { 8802, 25, 52, 19, -2, -42 },
  { 8965, 15, 42, 25, 6, -41 },
  { 9044, 25, 52, 19, -4, -42 },
  { 9207, 30, 27, 29, -1, -41 },
  { 9309, 26, 7, 24, -5, 4 },
  { 9332, 13, 9, 20, 8, -44 },
  { 9347, 30, 33, 32, 2, -32 },
  { 9471, 30, 44, 32, 0, -43 },
  { 9636, 26, 33, 27, 2, -32 },
  { 9744, 32, 44, 32, 2, -43 },
  { 9920, 28, 33, 31, 2, -32 },
  { 10036, 33, 58, 21, -6, -44 },
  { 10276, 32, 46, 32, 0, -32 },
  { 10460, 31, 43, 33, 0, -43 },
  { 10627, 19, 44, 17, 0, -44 },
  { 10732, 26, 58, 17, -7, -44 },
  { 10921, 36, 43, 32, 0, -43 },
  { 11115, 20, 43, 17, 0, -43 },
  { 11223, 47, 32, 49, 0, -32 },
  { 11411, 31, 32, 33, 0, -32 },
  { 11535, 28, 33, 32, 2, -32 },
  { 11651, 33, 46, 32, -3, -32 },
  { 11841, 30, 46, 32, 2, -32 },
  { 12014, 26, 32, 23, 0, -32 },
  { 12118, 25, 33, 26, 1, -32 },
  { 12222, 23, 39, 24, 2, -38 },
  { 12335, 31, 33, 33, 2, -32 },
  { 12463, 29, 32, 29, 3, -32 },
  { 12579, 44, 32, 44, 3, -32 },
  { 12755, 36, 32, 30, -3, -32 },
  { 12899, 36, 46, 29, -4, -32 },
  { 13106, 29, 32, 26, -2, -32 },
  { 13222, 24, 50, 20, 0, -41 },
  { 13372, 8, 56, 29, 10, -43 },
  { 13428, 23, 50, 20, -3, -41 },
  { 13572, 28, 11, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC57PT7B_H_
