#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x01, 0x8E, 0x38, 0xEF, 0xDB,
  0x76, 0xE0, 0x0E, 0xC1, 0xB0, 0x36, 0x3F, 0xF7, 0xFC, 0x36, 0x0E, 0xC7,
  0xFE, 0xFF, 0x86, 0xC1, 0x98, 0x36, 0x00, 0x02, 0x07, 0x8F, 0xE7, 0xF3,
  0x41, 0xE0, 0xF8, 0x1E, 0x0F, 0x25, 0xBF, 0xDF, 0xC1, 0x00, 0x80, 0x78,
  0x71, 0xF1, 0x8E, 0xCC, 0x33, 0x70, 0xDD, 0x83, 0xED, 0xEF, 0x7F, 0xC1,
  0xB7, 0x0C, 0xD8, 0x63, 0x63, 0x8F, 0x9C, 0x3C, 0x0F, 0x81, 0xF8, 0x39,
  0x83, 0xB8, 0x1F, 0x03, 0xEF, 0x7E, 0xEF, 0xFE, 0xE7, 0xCF, 0x78, 0xFF,
  0xC7, 0xFE, 0xFF, 0x60, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x18, 0x30, 0xE1,
  0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x00, 0x1C, 0x70, 0xC3, 0x0C, 0x30, 0xC7,
  0x1C, 0x63, 0x8E, 0x71, 0x8E, 0x00, 0x0C, 0x4C, 0x78, 0xFF, 0x3F, 0x7C,
  0x6C, 0x2E, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x7B, 0x99,
  0xC0, 0x7F, 0xFE, 0x7F, 0x80, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x3E, 0x7F, 0x77, 0xF7,
  0xE7, 0xE7, 0xE7, 0xEE, 0xEE, 0xFE, 0xFC, 0x78, 0x0F, 0x1E, 0x7E, 0xFE,
  0x6E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x1F, 0x3F, 0xCD, 0xE4,
  0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x7F, 0xBF, 0xDF, 0xC0, 0x3F, 0x1F,
  0xCC, 0xE0, 0x70, 0xF0, 0xF0, 0xFC, 0x0E, 0x07, 0x67, 0xBF, 0x9F, 0x80,
  0x03, 0x83, 0xC3, 0xE3, 0xE1, 0xF1, 0xB9, 0xDD, 0xFF, 0xFF, 0xFF, 0x83,
  0x81, 0xC0, 0x1F, 0x8F, 0xCE, 0x07, 0x03, 0xE3, 0xF8, 0xFC, 0x0E, 0x07,
  0x67, 0xBF, 0x9F, 0x80, 0x1F, 0x3F, 0x78, 0x70, 0xFE, 0xFE, 0xEF, 0xEF,
  0xEE, 0xEE, 0xFE, 0x7C, 0x3F, 0xCF, 0xF3, 0xF8, 0x1E, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0x1F, 0x1F, 0xCE, 0xE7, 0x73,
  0xF0, 0xF0, 0xFC, 0xEE, 0xE7, 0x73, 0x9F, 0xCF, 0xC0, 0x3E, 0x7E, 0xF7,
  0xE7, 0xE7, 0xFF, 0xFF, 0x7E, 0x0E, 0xBC, 0xF8, 0xF0, 0x11, 0xCE, 0x60,
  0x00, 0x0C, 0xE7, 0x00, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x71, 0xC6,
  0x38, 0x01, 0x07, 0x1F, 0x7C, 0xF0, 0xF0, 0x7E, 0x0F, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C, 0x0F, 0x1F, 0x7C, 0xF0,
  0xC0, 0x7D, 0xFD, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0x00, 0xC3, 0x87, 0x00,
  0x0F, 0xE1, 0xFF, 0x9C, 0x0C, 0xCF, 0xFC, 0xF9, 0xEE, 0xCF, 0x66, 0xFB,
  0x36, 0xDF, 0xF6, 0xFF, 0x30, 0x00, 0xE7, 0x03, 0xF8, 0x00, 0x03, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0xDC, 0x3B, 0x87, 0x71, 0xFE, 0x3F, 0xCF, 0xF9,
  0xC7, 0x70, 0xF0, 0x1F, 0x8F, 0xF3, 0x9C, 0xE7, 0x3B, 0x8F, 0xC7, 0xF9,
  0xCE, 0x73, 0x9D, 0xEF, 0xF3, 0xF8, 0x1F, 0x9F, 0xDE, 0x6E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7B, 0x3F, 0x8F, 0xC0, 0x1F, 0x8F, 0xF3, 0xBC,
  0xE7, 0x39, 0xCE, 0x77, 0x1D, 0xC7, 0x73, 0x9F, 0xEF, 0xF3, 0xF0, 0x1F,
  0x9F, 0xCE, 0x07, 0x03, 0xF1, 0xF9, 0xFC, 0xE0, 0x70, 0x3F, 0x3F, 0x9F,
  0xC0, 0x1F, 0x9F, 0xCE, 0x07, 0x03, 0x81, 0xF9, 0xFC, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x00, 0x1F, 0xCF, 0xF7, 0x89, 0xC0, 0xF0, 0x39, 0xEE, 0xFB,
  0x8E, 0xE3, 0xBD, 0xCF, 0xF1, 0xFC, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x8E,
  0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xF3, 0x8E, 0x38,
  0x1F, 0x8F, 0xC3, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x1F,
  0x9F, 0x80, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC7, 0xE3, 0xE1, 0xE0, 0x1C, 0xF3, 0x9E, 0x3B,
  0xC3, 0xB8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x78, 0xF3,
  0x8E, 0x38, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xFF, 0xFF,
  0xF0, 0x1E, 0x3E, 0x7C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0x6F, 0xC6, 0xDB,
  0x9D, 0xBE, 0x3B, 0xDC, 0x77, 0xB8, 0xCF, 0x73, 0x9C, 0xC7, 0x3B, 0x80,
  0x1C, 0x39, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0x67, 0x1B, 0xB1, 0xDF, 0x8E,
  0xFC, 0x73, 0xE3, 0x1F, 0x38, 0xF1, 0xC7, 0x80, 0x1F, 0x8F, 0xF7, 0xBD,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xBF, 0xEF, 0xF1, 0xF8, 0x1F,
  0x0F, 0xE3, 0xBC, 0xE7, 0x3B, 0xCF, 0xE7, 0xF9, 0xF8, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0x1F, 0x8F, 0xF7, 0xBD, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xE3, 0xBF, 0xEF, 0xF1, 0xF8, 0x0E, 0x03, 0xC0, 0x70, 0x1F, 0x8F, 0xE3,
  0xBC, 0xE7, 0x3B, 0xCF, 0xE7, 0xF1, 0xFC, 0x77, 0x1D, 0xCF, 0x3B, 0x8E,
  0x1F, 0x9F, 0xCE, 0x47, 0x03, 0x81, 0xF0, 0x78, 0x1E, 0x8F, 0x7F, 0x3F,
  0x9F, 0x80, 0x7F, 0xBF, 0xA7, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78,
  0x38, 0x1C, 0x0E, 0x00, 0x39, 0xDC, 0x77, 0x1D, 0xCF, 0x73, 0xBC, 0xEE,
  0x3B, 0x8E, 0xE7, 0x3F, 0xCF, 0xE1, 0xF0, 0xE1, 0xF8, 0xEE, 0x39, 0x9E,
  0x77, 0x1D, 0xC7, 0xE1, 0xB8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xE3, 0x8F,
  0xC7, 0x3F, 0x9E, 0x77, 0x3C, 0xEE, 0x7B, 0x9D, 0xF7, 0x3B, 0x6C, 0x7E,
  0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xE7, 0x87, 0x8E, 0x00, 0x1C, 0x78, 0xE7,
  0x07, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x81,
  0xDC, 0x1C, 0xF1, 0xE3, 0x80, 0xF3, 0xDC, 0xE7, 0x71, 0xDC, 0x7E, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x1F, 0xE3, 0xF8, 0x8F,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0xF1, 0xFE, 0x7F,
  0x80, 0x1F, 0x1E, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x78, 0xF8, 0xCE, 0xEE, 0xE6, 0x66, 0x77, 0x73, 0x1E, 0x3C,
  0x38, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x1E, 0x3C, 0x00,
  0x06, 0x07, 0x07, 0x83, 0xC3, 0x73, 0x99, 0x8D, 0xC7, 0x7F, 0xFF, 0xF7,
  0x30, 0x10, 0xBD, 0x9F, 0xDC, 0xEE, 0x77, 0x33, 0xB9, 0xDC, 0xFE, 0x7F,
  0x00, 0x1C, 0x1E, 0x0E, 0x07, 0x43, 0xF9, 0xFD, 0xEE, 0xE7, 0x73, 0xBB,
  0xDD, 0xDF, 0xEF, 0xE0, 0x08, 0x7D, 0xFF, 0x0E, 0x1C, 0x38, 0x76, 0xFC,
  0xF0, 0x03, 0x81, 0xC0, 0xE2, 0x77, 0xF3, 0xFB, 0x9D, 0xCE, 0xE6, 0x77,
  0x3B, 0x9F, 0xCF, 0xE0, 0x0C, 0x3E, 0x7F, 0xE7, 0xFE, 0xFE, 0xE0, 0xE4,
  0xFC, 0x7C, 0x03, 0xC1, 0xF0, 0x74, 0x1C, 0x1F, 0x87, 0xE0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x0B, 0x83, 0xE0, 0xF0, 0x00,
  0x08, 0x4F, 0x63, 0xF9, 0xCE, 0x73, 0x9C, 0xC7, 0x71, 0xDC, 0x7F, 0x1D,
  0xC0, 0xE2, 0x38, 0xFE, 0x3E, 0x00, 0x1C, 0x1E, 0x0E, 0x07, 0x63, 0xF9,
  0xFD, 0xEE, 0xE7, 0x73, 0xB9, 0xDD, 0xDC, 0xEE, 0x70, 0x1C, 0xF1, 0x80,
  0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0xE0, 0x07, 0x0F, 0x06, 0x00, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x13, 0xBC, 0x77, 0x1D, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC1, 0xDC, 0x73, 0x8E, 0x78, 0x1C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C,
  0x71, 0xC7, 0x38, 0xE0, 0x03, 0x10, 0xDF, 0xF3, 0xFF, 0xDE, 0xE7, 0x73,
  0x9D, 0xCE, 0xF7, 0x3B, 0x9D, 0xCE, 0xE7, 0x3B, 0x9C, 0xE0, 0x03, 0x1B,
  0xCF, 0xEF, 0x77, 0x3B, 0x9D, 0xCE, 0xEE, 0xE7, 0x73, 0x80, 0x08, 0x3E,
  0x7F, 0xE7, 0xE7, 0xE7, 0xEF, 0xEE, 0xFC, 0x78, 0x01, 0x06, 0xF1, 0xFC,
  0xF7, 0x39, 0xCE, 0x73, 0xBC, 0xEE, 0x7F, 0x9D, 0xC7, 0x01, 0xC0, 0x70,
  0x38, 0x00, 0x10, 0xBD, 0x9F, 0xDC, 0xEE, 0x77, 0x33, 0xB9, 0xDC, 0xFE,
  0x77, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x03, 0x36, 0x3E, 0x7E, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0x0C, 0x3F, 0x7E, 0x70, 0x7C, 0x3E, 0x1E, 0x8E,
  0xFC, 0xF8, 0x38, 0xCF, 0xFF, 0x73, 0x8E, 0x38, 0xEB, 0xEF, 0x80, 0x73,
  0xBB, 0xB9, 0xDC, 0xEE, 0x77, 0x73, 0xB9, 0xFC, 0xFE, 0x00, 0xE7, 0xF3,
  0xBB, 0x9D, 0xCF, 0xC7, 0xE1, 0xE0, 0xF0, 0x70, 0x00, 0xEF, 0x3F, 0x7B,
  0xBB, 0xDD, 0xF7, 0xCF, 0xBE, 0x7D, 0xE3, 0xCF, 0x1E, 0x70, 0xF7, 0x80,
  0x3D, 0xE3, 0xF8, 0x7E, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0xC3, 0xB8, 0xF3,
  0x80, 0x39, 0xE7, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x83, 0xE0, 0x7C, 0x0E, 0x00, 0x3F, 0x7F, 0x0E, 0x1C, 0x38,
  0x78, 0xF0, 0xFE, 0xFC, 0x0E, 0x3C, 0x70, 0xC3, 0x87, 0x3C, 0x70, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18,
  0x78, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x3E, 0x70, 0xC3, 0x8F, 0x1E, 0x30,
  0x00, 0x61, 0xFF, 0xFF, 0x86,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 12, 5, 0, -12 },
  { 10, 7, 4, 8, 2, -12 },
  { 14, 11, 12, 10, 0, -12 },
  { 31, 9, 14, 9, 0, -13 },
  { 47, 14, 12, 15, 1, -12 },
  { 68, 12, 12, 12, 0, -12 },
  { 86, 3, 4, 4, 2, -12 },
  { 88, 7, 15, 6, 0, -12 },
  { 102, 6, 15, 6, -1, -12 },
  { 114, 8, 8, 9, 1, -13 },
  { 122, 8, 8, 9, 1, -10 },
  { 130, 5, 4, 5, -1, -2 },
  { 133, 5, 3, 5, 0, -6 },
  { 135, 3, 3, 5, 0, -3 },
  { 137, 10, 12, 8, -1, -12 },
  { 152, 8, 12, 9, 1, -12 },
  { 164, 8, 12, 9, 1, -12 },
  { 176, 9, 12, 9, 0, -12 },
  { 190, 9, 12, 9, 0, -12 },
  { 204, 9, 12, 9, 0, -12 },
  { 218, 9, 12, 9, 0, -12 },
  { 232, 8, 12, 9, 1, -12 },
  { 244, 10, 12, 9, 0, -12 },
  { 259, 9, 12, 9, 0, -12 },
  { 273, 8, 12, 9, 1, -12 },
  { 285, 5, 10, 5, 0, -10 },
  { 292, 6, 12, 5, -1, -10 },
  { 301, 8, 9, 9, 1, -11 },
  { 310, 8, 6, 9, 1, -9 },
  { 316, 8, 9, 9, 1, -11 },
  { 325, 7, 12, 8, 1, -12 },
  { 336, 13, 13, 14, 1, -12 },
  { 358, 11, 12, 11, -1, -12 },
  { 375, 10, 12, 10, 0, -12 },
  { 390, 9, 12, 10, 1, -12 },
  { 404, 10, 12, 11, 0, -12 },
  { 419, 9, 12, 9, 0, -12 },
  { 433, 9, 12, 9, 0, -12 },
  { 447, 10, 12, 11, 1, -12 },
  { 462, 12, 12, 11, 0, -12 },
  { 480, 9, 12, 7, -1, -12 },
  { 494, 9, 16, 6, -3, -12 },
  { 512, 12, 12, 10, 0, -12 },
  { 530, 7, 12, 8, 0, -12 },
  { 541, 15, 12, 14, 0, -12 },
  { 564, 13, 12, 12, 0, -12 },
  { 584, 10, 12, 12, 1, -12 },
  { 599, 10, 12, 10, 0, -12 },
  { 614, 10, 15, 12, 1, -12 },
  { 633, 10, 12, 10, 0, -12 },
  { 648, 9, 12, 9, 0, -12 },
  { 662, 9, 12, 9, 1, -12 },
  { 676, 10, 12, 11, 1, -12 },
  { 691, 10, 12, 10, 1, -12 },
  { 706, 15, 12, 15, 1, -12 },
  { 729, 13, 12, 10, -1, -12 },
  { 749, 10, 12, 10, 1, -12 },
  { 764, 11, 12, 9, -1, -12 },
  { 781, 8, 15, 6, -1, -12 },
  { 796, 4, 12, 8, 2, -12 },
  { 802, 7, 15, 6, -1, -12 },
  { 816, 9, 8, 9, 0, -12 },
  { 825, 8, 2, 7, -2, 1 },
  { 827, 4, 3, 6, 2, -13 },
  { 829, 9, 10, 10, 1, -10 },
  { 841, 9, 13, 10, 0, -13 },
  { 856, 7, 10, 8, 1, -10 },
  { 865, 9, 13, 10, 1, -13 },
  { 880, 8, 10, 9, 1, -10 },
  { 890, 10, 17, 6, -2, -13 },
  { 912, 10, 14, 10, 0, -10 },
  { 930, 9, 13, 10, 0, -13 },
  { 945, 6, 13, 5, 0, -13 },
  { 955, 8, 17, 5, -2, -13 },
  { 972, 11, 13, 10, 0, -13 },
  { 990, 6, 13, 5, 0, -13 },
  { 1000, 14, 10, 14, 0, -10 },
  { 1018, 9, 10, 10, 0, -10 },
  { 1030, 8, 10, 10, 1, -10 },
  { 1040, 10, 14, 10, -1, -10 },
  { 1058, 9, 14, 10, 1, -10 },
  { 1074, 8, 10, 7, 0, -10 },
  { 1084, 8, 10, 8, 0, -10 },
  { 1094, 6, 11, 7, 1, -11 },
  { 1103, 9, 9, 10, 1, -9 },
  { 1114, 9, 9, 9, 1, -9 },
  { 1125, 13, 9, 13, 1, -9 },
  { 1140, 11, 9, 9, -1, -9 },
  { 1153, 11, 13, 9, -1, -9 },
  { 1171, 8, 9, 8, 0, -9 },
  { 1180, 7, 15, 6, 0, -12 },
  { 1194, 2, 17, 9, 3, -13 },
  { 1199, 7, 15, 6, -1, -12 },
  { 1213, 8, 4, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC17PT7B_H_
