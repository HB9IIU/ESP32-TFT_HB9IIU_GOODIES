#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F,
  0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0xC1, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE,
  0x78, 0x78, 0x07, 0xFC, 0xF8, 0x18, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFC,
  0xF0, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0x9F, 0xF0, 0x00, 0x07,
  0x9F, 0xF0, 0x40, 0x07, 0x9F, 0xF0, 0x70, 0x0F, 0x9F, 0xF0, 0x7E, 0x0F,
  0x3F, 0xF0, 0x7F, 0xEF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xFC, 0x7F, 0xBF, 0xE3, 0xFC,
  0x7F, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF8, 0x3F, 0xC7,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0xFF, 0x00, 0x1C,
  0x0F, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFE, 0xFE,
  0x03, 0x7F, 0xFF, 0xCF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x07, 0xE3, 0xFE, 0x00, 0x3C, 0x1F, 0xF0, 0x01, 0x81, 0xFC,
  0x00, 0x08, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x00, 0x02, 0x01, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC1,
  0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F,
  0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8,
  0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x0F,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0xFE, 0x3F, 0xF0, 0x3F, 0x1F,
  0xFC, 0x07, 0x87, 0xFF, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xE0,
  0x03, 0x80, 0x7F, 0xF0, 0x01, 0x80, 0x3F, 0xF8, 0x00, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x1F, 0xFC, 0x01, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x7F, 0xF9, 0xE0, 0x03, 0xFF, 0xE3,
  0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0x7F, 0xBF, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03,
  0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0xF0, 0x07, 0xF8, 0x7F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x02, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x80, 0x01, 0xFF, 0xE0, 0xE0, 0x03, 0xFF, 0xE0, 0xFF,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x3C, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x0E,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x7F, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xC7,
  0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03,
  0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x81, 0xFF,
  0xC7, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x07,
  0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF,
  0xDF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFF, 0x87, 0xFF, 0x9F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0xC0, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0x9F,
  0xF8, 0x01, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x0E,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xC3, 0xE0, 0x7F, 0xF0, 0xC0,
  0x1F, 0xFC, 0x20, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFF, 0xE3, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xC7, 0xF1, 0xFE, 0x07,
  0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x3F, 0xC1, 0xFF,
  0xFF, 0xE1, 0xFC, 0xFF, 0x0F, 0xFC, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xDF, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x3F,
  0xC1, 0xFD, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF7, 0xF0, 0xFF, 0x03, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0x0F, 0xE0, 0x7F, 0x83,
  0xFB, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0x07, 0xF0, 0x7F,
  0xBF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF3,
  0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0x8F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFC,
  0x3F, 0xFE, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE0, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x80, 0x70, 0x01, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFE, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFE, 0x3F,
  0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFE,
  0x00, 0x30, 0x1F, 0xFF, 0x00, 0x04, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x30, 0x0F,
  0xFF, 0x80, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF,
  0x8F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFE, 0x0F,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFF,
  0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFD,
  0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x07,
  0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF,
  0x0F, 0xF3, 0xFF, 0x00, 0x7F, 0xEF, 0xF1, 0xFF, 0x7F, 0xE0, 0x07, 0xFE,
  0xFF, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xF1, 0xFE, 0x7F, 0xE0, 0x0F,
  0xFC, 0xFF, 0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0xE0,
  0x0F, 0xFC, 0xFF, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xCF, 0xF7, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xE7, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0xE7, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE3, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF,
  0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF,
  0x8F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF,
  0x8F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7F,
  0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xF8,
  0x03, 0xFF, 0x80, 0x30, 0x07, 0xFF, 0x80, 0x10, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x60, 0x00, 0xFF, 0xE0, 0x78, 0x01, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xCF, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0xC7, 0xFB, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xBF, 0xC7, 0xFE, 0x00,
  0xFF, 0xCF, 0xFB, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0x3F, 0xCF, 0xFE,
  0x00, 0xFF, 0xDF, 0xF3, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFE, 0x3F, 0xCF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE3, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x3F,
  0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xC3, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFC,
  0x7F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x1F, 0xF9,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xF3,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x3F, 0xFC, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF,
  0x80, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xE1, 0xE0, 0xFF,
  0xF0, 0x04, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x20, 0xFF, 0xF0,
  0x1C, 0x1F, 0xFF, 0x1F, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFB, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0x07, 0xFF, 0x80, 0x38, 0x3F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF7, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x03,
  0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFF, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x20, 0x00, 0x7F, 0xF0, 0x0C, 0x00, 0x3F, 0xF8, 0x03,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F,
  0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xCF, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0xC7, 0xFF,
  0xE0, 0x3F, 0xEF, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE,
  0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F,
  0xF8, 0x3F, 0xFC, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x1F,
  0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xEF, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x8F,
  0xF0, 0x00, 0x7F, 0xF0, 0x60, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0x80, 0x0F, 0xF3, 0xFF, 0x80, 0x01, 0xC3, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFD, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x40, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFC, 0x3F, 0x07, 0xFF, 0x01, 0x81, 0xFF, 0xC0, 0x20, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x80, 0x0F, 0xFE, 0x3C, 0x07, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x00, 0x2D, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF9, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0xC0, 0x1F,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF,
  0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x3F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF,
  0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xE7, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x3F, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0x03,
  0xFE, 0x3F, 0xBF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F, 0x7F, 0x1F, 0xF8, 0x0F,
  0xF9, 0xFE, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFD, 0xFC, 0xFF, 0xC0, 0x3F,
  0xE7, 0xF3, 0xF9, 0xFF, 0x00, 0x7F, 0xDF, 0xE7, 0xF7, 0xFE, 0x00, 0xFF,
  0xBF, 0x9F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0x3F, 0xDF, 0xF0, 0x03, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xBF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x13, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x80, 0x01, 0xFF,
  0x88, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 20, 44, 17, 0, -43 },
  { 111, 25, 16, 27, 5, -43 },
  { 161, 38, 43, 36, 0, -43 },
  { 366, 32, 50, 32, 1, -46 },
  { 566, 48, 44, 53, 3, -43 },
  { 830, 41, 44, 41, 0, -43 },
  { 1056, 13, 16, 14, 5, -43 },
  { 1082, 24, 53, 20, 1, -44 },
  { 1241, 23, 53, 20, -4, -44 },
  { 1394, 28, 29, 30, 4, -46 },
  { 1496, 28, 29, 33, 3, -36 },
  { 1598, 15, 16, 17, -3, -8 },
  { 1628, 17, 9, 19, 1, -21 },
  { 1648, 12, 12, 17, 0, -11 },
  { 1666, 34, 44, 26, -3, -43 },
  { 1853, 30, 45, 32, 2, -44 },
  { 2022, 26, 43, 32, 5, -43 },
  { 2162, 33, 43, 32, -2, -43 },
  { 2340, 31, 44, 32, 0, -43 },
  { 2511, 32, 43, 32, 0, -43 },
  { 2683, 32, 44, 32, 1, -43 },
  { 2859, 31, 44, 32, 2, -43 },
  { 3030, 34, 43, 32, 1, -43 },
  { 3213, 31, 45, 32, 1, -44 },
  { 3388, 30, 44, 32, 2, -43 },
  { 3553, 17, 35, 18, 0, -34 },
  { 3628, 20, 42, 18, -3, -34 },
  { 3733, 28, 32, 33, 3, -38 },
  { 3845, 28, 22, 33, 3, -32 },
  { 3922, 28, 32, 33, 3, -38 },
  { 4034, 26, 44, 27, 3, -43 },
  { 4177, 46, 48, 50, 2, -43 },
  { 4453, 38, 43, 37, -4, -43 },
  { 4658, 35, 43, 35, 0, -43 },
  { 4847, 34, 45, 34, 3, -44 },
  { 5039, 37, 43, 38, 0, -43 },
  { 5238, 33, 43, 31, 0, -43 },
  { 5416, 33, 43, 31, 0, -43 },
  { 5594, 36, 45, 39, 3, -44 },
  { 5797, 41, 43, 40, 0, -43 },
  { 6018, 30, 43, 24, -2, -43 },
  { 6180, 31, 57, 20, -10, -43 },
  { 6401, 42, 43, 37, 0, -43 },
  { 6627, 26, 43, 29, 0, -43 },
  { 6767, 52, 43, 51, 0, -43 },
  { 7047, 44, 43, 43, 0, -43 },
  { 7284, 36, 45, 41, 3, -44 },
  { 7487, 35, 43, 34, 0, -43 },
  { 7676, 36, 54, 41, 3, -44 },
  { 7919, 35, 43, 36, 0, -43 },
  { 8108, 32, 44, 30, 0, -43 },
  { 8284, 29, 43, 30, 5, -43 },
  { 8440, 37, 44, 39, 3, -43 },
  { 8644, 35, 43, 35, 5, -43 },
  { 8833, 52, 43, 52, 5, -43 },
  { 9113, 45, 43, 36, -4, -43 },
  { 9355, 34, 43, 34, 5, -43 },
  { 9538, 37, 43, 30, -3, -43 },
  { 9737, 26, 54, 20, -2, -44 },
  { 9913, 16, 44, 26, 6, -43 },
  { 10001, 26, 54, 20, -4, -44 },
  { 10177, 31, 28, 31, -1, -43 },
  { 10286, 28, 7, 26, -6, 4 },
  { 10311, 14, 10, 21, 9, -46 },
  { 10329, 32, 35, 34, 2, -34 },
  { 10469, 32, 47, 34, 0, -46 },
  { 10657, 27, 35, 28, 2, -34 },
  { 10776, 34, 47, 34, 2, -46 },
  { 10976, 29, 35, 32, 2, -34 },
  { 11103, 35, 60, 22, -6, -46 },
  { 11366, 34, 48, 34, 0, -34 },
  { 11570, 32, 46, 34, 0, -46 },
  { 11754, 20, 47, 18, 0, -47 },
  { 11872, 28, 61, 18, -8, -47 },
  { 12086, 37, 46, 34, 0, -46 },
  { 12299, 21, 46, 18, 0, -46 },
  { 12420, 49, 34, 51, 0, -34 },
  { 12629, 32, 34, 34, 0, -34 },
  { 12765, 30, 35, 34, 2, -34 },
  { 12897, 35, 48, 34, -3, -34 },
  { 13107, 32, 48, 34, 2, -34 },
  { 13299, 27, 34, 24, 0, -34 },
  { 13414, 26, 35, 28, 1, -34 },
  { 13528, 24, 41, 25, 2, -40 },
  { 13651, 32, 34, 34, 2, -33 },
  { 13787, 31, 33, 31, 3, -33 },
  { 13915, 47, 33, 46, 3, -33 },
  { 14109, 38, 33, 32, -3, -33 },
  { 14266, 38, 47, 31, -4, -33 },
  { 14490, 31, 33, 27, -2, -33 },
  { 14618, 26, 52, 21, 0, -43 },
  { 14787, 8, 60, 30, 11, -46 },
  { 14847, 25, 52, 21, -4, -43 },
  { 15010, 28, 12, 33, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC60PT7B_H_
