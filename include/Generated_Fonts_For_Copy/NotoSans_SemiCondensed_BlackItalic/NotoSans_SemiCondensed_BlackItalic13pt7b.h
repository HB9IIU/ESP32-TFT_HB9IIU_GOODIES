#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x76, 0x66, 0x0E, 0xC0, 0x7F, 0x6D, 0x80, 0x1B, 0x16, 0x7F,
  0x7F, 0x34, 0xFE, 0xFE, 0x68, 0x58, 0x08, 0x7D, 0xFB, 0x47, 0x07, 0x87,
  0x6E, 0xFC, 0x60, 0x80, 0x71, 0xB4, 0xCF, 0x62, 0xD6, 0xEF, 0xC6, 0xF1,
  0x2C, 0xCB, 0x63, 0x80, 0x3E, 0x1B, 0x0D, 0x87, 0x87, 0xBF, 0xFB, 0x3D,
  0xFC, 0x7F, 0x00, 0x7B, 0x00, 0x18, 0xCC, 0xC6, 0x33, 0x18, 0xC6, 0x18,
  0xC0, 0x10, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x99, 0xC0, 0x32, 0xCF, 0xCF,
  0xF1, 0x60, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x76, 0x6C, 0xFF, 0xF8,
  0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x3C, 0x7D, 0x9B,
  0x36, 0xFD, 0xFB, 0x3E, 0x78, 0x1D, 0xEF, 0x9E, 0x38, 0xC3, 0x0C, 0x70,
  0x3C, 0xFC, 0xB8, 0x61, 0xC7, 0x1C, 0x7E, 0xFC, 0x7C, 0x7C, 0x39, 0xE3,
  0x81, 0x83, 0x7E, 0xF8, 0x0E, 0x3C, 0x71, 0xE6, 0xDF, 0xFF, 0x0C, 0x18,
  0x3E, 0x7C, 0xC3, 0xE7, 0xC1, 0x83, 0x7E, 0xF8, 0x1E, 0x7D, 0xC3, 0xE7,
  0xFD, 0xFB, 0x3E, 0x78, 0x7F, 0x7E, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70,
  0xE0, 0x3E, 0x6D, 0xD9, 0xE3, 0xCD, 0xB3, 0x7E, 0x78, 0x3C, 0xFD, 0x9B,
  0x77, 0xEF, 0x83, 0x7C, 0xF0, 0x77, 0x00, 0x0E, 0xC0, 0x39, 0xC0, 0x00,
  0x39, 0x8C, 0xC0, 0x0C, 0xFF, 0x30, 0x78, 0x70, 0x40, 0xFF, 0xF0, 0x3F,
  0xFC, 0x83, 0x87, 0x87, 0xFB, 0x08, 0x00, 0xFF, 0xC6, 0x76, 0x60, 0x18,
  0xC0, 0x1F, 0x86, 0x19, 0x9D, 0x37, 0xB5, 0xB5, 0xB4, 0xB7, 0xE2, 0x48,
  0x62, 0x07, 0xC0, 0x0F, 0x0F, 0x1F, 0x1B, 0x3B, 0x3F, 0x7F, 0x63, 0xE3,
  0x3E, 0x3F, 0x77, 0x7E, 0x7C, 0x6E, 0x6E, 0xFE, 0xFC, 0x3E, 0xFB, 0x86,
  0x0C, 0x18, 0x30, 0x7C, 0x78, 0x3E, 0x3F, 0x77, 0x73, 0x67, 0x67, 0x6E,
  0xFC, 0xF8, 0x3E, 0x7D, 0xC3, 0xE7, 0xCC, 0x18, 0x7E, 0xF8, 0x3E, 0x7D,
  0xC3, 0x87, 0xCF, 0x98, 0x70, 0xE0, 0x3E, 0xFF, 0x86, 0x0D, 0xF9, 0xF3,
  0x7E, 0x7C, 0x33, 0x99, 0x9C, 0xCF, 0xE7, 0xF3, 0x39, 0x99, 0xCC, 0xEE,
  0x00, 0x7C, 0xE3, 0x0C, 0x31, 0xC7, 0x3C, 0xF0, 0x0E, 0x18, 0x30, 0xE1,
  0xC3, 0x06, 0x0C, 0x38, 0x63, 0xC7, 0x00, 0x33, 0x9B, 0x9F, 0x8F, 0x87,
  0xC3, 0xE1, 0xB1, 0xDC, 0xEE, 0x00, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x3F,
  0xF8, 0x38, 0xE7, 0x3D, 0xE7, 0xBD, 0xE7, 0xBC, 0xFD, 0x9B, 0xB7, 0x6E,
  0xCD, 0x80, 0x39, 0xCE, 0x67, 0x99, 0xB6, 0x6F, 0x9B, 0xC6, 0xF3, 0x9C,
  0xC7, 0x00, 0x3E, 0x7E, 0xE7, 0xC7, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x3E,
  0x7D, 0xDB, 0xB7, 0xEF, 0x98, 0x70, 0xE0, 0x3E, 0x7E, 0xE7, 0xC7, 0xC6,
  0xC6, 0xCE, 0xFC, 0x78, 0x18, 0x1C, 0x3E, 0x3E, 0x77, 0x76, 0x7E, 0x7C,
  0x6C, 0xEE, 0xEE, 0x3E, 0xF9, 0xC3, 0x83, 0x83, 0xA7, 0x7E, 0xF8, 0xFF,
  0xF3, 0x1C, 0x71, 0x86, 0x18, 0xE0, 0x67, 0x66, 0xE6, 0xEE, 0xCE, 0xCC,
  0xCC, 0xFC, 0x78, 0xC7, 0xCE, 0xCC, 0xDC, 0xD8, 0xD8, 0xF0, 0xF0, 0x60,
  0xCE, 0x79, 0xDF, 0x3B, 0x6F, 0x6D, 0xF9, 0xEF, 0x3D, 0xE7, 0x38, 0xE7,
  0x00, 0x39, 0xC6, 0xE1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0x61, 0xDC, 0xE7,
  0x00, 0xEF, 0xD9, 0xF3, 0xC7, 0x0E, 0x1C, 0x30, 0x60, 0x3F, 0x3F, 0x0E,
  0x0C, 0x1C, 0x38, 0x70, 0x7E, 0xFE, 0x39, 0xCC, 0xC6, 0x31, 0x88, 0xC6,
  0x31, 0xC0, 0xC6, 0x66, 0x66, 0x62, 0x30, 0x1C, 0xF1, 0x86, 0x18, 0x61,
  0x0C, 0x30, 0xC3, 0x38, 0x18, 0x30, 0xF3, 0x66, 0xD8, 0xC0, 0xFC, 0xCC,
  0x3E, 0xFD, 0xBB, 0x7E, 0xDF, 0x9F, 0x00, 0x30, 0x60, 0xC3, 0xF7, 0xEC,
  0xDB, 0xB7, 0xFD, 0xF0, 0x3D, 0xF6, 0x38, 0xE1, 0xE7, 0x80, 0x07, 0x07,
  0x06, 0x3E, 0x7E, 0x6E, 0x6E, 0xEC, 0xFC, 0x7C, 0x3C, 0xFD, 0xBF, 0xEE,
  0x0F, 0x9F, 0x00, 0x0E, 0x3C, 0x61, 0xE3, 0xC7, 0x0C, 0x18, 0x30, 0xE1,
  0xC7, 0x0E, 0x00, 0x3E, 0xFD, 0xBB, 0x7E, 0xDF, 0x9F, 0x0E, 0xF9, 0xE0,
  0x30, 0x60, 0xC3, 0xF7, 0xEC, 0xDB, 0xB7, 0xED, 0x98, 0x33, 0x07, 0x76,
  0x66, 0xEC, 0x0C, 0x30, 0x07, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x3C, 0xE0,
  0x30, 0x30, 0x30, 0x77, 0x7E, 0x7C, 0x78, 0x7C, 0xEC, 0xCE, 0x33, 0x37,
  0x76, 0x66, 0xEC, 0x6F, 0xCF, 0xFD, 0x9B, 0xB7, 0x66, 0xCD, 0xD9, 0xB3,
  0x70, 0x6E, 0xFD, 0x9B, 0x76, 0xFD, 0xB3, 0x00, 0x3C, 0xFD, 0x9F, 0x7E,
  0xCF, 0x9E, 0x00, 0x37, 0x3F, 0x33, 0x37, 0x37, 0x7E, 0x6C, 0x60, 0x60,
  0xE0, 0x3E, 0xFD, 0xBB, 0x7E, 0xDF, 0x9F, 0x0E, 0x18, 0x30, 0x6D, 0xE7,
  0x18, 0x63, 0x8C, 0x00, 0x7D, 0xA7, 0x1E, 0x1B, 0xEF, 0x00, 0x10, 0xC7,
  0xFE, 0x61, 0x86, 0x1C, 0x70, 0x76, 0xCD, 0x9B, 0x76, 0xDF, 0x9F, 0x00,
  0xCF, 0x7D, 0xBC, 0xF3, 0x8E, 0x00, 0xDD, 0xF7, 0x6F, 0xFB, 0xFC, 0xEF,
  0x3B, 0x8E, 0xE0, 0x3B, 0x9F, 0x07, 0x83, 0x83, 0xC3, 0xF3, 0xB8, 0x33,
  0x37, 0x36, 0x3E, 0x3C, 0x3C, 0x38, 0x38, 0xF0, 0xE0, 0x7D, 0xF3, 0x8C,
  0x63, 0xEF, 0x80, 0x1C, 0xE3, 0x0C, 0xF3, 0x06, 0x18, 0x61, 0x86, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xE1, 0x8E, 0x1C, 0x63, 0x0C, 0x63, 0x8E,
  0x00, 0xE7, 0xF9, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 6, 3, 6, 1, -9 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 7, 11, 7, 0, -10 },
  { 28, 10, 9, 11, 1, -9 },
  { 40, 9, 9, 9, 0, -9 },
  { 51, 3, 3, 3, 1, -9 },
  { 53, 5, 12, 4, 0, -10 },
  { 61, 5, 12, 4, -1, -10 },
  { 69, 6, 6, 7, 1, -10 },
  { 74, 6, 7, 7, 1, -8 },
  { 80, 4, 4, 4, -1, -2 },
  { 82, 4, 2, 4, 0, -4 },
  { 83, 3, 2, 4, 0, -2 },
  { 84, 8, 9, 6, -1, -9 },
  { 93, 7, 9, 7, 0, -9 },
  { 101, 6, 9, 7, 1, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 7, 9, 7, 0, -9 },
  { 124, 7, 9, 7, 0, -9 },
  { 132, 7, 9, 7, 0, -9 },
  { 140, 7, 9, 7, 0, -9 },
  { 148, 8, 9, 7, 0, -9 },
  { 157, 7, 9, 7, 0, -9 },
  { 165, 7, 9, 7, 0, -9 },
  { 173, 4, 7, 4, 0, -7 },
  { 177, 5, 9, 4, -1, -7 },
  { 183, 6, 7, 7, 1, -8 },
  { 189, 6, 5, 7, 1, -7 },
  { 193, 6, 7, 7, 1, -8 },
  { 199, 5, 9, 6, 1, -9 },
  { 205, 11, 10, 11, 0, -9 },
  { 219, 8, 9, 8, -1, -9 },
  { 228, 8, 9, 8, 0, -9 },
  { 237, 7, 9, 7, 1, -9 },
  { 245, 8, 9, 8, 0, -9 },
  { 254, 7, 9, 7, 0, -9 },
  { 262, 7, 9, 7, 0, -9 },
  { 270, 7, 9, 8, 1, -9 },
  { 278, 9, 9, 9, 0, -9 },
  { 289, 6, 9, 5, 0, -9 },
  { 296, 7, 12, 4, -2, -9 },
  { 307, 9, 9, 8, 0, -9 },
  { 318, 6, 9, 6, 0, -9 },
  { 325, 11, 9, 11, 0, -9 },
  { 338, 10, 9, 9, 0, -9 },
  { 350, 8, 9, 9, 1, -9 },
  { 359, 7, 9, 7, 0, -9 },
  { 367, 8, 11, 9, 1, -9 },
  { 378, 8, 9, 8, 0, -9 },
  { 387, 7, 9, 7, 0, -9 },
  { 395, 6, 9, 7, 1, -9 },
  { 402, 8, 9, 8, 1, -9 },
  { 411, 8, 9, 8, 1, -9 },
  { 420, 11, 9, 11, 1, -9 },
  { 433, 10, 9, 8, -1, -9 },
  { 445, 7, 9, 7, 1, -9 },
  { 453, 8, 9, 7, -1, -9 },
  { 462, 5, 12, 4, 0, -10 },
  { 470, 4, 9, 6, 1, -9 },
  { 475, 6, 12, 4, -1, -10 },
  { 484, 7, 6, 7, 0, -9 },
  { 490, 6, 1, 6, -1, 1 },
  { 491, 3, 2, 4, 2, -10 },
  { 492, 7, 7, 7, 0, -7 },
  { 499, 7, 10, 7, 0, -10 },
  { 508, 6, 7, 6, 0, -7 },
  { 514, 8, 10, 7, 0, -10 },
  { 524, 7, 7, 7, 0, -7 },
  { 531, 7, 13, 5, -1, -10 },
  { 543, 7, 10, 7, 0, -7 },
  { 552, 7, 10, 7, 0, -10 },
  { 561, 4, 10, 4, 0, -10 },
  { 566, 6, 13, 4, -2, -10 },
  { 576, 8, 10, 7, 0, -10 },
  { 586, 4, 10, 4, 0, -10 },
  { 591, 11, 7, 11, 0, -7 },
  { 601, 7, 7, 7, 0, -7 },
  { 608, 7, 7, 7, 0, -7 },
  { 615, 8, 10, 7, -1, -7 },
  { 625, 7, 10, 7, 0, -7 },
  { 634, 6, 7, 5, 0, -7 },
  { 640, 6, 7, 6, 0, -7 },
  { 646, 6, 9, 5, 0, -9 },
  { 653, 7, 7, 7, 0, -7 },
  { 660, 6, 7, 7, 1, -7 },
  { 666, 10, 7, 10, 1, -7 },
  { 675, 9, 7, 7, -1, -7 },
  { 683, 8, 10, 7, -1, -7 },
  { 693, 6, 7, 6, 0, -7 },
  { 699, 6, 11, 5, 0, -9 },
  { 708, 2, 13, 7, 2, -10 },
  { 712, 6, 11, 5, -1, -9 },
  { 721, 6, 3, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC13PT7B_H_
