#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x9C, 0xE6, 0x30, 0x00, 0xE7, 0x00, 0x6D, 0xBD, 0xB6, 0x1B,
  0x0D, 0x86, 0x8F, 0xF3, 0x61, 0xB3, 0xFC, 0xD8, 0x6C, 0x3C, 0x00, 0x04,
  0x1E, 0x3F, 0x7A, 0x78, 0x3C, 0x1E, 0x16, 0xDE, 0xFC, 0x30, 0x20, 0x71,
  0xDF, 0x33, 0x6C, 0x6F, 0x0F, 0x7F, 0xDB, 0xC6, 0xD8, 0xDB, 0x33, 0xCC,
  0x38, 0x1E, 0x0F, 0xC3, 0x70, 0xF8, 0x3D, 0xDF, 0x6E, 0xFB, 0xBC, 0xFF,
  0x1F, 0xE0, 0x6F, 0x60, 0x1C, 0xE3, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x86,
  0x18, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x99, 0xC0, 0x12, 0x6F, 0x7F,
  0x7B, 0xE5, 0x80, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x76, 0x6C, 0x7F, 0xFC,
  0x03, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0x1E, 0x7D,
  0xDB, 0xB6, 0x6C, 0xFB, 0xF7, 0x7C, 0xF0, 0x1C, 0xF7, 0xF6, 0x18, 0xE3,
  0x8E, 0x31, 0xC0, 0x3E, 0xFC, 0x98, 0x70, 0xE3, 0x8E, 0x38, 0xFD, 0xF8,
  0x7E, 0x7C, 0x98, 0x73, 0xC7, 0x83, 0xC7, 0xFD, 0xF0, 0x07, 0x0E, 0x1E,
  0x3E, 0x3E, 0x6C, 0xFE, 0xFE, 0x1C, 0x1C, 0x3F, 0x3E, 0x30, 0x78, 0x7C,
  0x3E, 0x0E, 0x8E, 0xFC, 0xF8, 0x1F, 0x3F, 0x30, 0x7C, 0x7E, 0x7E, 0xEE,
  0x6E, 0x7C, 0x3C, 0x3F, 0x7F, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70,
  0xE0, 0x1E, 0x3E, 0x77, 0x36, 0x3C, 0x7C, 0x6E, 0xEE, 0xFC, 0x7C, 0x7B,
  0xFE, 0xF3, 0xFF, 0xF7, 0xC6, 0xF3, 0x80, 0x37, 0x20, 0x00, 0xEE, 0x19,
  0xC4, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04, 0x33, 0xF8, 0xE1, 0xF0, 0xC1,
  0xFC, 0x00, 0x3F, 0xFC, 0x83, 0x0F, 0x0F, 0x3F, 0xCC, 0x20, 0x7B, 0xF9,
  0xC6, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x0F, 0x83, 0x1C, 0xC9, 0xB7, 0xD6,
  0x92, 0xB6, 0xF6, 0xDE, 0xFE, 0x69, 0x0E, 0x20, 0xFC, 0x00, 0x07, 0x07,
  0x83, 0xC3, 0xE1, 0xB9, 0xDC, 0xFE, 0xFF, 0x73, 0xF1, 0xC0, 0x3E, 0x3F,
  0x33, 0x77, 0x7E, 0x7E, 0x66, 0x66, 0xFE, 0xFC, 0x3F, 0x7E, 0x72, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC4, 0xFC, 0x7C, 0x3E, 0x1F, 0x8C, 0xCE, 0x77, 0x3B,
  0x99, 0x9C, 0xCE, 0xFE, 0x7C, 0x00, 0x3F, 0x3E, 0x30, 0x70, 0x7E, 0x7C,
  0x60, 0x60, 0xFC, 0xFC, 0x3F, 0x3E, 0x30, 0x70, 0x7E, 0x7C, 0x60, 0x60,
  0xE0, 0xE0, 0x1F, 0x7F, 0x72, 0xE0, 0xEF, 0xDE, 0xC6, 0xEE, 0xFE, 0x7C,
  0x39, 0x98, 0xCC, 0xEE, 0x77, 0xFB, 0xF9, 0x8C, 0xCE, 0xE7, 0x73, 0x00,
  0x3F, 0x3E, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x7C, 0xFC, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE7, 0x8E, 0x00, 0x3B, 0xCC,
  0xE3, 0x71, 0xF8, 0x7C, 0x1F, 0x06, 0xE1, 0xB8, 0xE6, 0x39, 0xC0, 0x38,
  0xC3, 0x1C, 0x71, 0xC6, 0x18, 0xFF, 0xF0, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7,
  0xDE, 0x7D, 0xE6, 0xF6, 0x6F, 0xE6, 0xEE, 0xEE, 0xCE, 0xCC, 0x38, 0xCF,
  0x33, 0xCD, 0xF7, 0x7D, 0x9B, 0xE6, 0xF9, 0x9E, 0xE7, 0xB9, 0xC0, 0x3E,
  0x7F, 0x77, 0xE3, 0xE3, 0xC7, 0xC7, 0xCE, 0xFE, 0x78, 0x3E, 0x3F, 0x37,
  0x77, 0x7F, 0x7E, 0x78, 0x60, 0xE0, 0xE0, 0x3E, 0x7F, 0x77, 0xE3, 0xE3,
  0xC7, 0xC7, 0xCE, 0xFE, 0x78, 0x1C, 0x1E, 0x3E, 0x3F, 0x37, 0x77, 0x7F,
  0x7E, 0x6C, 0x6E, 0xEE, 0xE7, 0x1E, 0x7D, 0xCB, 0x83, 0x87, 0x87, 0x46,
  0xFD, 0xF0, 0xFF, 0xFC, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC0, 0x73,
  0x67, 0x67, 0xE7, 0xE6, 0xE6, 0xCE, 0xCE, 0xFC, 0x78, 0xE7, 0xE7, 0xEE,
  0xEE, 0xEC, 0xFC, 0xF8, 0x78, 0x70, 0x70, 0xE6, 0x3E, 0x67, 0xCE, 0x6C,
  0xEE, 0xDE, 0xCD, 0xEC, 0xF7, 0xCF, 0x78, 0xF7, 0x8E, 0x70, 0x39, 0xC6,
  0x61, 0xF8, 0x7C, 0x0E, 0x07, 0x81, 0xF0, 0xFC, 0x77, 0x38, 0xE0, 0xE7,
  0x6E, 0x6C, 0x7C, 0x78, 0x78, 0x70, 0x70, 0x70, 0x60, 0x1F, 0x9F, 0xC1,
  0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x7E, 0x7F, 0x00, 0x3C, 0xC3, 0x1C,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x38, 0xE6, 0x66, 0x66, 0x73, 0x33, 0x1C,
  0xB1, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x3C, 0x08, 0x38, 0x71, 0xE6,
  0x6C, 0xF1, 0x80, 0xFF, 0xF0, 0xEC, 0x80, 0x3B, 0x3F, 0x76, 0x66, 0x66,
  0xEE, 0x7E, 0x7C, 0x38, 0x70, 0xC1, 0xF7, 0xEE, 0xD9, 0xB3, 0x6F, 0xFB,
  0x70, 0x1E, 0x79, 0xD3, 0x06, 0x1C, 0x9F, 0x3E, 0x03, 0x03, 0x03, 0x3F,
  0x3F, 0x76, 0x66, 0x66, 0xEE, 0x7E, 0x7C, 0x1C, 0x7D, 0xDB, 0xFF, 0xDC,
  0x1F, 0x3E, 0x07, 0x0E, 0x1C, 0x1E, 0x3E, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0xE0, 0xE0, 0x1B, 0x3F, 0x76, 0x66, 0x66, 0xEE, 0x7E, 0x7C,
  0x0C, 0xFC, 0xF8, 0x38, 0x38, 0x30, 0x3E, 0x7E, 0x77, 0x76, 0x66, 0x6E,
  0xEE, 0xEE, 0x39, 0xC4, 0x67, 0x39, 0x8C, 0x67, 0x38, 0x0E, 0x1C, 0x10,
  0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x8F, 0x1E, 0x00, 0x38, 0x1C,
  0x0C, 0x06, 0x77, 0x73, 0xF1, 0xF0, 0xF8, 0x6C, 0x77, 0x3B, 0x80, 0x39,
  0xCC, 0x67, 0x39, 0x8C, 0x67, 0x38, 0x3E, 0xEF, 0xFD, 0xDD, 0xBB, 0x36,
  0x66, 0xDD, 0xFB, 0xBF, 0x76, 0x3E, 0x7E, 0x77, 0x76, 0x66, 0x6E, 0xEE,
  0xEE, 0x1C, 0x7D, 0xDB, 0x36, 0x7D, 0xDF, 0x3C, 0x1F, 0x3F, 0x3B, 0x33,
  0x33, 0x37, 0x7F, 0x7E, 0x60, 0x60, 0xE0, 0x1B, 0x3F, 0x76, 0x66, 0x66,
  0xEE, 0x7E, 0x7C, 0x0C, 0x1C, 0x1C, 0x3D, 0xF7, 0xDC, 0x61, 0x8E, 0x38,
  0x3D, 0xF6, 0x5E, 0x38, 0x7F, 0xBE, 0x18, 0xF7, 0xFC, 0x71, 0x86, 0x1E,
  0x78, 0x6F, 0xDF, 0xBE, 0x6C, 0xDB, 0xBF, 0x7C, 0xCF, 0x9B, 0x76, 0xCF,
  0x9E, 0x3C, 0x70, 0xCC, 0xFB, 0x9B, 0x77, 0x6A, 0xCF, 0xF9, 0xFE, 0x3B,
  0xC7, 0x70, 0x3B, 0x9D, 0x87, 0xC3, 0xC1, 0xC1, 0xF1, 0xD9, 0xCE, 0x33,
  0x99, 0x8D, 0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x30, 0x38, 0x78, 0x38, 0x00,
  0x7E, 0xF8, 0x71, 0xC3, 0x0C, 0x3F, 0x7C, 0x1C, 0x73, 0x0C, 0x33, 0xCE,
  0x18, 0x61, 0x87, 0x1C, 0xFF, 0xFC, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xCC,
  0x31, 0xCE, 0x38, 0xF7, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 10, 4, 0, -10 },
  { 8, 6, 4, 6, 1, -10 },
  { 11, 9, 10, 8, 0, -10 },
  { 23, 8, 12, 8, 0, -11 },
  { 35, 11, 10, 12, 1, -10 },
  { 49, 10, 10, 10, 0, -10 },
  { 62, 3, 4, 3, 1, -10 },
  { 64, 6, 12, 5, 0, -10 },
  { 73, 5, 12, 5, -1, -10 },
  { 81, 6, 7, 7, 1, -11 },
  { 87, 6, 6, 8, 1, -8 },
  { 92, 4, 4, 4, -1, -2 },
  { 94, 4, 2, 5, 0, -5 },
  { 95, 3, 2, 4, 0, -2 },
  { 96, 8, 10, 6, -1, -10 },
  { 106, 7, 10, 8, 0, -10 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 7, 10, 8, 0, -10 },
  { 132, 7, 10, 8, 0, -10 },
  { 141, 8, 10, 8, 0, -10 },
  { 151, 8, 10, 8, 0, -10 },
  { 161, 8, 10, 8, 0, -10 },
  { 171, 8, 10, 8, 0, -10 },
  { 181, 8, 10, 8, 0, -10 },
  { 191, 6, 10, 8, 1, -10 },
  { 199, 4, 8, 4, 0, -8 },
  { 203, 5, 10, 4, -1, -8 },
  { 210, 6, 8, 8, 1, -9 },
  { 216, 6, 5, 8, 1, -7 },
  { 220, 6, 8, 8, 1, -9 },
  { 226, 6, 10, 6, 1, -10 },
  { 234, 11, 11, 12, 0, -10 },
  { 250, 9, 10, 9, -1, -10 },
  { 262, 8, 10, 8, 0, -10 },
  { 272, 8, 10, 8, 1, -10 },
  { 282, 9, 10, 9, 0, -10 },
  { 294, 8, 10, 7, 0, -10 },
  { 304, 8, 10, 7, 0, -10 },
  { 314, 8, 10, 9, 1, -10 },
  { 324, 9, 10, 9, 0, -10 },
  { 336, 8, 10, 6, -1, -10 },
  { 346, 7, 13, 5, -2, -10 },
  { 358, 10, 10, 9, 0, -10 },
  { 371, 6, 10, 7, 0, -10 },
  { 379, 12, 10, 12, 0, -10 },
  { 394, 10, 10, 10, 0, -10 },
  { 407, 8, 10, 9, 1, -10 },
  { 417, 8, 10, 8, 0, -10 },
  { 427, 8, 12, 9, 1, -10 },
  { 439, 8, 10, 8, 0, -10 },
  { 449, 7, 10, 7, 0, -10 },
  { 458, 7, 10, 7, 1, -10 },
  { 467, 8, 10, 9, 1, -10 },
  { 477, 8, 10, 8, 1, -10 },
  { 487, 12, 10, 12, 1, -10 },
  { 502, 10, 10, 8, -1, -10 },
  { 515, 8, 10, 8, 1, -10 },
  { 525, 9, 10, 7, -1, -10 },
  { 537, 6, 12, 5, 0, -10 },
  { 546, 4, 10, 6, 1, -10 },
  { 551, 6, 12, 5, -1, -10 },
  { 560, 7, 7, 7, 0, -10 },
  { 567, 6, 2, 6, -1, 1 },
  { 569, 3, 3, 5, 2, -11 },
  { 571, 8, 8, 8, 0, -8 },
  { 579, 7, 11, 8, 0, -11 },
  { 589, 7, 8, 7, 0, -8 },
  { 596, 8, 11, 8, 0, -11 },
  { 607, 7, 8, 8, 0, -8 },
  { 614, 8, 14, 5, -1, -11 },
  { 628, 8, 11, 8, 0, -8 },
  { 639, 8, 11, 8, 0, -11 },
  { 650, 5, 11, 4, 0, -11 },
  { 657, 7, 14, 4, -2, -11 },
  { 670, 9, 11, 8, 0, -11 },
  { 683, 5, 11, 4, 0, -11 },
  { 690, 11, 8, 12, 0, -8 },
  { 701, 8, 8, 8, 0, -8 },
  { 709, 7, 8, 8, 0, -8 },
  { 716, 8, 11, 8, -1, -8 },
  { 727, 8, 11, 8, 0, -8 },
  { 738, 6, 8, 6, 0, -8 },
  { 744, 6, 8, 6, 0, -8 },
  { 750, 6, 9, 6, 0, -9 },
  { 757, 7, 8, 8, 1, -8 },
  { 764, 7, 8, 7, 1, -8 },
  { 771, 11, 8, 11, 1, -8 },
  { 782, 9, 8, 7, -1, -8 },
  { 791, 9, 11, 7, -1, -8 },
  { 804, 7, 8, 6, 0, -8 },
  { 811, 6, 12, 5, 0, -10 },
  { 820, 1, 14, 7, 3, -11 },
  { 822, 6, 12, 5, -1, -10 },
  { 831, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC14PT7B_H_
