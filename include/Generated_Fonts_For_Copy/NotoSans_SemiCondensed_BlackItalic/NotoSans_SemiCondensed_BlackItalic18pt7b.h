#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x00, 0x06, 0x3C, 0xE0, 0xEF,
  0xDF, 0xB6, 0x6D, 0xC0, 0x06, 0xE1, 0x98, 0x33, 0x06, 0xE7, 0xFE, 0xFF,
  0xC6, 0xE7, 0xFE, 0xFF, 0xDF, 0xF8, 0xD8, 0x3B, 0x06, 0xE0, 0x02, 0x00,
  0x81, 0xFC, 0xFE, 0x3C, 0x8F, 0x03, 0xC0, 0x7C, 0x0F, 0x82, 0xE4, 0xB9,
  0xFC, 0xFE, 0x06, 0x01, 0x00, 0x38, 0x39, 0xF1, 0xC6, 0xC6, 0x3B, 0x30,
  0xCD, 0xC3, 0x76, 0xEF, 0xB7, 0xDD, 0xDB, 0x06, 0xEC, 0x33, 0xB1, 0xCC,
  0xC6, 0x3F, 0x30, 0x78, 0x0F, 0x81, 0xFC, 0x1D, 0xC3, 0x9C, 0x1F, 0x81,
  0xF0, 0x3E, 0x77, 0xFF, 0xF7, 0xEE, 0x7C, 0xF7, 0xCF, 0xFC, 0x7F, 0xE0,
  0xFF, 0xEC, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0x60, 0xC3, 0x87,
  0x06, 0x0C, 0x1C, 0x38, 0x1C, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x86, 0x1C,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0x0E, 0x06, 0x1B, 0x1F, 0xF7, 0xF9,
  0xED, 0xF8, 0xDC, 0x24, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x7B, 0x9D, 0xC0, 0x7F, 0xEF, 0x80, 0xEF, 0xE0, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x00, 0x1E, 0x1F, 0x9F, 0xCE, 0xFF, 0x7F, 0x3F, 0x9D, 0xCE,
  0xE7, 0x77, 0xBF, 0x9F, 0x87, 0x80, 0x07, 0x0F, 0x3F, 0xFE, 0x7E, 0x4E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x07, 0x87, 0xF1, 0xFC, 0x27,
  0x01, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xF9, 0xFE, 0xFF, 0x80,
  0x1F, 0x1F, 0xCF, 0xE0, 0x70, 0x38, 0xF8, 0x78, 0x7E, 0x07, 0x83, 0xFF,
  0xDF, 0xEF, 0xC0, 0x03, 0xC0, 0xE0, 0x78, 0x3E, 0x1F, 0x8F, 0xE3, 0x71,
  0x9C, 0xFF, 0xBF, 0xEF, 0xF8, 0x38, 0x0E, 0x00, 0x1F, 0xC7, 0xE1, 0xF8,
  0xE0, 0x38, 0x0F, 0xC7, 0xF0, 0x9E, 0x07, 0x81, 0xEF, 0xF3, 0xFC, 0xFC,
  0x00, 0x0F, 0x9F, 0xCF, 0xEE, 0x0F, 0x47, 0xFB, 0xFD, 0xCE, 0xE7, 0x73,
  0xBB, 0xDF, 0xC7, 0xC0, 0x3F, 0xE7, 0xF8, 0xFF, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x00, 0x0F, 0x07,
  0xE3, 0xFC, 0xE7, 0x3B, 0x8F, 0xC1, 0xF1, 0xFC, 0x73, 0xB8, 0xEF, 0x79,
  0xFC, 0x3E, 0x00, 0x1E, 0x7F, 0x7F, 0xF7, 0xE7, 0xE7, 0xFF, 0xFF, 0x77,
  0x0E, 0xBC, 0xFC, 0xF0, 0x39, 0xCE, 0x00, 0x00, 0x1C, 0xF7, 0x00, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x79, 0xC6, 0x38, 0x01, 0x07, 0x1F, 0x7C,
  0xE0, 0xF8, 0x3F, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0xF8, 0x3F, 0x07, 0x1F, 0xFC, 0xF0, 0xC0, 0x3C, 0xFE, 0x7F,
  0x47, 0x0E, 0x3E, 0x38, 0x70, 0x00, 0x00, 0x60, 0xF0, 0xE0, 0x07, 0xE0,
  0x7F, 0xC3, 0x83, 0x9C, 0xE6, 0x67, 0xDF, 0x33, 0x7D, 0xDD, 0xB6, 0x66,
  0xD9, 0x9B, 0x7F, 0xCC, 0xEE, 0x38, 0x00, 0x71, 0x80, 0xFE, 0x00, 0x40,
  0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0x70, 0xEE, 0x1D, 0xC7, 0x38, 0xE7,
  0x3F, 0xE7, 0xFD, 0xFF, 0xB8, 0x7F, 0x0E, 0x1F, 0x83, 0xF8, 0xFF, 0x9C,
  0xF3, 0x9C, 0x7F, 0x0F, 0xC3, 0xFC, 0x73, 0xCE, 0x79, 0xFE, 0x7F, 0xCF,
  0xE0, 0x0F, 0x8F, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xF1, 0xFC, 0x3E, 0x00, 0x1F, 0x03, 0xF8, 0xFF, 0x9C, 0xF3,
  0x8E, 0x71, 0xCE, 0x3B, 0xCF, 0x71, 0xCE, 0x79, 0xFE, 0x7F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF3, 0xF8, 0xE0, 0x38, 0x0F, 0xE3, 0xF1, 0xFC, 0x70, 0x1C,
  0x07, 0xF3, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0xE0, 0x38, 0x0F,
  0xC3, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0xFF, 0x3C, 0x27, 0x01, 0xEF, 0xB9, 0xF7, 0x3E, 0xEB, 0x9C, 0x73,
  0xFE, 0x3F, 0xC3, 0xF0, 0x1C, 0x71, 0xC7, 0x3C, 0xF3, 0x8E, 0x38, 0xE3,
  0xFE, 0x3F, 0xE7, 0xFE, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x3C, 0xF3, 0xC0,
  0x1F, 0x8F, 0xC3, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x0F, 0xCF, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF3, 0xF1, 0xF8, 0xF0, 0x00, 0x1C,
  0x78, 0xE7, 0x0F, 0x78, 0x77, 0x83, 0xB8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x77, 0x83, 0xBC, 0x1C, 0xE1, 0xE7, 0x8F, 0x3C, 0x00, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x7F, 0xFF, 0xFE, 0x1E, 0x1F,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x36, 0xFC,
  0x76, 0xDC, 0x77, 0xDC, 0x77, 0x9C, 0x77, 0xB8, 0xE7, 0xB8, 0xE7, 0x38,
  0x1E, 0x38, 0xF1, 0xCF, 0x8E, 0x7C, 0x73, 0xF7, 0x1F, 0xB8, 0xDD, 0xCE,
  0xFE, 0x73, 0xF3, 0x9F, 0x1C, 0xF9, 0xC7, 0xCE, 0x1E, 0x00, 0x0F, 0x87,
  0xF8, 0xFF, 0x3C, 0xF7, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x7B,
  0xFE, 0x3F, 0x83, 0xE0, 0x1F, 0x07, 0xF3, 0xFC, 0xE7, 0x39, 0xCE, 0x73,
  0xFD, 0xFE, 0x7E, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x87, 0xF8,
  0xFF, 0xBC, 0xF7, 0x1F, 0xE3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x7B, 0xFE,
  0x3F, 0x83, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x1F, 0x07, 0xF3, 0xFC, 0xE7,
  0x39, 0xCE, 0xF3, 0xF9, 0xFC, 0x77, 0x1D, 0xE7, 0x3B, 0xCE, 0xF3, 0xC0,
  0x0F, 0x8F, 0xF3, 0xF8, 0xE2, 0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x21,
  0xCF, 0xF3, 0xF8, 0xFC, 0x00, 0x7F, 0xBF, 0xFF, 0xE3, 0x81, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x38, 0xE7, 0x3D, 0xE7,
  0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9C, 0xE3, 0x9C, 0x73, 0xFE, 0x7F,
  0x87, 0xE0, 0xF1, 0xEE, 0x39, 0xCF, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF1, 0xC7, 0xF3, 0xCF,
  0xF3, 0xCE, 0xE3, 0xCE, 0xE7, 0xDC, 0xE7, 0xDC, 0xEF, 0xFC, 0x6D, 0xF8,
  0x7D, 0xF8, 0x7D, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x71, 0xE0, 0x1C, 0x78,
  0xF3, 0x83, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x81, 0xFE, 0x0E, 0x70, 0xF3, 0x8F, 0x1E, 0x00, 0xE3, 0xF9, 0xEE, 0x73,
  0xB8, 0xFE, 0x1F, 0x07, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xFE, 0x3F, 0xCF, 0xF8, 0x0F, 0x1F, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x78, 0xF8, 0xE7,
  0x39, 0xC6, 0x31, 0xCE, 0x73, 0x9C, 0x63, 0x80, 0x1F, 0x1E, 0x0E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0xF0, 0xF0,
  0x06, 0x07, 0x03, 0xC3, 0xE1, 0xB1, 0x99, 0xCE, 0xC7, 0xE1, 0x80, 0x7F,
  0xFF, 0x80, 0xEE, 0x70, 0x3B, 0xBF, 0xDF, 0xFC, 0xEE, 0x77, 0x3B, 0x9D,
  0xDE, 0xFE, 0x7F, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x3F, 0x8F, 0xE3,
  0xFD, 0xEF, 0x73, 0xDC, 0xE7, 0x39, 0xDE, 0xFF, 0x3B, 0x80, 0x3F, 0x7E,
  0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFC, 0x7C, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x3B, 0x9F, 0xE7, 0xFB, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xBC, 0xFE,
  0x3F, 0x80, 0x3E, 0x7F, 0x77, 0xE7, 0xFF, 0xFE, 0xE0, 0xE2, 0xFE, 0x7C,
  0x01, 0xE0, 0x78, 0x1F, 0x03, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x05, 0xC0, 0xF8, 0x1E,
  0x00, 0x1D, 0xCF, 0xF3, 0xFD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xDE, 0x7F,
  0x1F, 0xC0, 0x72, 0x3C, 0xFE, 0x3F, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x3F, 0x8F, 0xF3, 0xFD, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0xF7, 0xB9,
  0xC0, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0xF3, 0x80,
  0x07, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x9E, 0x77, 0x8E, 0xE3, 0xF8, 0x7E, 0x0F, 0xE1, 0xFC, 0x3B, 0x8F, 0x79,
  0xC7, 0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0xF3,
  0x80, 0x3F, 0xBC, 0x7F, 0xFC, 0xFF, 0xFB, 0xDE, 0xF7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0xF7, 0xBD, 0xCE, 0x70, 0x3F, 0x8F, 0xF3, 0xFD,
  0xEF, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0xF7, 0xB9, 0xC0, 0x3E, 0x3F, 0x9D,
  0xDC, 0xFE, 0x77, 0x3B, 0x9D, 0xDE, 0xFE, 0x3E, 0x00, 0x1F, 0xC3, 0xF8,
  0x7F, 0x9E, 0xF3, 0x9E, 0x73, 0x8E, 0x71, 0xDE, 0x7F, 0x8E, 0xE1, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x00, 0x3B, 0xBF, 0xDF, 0xFE, 0xEE, 0x77, 0x3B,
  0x9D, 0xDE, 0xFE, 0x7F, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x3B, 0x3F, 0x3F,
  0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0x3F, 0x3F, 0x72, 0x78, 0x7C,
  0x3E, 0x0E, 0xCE, 0xFE, 0xFC, 0x18, 0x71, 0xFF, 0xEF, 0xCE, 0x3C, 0x70,
  0xE1, 0xF3, 0xE7, 0xC0, 0x73, 0xB9, 0xDC, 0xFE, 0xFE, 0x77, 0x3B, 0x9D,
  0xDE, 0xFF, 0x7B, 0x00, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE7, 0xE1, 0xF0,
  0xF0, 0x78, 0x38, 0x00, 0xE7, 0xBF, 0x9E, 0xEE, 0xF3, 0xBB, 0xDC, 0xFF,
  0x73, 0xED, 0x8F, 0xBE, 0x3E, 0xF8, 0xF3, 0xC3, 0xCF, 0x00, 0x3C, 0xF1,
  0xDC, 0x1F, 0xC1, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xF8, 0x7B, 0x8F,
  0x38, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x76, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1C, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0xCF, 0xE3,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xFC, 0x7F, 0x3F, 0xC0, 0x07, 0x0E,
  0x1E, 0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x38, 0xF0,
  0xE1, 0xC3, 0x87, 0x07, 0x1E, 0x78, 0xE1, 0xC3, 0x1E, 0x3C, 0x70, 0xF1,
  0xFF, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 13, 5, 0, -13 },
  { 11, 7, 5, 8, 2, -13 },
  { 16, 11, 13, 11, 0, -13 },
  { 34, 10, 15, 10, 0, -14 },
  { 53, 14, 13, 16, 1, -13 },
  { 76, 12, 13, 12, 0, -13 },
  { 96, 3, 5, 4, 2, -13 },
  { 98, 7, 16, 6, 0, -13 },
  { 112, 7, 16, 6, -1, -13 },
  { 126, 9, 9, 9, 1, -14 },
  { 137, 8, 9, 10, 1, -11 },
  { 146, 5, 4, 5, -1, -2 },
  { 149, 6, 3, 6, 0, -6 },
  { 152, 4, 3, 5, 0, -3 },
  { 154, 10, 13, 8, -1, -13 },
  { 171, 9, 13, 10, 1, -13 },
  { 186, 8, 13, 10, 1, -13 },
  { 199, 10, 13, 10, -1, -13 },
  { 216, 9, 13, 10, 0, -13 },
  { 231, 10, 13, 10, 0, -13 },
  { 248, 10, 13, 10, 0, -13 },
  { 265, 9, 13, 10, 1, -13 },
  { 280, 11, 13, 10, 0, -13 },
  { 298, 10, 13, 10, 0, -13 },
  { 315, 8, 13, 10, 1, -13 },
  { 328, 5, 10, 5, 0, -10 },
  { 335, 6, 12, 5, -1, -10 },
  { 344, 8, 9, 10, 1, -11 },
  { 353, 8, 7, 10, 1, -10 },
  { 360, 8, 9, 10, 1, -11 },
  { 369, 8, 13, 8, 1, -13 },
  { 382, 14, 15, 15, 1, -13 },
  { 409, 11, 13, 11, -1, -13 },
  { 427, 11, 13, 11, 0, -13 },
  { 445, 10, 13, 10, 1, -13 },
  { 462, 11, 13, 11, 0, -13 },
  { 480, 10, 13, 9, 0, -13 },
  { 497, 10, 13, 9, 0, -13 },
  { 514, 11, 13, 12, 1, -13 },
  { 532, 12, 13, 12, 0, -13 },
  { 552, 9, 13, 7, -1, -13 },
  { 567, 9, 17, 6, -3, -13 },
  { 587, 13, 13, 11, 0, -13 },
  { 609, 8, 13, 9, 0, -13 },
  { 622, 16, 13, 15, 0, -13 },
  { 648, 13, 13, 13, 0, -13 },
  { 670, 11, 13, 12, 1, -13 },
  { 688, 10, 13, 10, 0, -13 },
  { 705, 11, 16, 12, 1, -13 },
  { 727, 10, 13, 11, 0, -13 },
  { 744, 10, 13, 9, 0, -13 },
  { 761, 9, 13, 9, 1, -13 },
  { 776, 11, 13, 12, 1, -13 },
  { 794, 11, 13, 10, 1, -13 },
  { 812, 16, 13, 16, 1, -13 },
  { 838, 13, 13, 11, -1, -13 },
  { 860, 10, 13, 10, 2, -13 },
  { 877, 11, 13, 9, -1, -13 },
  { 895, 8, 16, 6, -1, -13 },
  { 911, 5, 13, 8, 2, -13 },
  { 920, 8, 16, 6, -1, -13 },
  { 936, 9, 9, 9, 0, -13 },
  { 947, 9, 2, 8, -2, 1 },
  { 950, 4, 3, 6, 3, -14 },
  { 952, 9, 10, 10, 1, -10 },
  { 964, 10, 14, 10, 0, -14 },
  { 982, 8, 10, 8, 1, -10 },
  { 992, 10, 14, 10, 1, -14 },
  { 1010, 8, 10, 10, 1, -10 },
  { 1020, 11, 18, 7, -2, -14 },
  { 1045, 10, 14, 10, 0, -10 },
  { 1063, 10, 14, 10, 0, -14 },
  { 1081, 6, 14, 5, 0, -14 },
  { 1092, 8, 18, 5, -2, -14 },
  { 1110, 11, 14, 10, 0, -14 },
  { 1130, 6, 14, 5, 0, -14 },
  { 1141, 15, 10, 15, 0, -10 },
  { 1160, 10, 10, 10, 0, -10 },
  { 1173, 9, 10, 10, 1, -10 },
  { 1185, 11, 14, 10, -1, -10 },
  { 1205, 9, 14, 10, 1, -10 },
  { 1221, 8, 10, 7, 0, -10 },
  { 1231, 8, 10, 8, 0, -10 },
  { 1241, 7, 12, 7, 1, -12 },
  { 1252, 9, 10, 10, 1, -10 },
  { 1264, 9, 10, 9, 1, -10 },
  { 1276, 14, 10, 14, 1, -10 },
  { 1294, 12, 10, 9, -1, -10 },
  { 1309, 11, 14, 9, -1, -10 },
  { 1329, 10, 10, 8, -1, -10 },
  { 1342, 8, 16, 6, 0, -13 },
  { 1358, 3, 18, 9, 3, -14 },
  { 1365, 7, 16, 6, -1, -13 },
  { 1379, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC18PT7B_H_
