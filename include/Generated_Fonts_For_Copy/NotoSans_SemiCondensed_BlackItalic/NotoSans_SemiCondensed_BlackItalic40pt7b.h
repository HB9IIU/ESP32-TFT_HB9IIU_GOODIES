#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x3F, 0x7E, 0x7F, 0x7E, 0x7F, 0x7E, 0x7E, 0xFE, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xF8, 0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF0,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x07, 0xE3, 0xE0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xDC, 0x60, 0xFC, 0xC0, 0x07, 0xEE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xDF, 0x80, 0x0E,
  0xFC, 0x60, 0x77, 0xE3, 0xE3, 0xBF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xF8,
  0x03, 0xF0, 0x1F, 0xF8, 0x03, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x0F, 0xC0, 0x7E, 0x7C, 0x0F, 0x80, 0x7E, 0x7C, 0x1F, 0x00, 0x7C, 0x7C,
  0x3F, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x7C, 0x00, 0xFC, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0xF8, 0x30, 0xFC, 0xF9, 0xF1, 0xFC, 0xFF, 0xFB,
  0xF3, 0xFE, 0x7F, 0xF3, 0xE7, 0xFF, 0x7F, 0xE7, 0xCF, 0xFF, 0x3F, 0xCF,
  0xCF, 0x9F, 0x1F, 0x8F, 0x9F, 0x9F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3F,
  0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x3F, 0x00, 0xFC,
  0x3F, 0x3F, 0x00, 0xF8, 0x3F, 0x3E, 0x01, 0xF0, 0x3F, 0x7E, 0x03, 0xF0,
  0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x9F, 0xCF,
  0xF7, 0xF7, 0xF1, 0xFC, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0x8F, 0xF1, 0xFF,
  0xF1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xCF, 0xF8, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x60, 0xF8, 0x1E, 0x3C,
  0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xF7, 0xC1, 0xFD, 0xF0, 0x1E,
  0x7E, 0x03, 0x1F, 0xC0, 0x43, 0x80, 0x00, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC7, 0xF1, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7C, 0x3F, 0x00, 0x3F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xF3,
  0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F, 0x87, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFF, 0x3F, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x1F,
  0xBF, 0x87, 0x1F, 0xC1, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x7F, 0xC0,
  0xF0, 0xFF, 0x01, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x0E, 0x1F, 0xE0, 0x40, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x21, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x40, 0x0F, 0xF3, 0x00, 0x7F,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x00,
  0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0x3F, 0x80, 0xF8, 0xFE, 0x07, 0xE7,
  0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x08, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x40, 0x1F, 0xE3, 0x01,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE7, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xF0,
  0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFB, 0xFC, 0x7F, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xCF, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7, 0xF8,
  0x7F, 0x7F, 0x87, 0xF7, 0xF8, 0xFF, 0x7F, 0x8F, 0xF7, 0xF9, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFE, 0xFE, 0x0F, 0xCF, 0xC0,
  0x21, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0x7F, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xF0, 0xFE, 0x20, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x83, 0xFE,
  0x3E, 0x3E, 0x1F, 0xFE, 0x7C, 0xFC, 0x7F, 0xFC, 0xF9, 0xF1, 0xFF, 0xF9,
  0xF3, 0xE3, 0xE3, 0xE3, 0xEF, 0x8F, 0xC7, 0xC7, 0xDF, 0x1F, 0x0F, 0x8F,
  0xBE, 0x7E, 0x1F, 0x1F, 0x78, 0xF8, 0x7C, 0x3F, 0xF1, 0xF0, 0xF8, 0x7B,
  0xE3, 0xE1, 0xF1, 0xF7, 0xC7, 0xC7, 0xE7, 0xCF, 0x8F, 0xDF, 0xDF, 0x9F,
  0x1F, 0xFF, 0xFE, 0x3E, 0x1F, 0xEF, 0xF8, 0x3E, 0x3F, 0x9F, 0xE0, 0x7C,
  0x1C, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x01, 0xFE,
  0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F,
  0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x8F,
  0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0x0F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFE, 0x3E, 0x0F, 0xF0, 0x08, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x60, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFC, 0x7C, 0x1F, 0xF0, 0x08, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xFC, 0xFF,
  0x1F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE,
  0x3F, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF,
  0x07, 0xF0, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x08, 0x7F, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x3F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xEF, 0x87,
  0xDF, 0x80, 0xFD, 0xF1, 0xFF, 0xF0, 0x1F, 0xBE, 0x3E, 0xFE, 0x07, 0xF7,
  0xCF, 0xDF, 0xC0, 0xFE, 0xF9, 0xFB, 0xF0, 0x1F, 0xDF, 0x7E, 0xFE, 0x03,
  0xF3, 0xEF, 0xDF, 0xC0, 0x7E, 0x7D, 0xF3, 0xF8, 0x1F, 0xCF, 0xFE, 0x7F,
  0x03, 0xF9, 0xFF, 0x8F, 0xC0, 0x7F, 0x3F, 0xF3, 0xF8, 0x0F, 0xC7, 0xFC,
  0x7F, 0x03, 0xF8, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xF8, 0x0F, 0xE3,
  0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x8F, 0xE0, 0x3F, 0x0F, 0xE1, 0xFC, 0x0F,
  0xE1, 0xFC, 0x3F, 0x80, 0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x07, 0xE0,
  0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x1F,
  0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xE1, 0xFC, 0x07, 0xFF,
  0x87, 0xF0, 0x3F, 0xFE, 0x1F, 0xC0, 0xFD, 0xF8, 0x7E, 0x03, 0xF7, 0xF1,
  0xF8, 0x0F, 0xDF, 0xCF, 0xE0, 0x3F, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0xFE,
  0x07, 0xF3, 0xFB, 0xF0, 0x1F, 0xCF, 0xEF, 0xC0, 0x7E, 0x3F, 0xBF, 0x01,
  0xF8, 0x7F, 0xFC, 0x0F, 0xE1, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0x80, 0xFE,
  0x1F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x7F,
  0xC0, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF1, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F,
  0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF,
  0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF9, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFF,
  0x07, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF1, 0xFC, 0x0F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xC7, 0x81, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x20, 0x1F, 0xE1, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF,
  0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x7F, 0x03,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xF0, 0x7F, 0x3F,
  0x83, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xC3, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F,
  0x1F, 0xC3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0xFC,
  0x7F, 0x0F, 0xE7, 0xFF, 0x9F, 0xC1, 0xFC, 0xFF, 0xF3, 0xF8, 0x3F, 0x9F,
  0x7E, 0xFE, 0x07, 0xF7, 0xEF, 0xDF, 0xC0, 0xFE, 0xFD, 0xFB, 0xF0, 0x1F,
  0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x7E, 0xF8, 0xFB, 0xF0,
  0x0F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00,
  0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF3, 0xF8,
  0x3F, 0xC7, 0xF0, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF,
  0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC1,
  0xF8, 0x7E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0xFC, 0x01, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xFE, 0x7F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3E, 0x00, 0x40, 0x00,
  0x1F, 0xCF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFB, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xBF, 0xC7, 0xF8, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x3F, 0x9F,
  0xC1, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x3F,
  0x9F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xEF, 0xC0, 0x7E, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x20, 0x07, 0xF7, 0xE0, 0x7F, 0x7F,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFB, 0xFC, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE,
  0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0xFE, 0x3F, 0xCF, 0xF1,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xCF, 0xF0, 0x7E, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0x3F, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFE, 0x70, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x06, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x21, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFD,
  0xFE, 0x0F, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC,
  0x3F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x7F, 0x87, 0xF7, 0xF1,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x87, 0xF0, 0x30, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF1, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x02,
  0x7F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07,
  0xF3, 0xF0, 0x3F, 0xEF, 0xC1, 0xFF, 0xBF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0x7F, 0x87, 0xF8, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3,
  0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x82, 0x00, 0xFE, 0x0E, 0x07, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x20, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xF1, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8,
  0x7F, 0x80, 0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x02, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x87,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x1F,
  0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x80, 0x10, 0x03, 0xE3, 0xF8, 0x7F, 0x03, 0xF3, 0xFE, 0x7F, 0xC1, 0xFB,
  0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC7, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x80,
  0x1F, 0x1F, 0x80, 0xFD, 0xFF, 0x03, 0xF7, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0x7F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE1, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF7,
  0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE,
  0xFF, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0x1F, 0xC7, 0xF3, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x08, 0x40, 0x03, 0xE7, 0xF0, 0x0F, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xF7, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xCF, 0xC1, 0xFF, 0x7E, 0x1F, 0xFB, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xBF, 0xC7, 0xF8, 0xFE, 0x7F, 0x87, 0xF3, 0xFC, 0x3F,
  0x9F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xFC,
  0x3F, 0x9F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7E, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x81, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x7E, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x30, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x80, 0x7F, 0x3C, 0x3F, 0xCF, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x9F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFB, 0xF0, 0x3F, 0xCF,
  0xC0, 0x7E, 0x3E, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0x83, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0xFE, 0x0F, 0xC7,
  0xF0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F, 0xC3, 0xFB, 0xF8, 0x7F,
  0x87, 0xF7, 0xF1, 0xFF, 0x1F, 0xCF, 0xE3, 0xFE, 0x3F, 0x9F, 0xCF, 0xFC,
  0x7E, 0x3F, 0x9F, 0xF9, 0xFC, 0x7F, 0x3F, 0xF3, 0xF8, 0xFE, 0xFB, 0xEF,
  0xE1, 0xFD, 0xF7, 0xDF, 0xC3, 0xFB, 0xEF, 0xBF, 0x03, 0xFF, 0x9F, 0xFE,
  0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0x1F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0,
  0x0F, 0xF3, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F,
  0xC7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x4F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x1F, 0xF4,
  0x00, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 29, 12, 0, -29 },
  { 49, 16, 11, 18, 4, -29 },
  { 71, 25, 29, 24, 0, -29 },
  { 162, 21, 32, 22, 1, -30 },
  { 246, 32, 29, 35, 2, -29 },
  { 362, 27, 29, 27, 0, -29 },
  { 460, 8, 11, 10, 4, -29 },
  { 471, 16, 35, 14, 1, -29 },
  { 541, 16, 35, 14, -3, -29 },
  { 611, 18, 20, 20, 3, -31 },
  { 656, 19, 20, 22, 2, -24 },
  { 704, 10, 10, 12, -2, -5 },
  { 717, 12, 6, 13, 0, -14 },
  { 726, 8, 7, 12, 0, -7 },
  { 733, 23, 29, 18, -2, -29 },
  { 817, 20, 29, 22, 1, -29 },
  { 890, 17, 29, 22, 3, -29 },
  { 952, 22, 29, 22, -1, -29 },
  { 1032, 21, 29, 22, 0, -29 },
  { 1109, 22, 29, 22, 0, -29 },
  { 1189, 21, 29, 22, 1, -29 },
  { 1266, 21, 29, 22, 1, -29 },
  { 1343, 23, 29, 22, 1, -29 },
  { 1427, 20, 29, 22, 1, -29 },
  { 1500, 20, 29, 22, 1, -29 },
  { 1573, 12, 22, 12, 0, -22 },
  { 1606, 14, 27, 12, -2, -22 },
  { 1654, 19, 21, 22, 2, -25 },
  { 1704, 19, 14, 22, 2, -21 },
  { 1738, 19, 21, 22, 2, -25 },
  { 1788, 17, 29, 18, 2, -29 },
  { 1850, 31, 32, 33, 1, -29 },
  { 1974, 24, 29, 25, -2, -29 },
  { 2061, 23, 29, 24, 0, -29 },
  { 2145, 23, 29, 23, 2, -29 },
  { 2229, 25, 29, 25, 0, -29 },
  { 2320, 22, 29, 20, 0, -29 },
  { 2400, 22, 29, 20, 0, -29 },
  { 2480, 24, 29, 26, 2, -29 },
  { 2567, 27, 29, 26, 0, -29 },
  { 2665, 20, 29, 16, -1, -29 },
  { 2738, 20, 38, 13, -6, -29 },
  { 2833, 28, 29, 24, 0, -29 },
  { 2935, 17, 29, 19, 0, -29 },
  { 2997, 35, 29, 34, 0, -29 },
  { 3124, 30, 29, 29, 0, -29 },
  { 3233, 24, 29, 27, 2, -29 },
  { 3320, 23, 29, 23, 0, -29 },
  { 3404, 24, 36, 27, 2, -29 },
  { 3512, 23, 29, 24, 0, -29 },
  { 3596, 21, 29, 20, 0, -29 },
  { 3673, 20, 29, 20, 3, -29 },
  { 3746, 25, 29, 26, 2, -29 },
  { 3837, 23, 29, 23, 3, -29 },
  { 3921, 35, 29, 35, 3, -29 },
  { 4048, 29, 29, 24, -2, -29 },
  { 4154, 23, 29, 22, 3, -29 },
  { 4238, 25, 29, 20, -2, -29 },
  { 4329, 17, 36, 13, -1, -29 },
  { 4406, 11, 29, 18, 4, -29 },
  { 4446, 18, 36, 13, -3, -29 },
  { 4527, 20, 19, 20, 0, -29 },
  { 4575, 19, 4, 17, -4, 3 },
  { 4585, 9, 7, 14, 6, -31 },
  { 4593, 21, 23, 23, 1, -23 },
  { 4654, 21, 30, 23, 0, -30 },
  { 4733, 18, 23, 19, 1, -23 },
  { 4785, 23, 30, 22, 1, -30 },
  { 4872, 20, 23, 21, 1, -23 },
  { 4930, 23, 41, 15, -4, -31 },
  { 5048, 22, 33, 23, 0, -23 },
  { 5139, 22, 30, 23, 0, -30 },
  { 5222, 13, 31, 12, 0, -31 },
  { 5273, 19, 41, 12, -5, -31 },
  { 5371, 25, 30, 23, 0, -30 },
  { 5465, 14, 30, 12, 0, -30 },
  { 5518, 33, 23, 34, 0, -23 },
  { 5613, 22, 23, 23, 0, -23 },
  { 5677, 20, 23, 22, 1, -23 },
  { 5735, 23, 33, 23, -2, -23 },
  { 5830, 21, 33, 23, 1, -23 },
  { 5917, 18, 23, 16, 0, -23 },
  { 5969, 18, 23, 18, 0, -23 },
  { 6021, 16, 27, 17, 1, -27 },
  { 6075, 22, 22, 23, 1, -22 },
  { 6136, 21, 22, 20, 2, -22 },
  { 6194, 31, 22, 31, 2, -22 },
  { 6280, 25, 22, 21, -2, -22 },
  { 6349, 25, 32, 20, -2, -22 },
  { 6449, 20, 22, 18, -1, -22 },
  { 6504, 17, 35, 14, 0, -29 },
  { 6579, 6, 39, 20, 7, -30 },
  { 6609, 16, 35, 14, -2, -29 },
  { 6679, 19, 8, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC40PT7B_H_
