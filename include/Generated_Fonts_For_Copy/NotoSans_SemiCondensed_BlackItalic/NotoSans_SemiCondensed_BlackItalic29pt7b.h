#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x00, 0x7D, 0xFF, 0x9E, 0xF9, 0xEF, 0xBE, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCE, 0x3C, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x70, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC1, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF0, 0x79, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3,
  0x80, 0x79, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0xE0, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x8F, 0xF2, 0x1E, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x41, 0xBC, 0xE6, 0xF9,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1F, 0x00, 0xF0, 0x7F, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xDE, 0x1E,
  0x0F, 0x3C, 0x78, 0x1E, 0x78, 0xF0, 0x3C, 0xF3, 0xC0, 0x79, 0xCF, 0x00,
  0xE7, 0x9E, 0x71, 0xFF, 0x7B, 0xFB, 0xFD, 0xEF, 0xF7, 0xF3, 0xDF, 0xF3,
  0xCF, 0x79, 0xE0, 0x3C, 0xF3, 0xC0, 0x79, 0xE7, 0x81, 0xE3, 0xCF, 0x07,
  0x87, 0xBC, 0x0F, 0x0F, 0x78, 0x3C, 0x1F, 0xE0, 0xF0, 0x3F, 0xC3, 0xE0,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x9F, 0x1F, 0xE3, 0xE3, 0xFF, 0x3E, 0x7F, 0xFF, 0xC7, 0xDF,
  0xFC, 0xFC, 0xFF, 0x8F, 0x87, 0xF8, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0xEF, 0xBE, 0xF3, 0xCF,
  0x38, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x80, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x10, 0xF0, 0xE7, 0x07, 0xF8, 0xFF, 0xFD, 0xFF,
  0xE1, 0xFF, 0x1F, 0x81, 0xFE, 0x1F, 0x70, 0x73, 0xC1, 0x1E, 0x00, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F, 0xBF, 0xDF,
  0xDF, 0xE0, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x3F, 0x7C, 0xF9, 0xF7, 0xE7,
  0xDF, 0x1F, 0x7C, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3,
  0xEF, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F,
  0x80, 0x00, 0xF8, 0x0F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF,
  0x8F, 0x7C, 0x33, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x03, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x06, 0x1F,
  0x04, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF0, 0xE7, 0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7E,
  0xC1, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0xF8, 0x3C, 0xF8, 0x78, 0xF8,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0xC1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFE,
  0x07, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFC, 0x27, 0xE0, 0x0F, 0x80, 0x3E,
  0x70, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xF7, 0xEF, 0xCF, 0xDF, 0x1F,
  0xBE, 0x3F, 0x7C, 0x7C, 0xF9, 0xF8, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE3, 0xE7, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x81, 0xFF, 0x87, 0xFF, 0x9F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x7F, 0x7D, 0xF9, 0xF7, 0xC7,
  0xDF, 0x1F, 0x7C, 0x7D, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0x78, 0xFB,
  0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE,
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xFC, 0xFC, 0xFC, 0xF8, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF0, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xC0,
  0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0xFF, 0xF7, 0xFF,
  0x7B, 0xF4, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0,
  0x7E, 0x1F, 0x00, 0x7C, 0x78, 0x30, 0xF3, 0xC7, 0xF9, 0xDE, 0x3F, 0xE7,
  0x79, 0xF7, 0x9D, 0xCF, 0x1C, 0x7F, 0x3C, 0x71, 0xFC, 0xE3, 0xC7, 0xF7,
  0x8F, 0x3F, 0x9E, 0x3C, 0xEE, 0x79, 0xE7, 0xBC, 0xFF, 0xFC, 0xF3, 0xF7,
  0xE3, 0xC7, 0x8F, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDE,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0x81, 0xF7, 0xE0,
  0x7D, 0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFB, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xE7, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xF8, 0x10, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x18, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC,
  0x7D, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x04,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xE0, 0x43, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x1F, 0xE7, 0xCF,
  0xF3, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x07, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8,
  0x7E, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x07,
  0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xF8, 0x00,
  0x80, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0xFC,
  0x0F, 0x9F, 0x81, 0xFB, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x0B, 0xFF,
  0x9F, 0xFC, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x87,
  0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1E, 0xF3, 0xDE, 0x0F, 0x79,
  0xFF, 0x0F, 0xBD, 0xEF, 0x87, 0xDE, 0xF7, 0xC3, 0xEF, 0xF3, 0xE1, 0xF7,
  0xFB, 0xE0, 0xF3, 0xFD, 0xF0, 0xF9, 0xFC, 0xF8, 0x7C, 0xFE, 0x7C, 0x3E,
  0x7E, 0x3C, 0x1F, 0x3F, 0x3E, 0x0F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x80,
  0x07, 0xE0, 0x78, 0x7F, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0xC1, 0xF0, 0xFF,
  0x0F, 0x8F, 0xF8, 0x78, 0x7F, 0xC7, 0xC3, 0xFF, 0x3E, 0x1E, 0xF9, 0xF0,
  0xF7, 0xCF, 0x8F, 0xBE, 0x78, 0x7C, 0xFF, 0xC3, 0xE7, 0xFE, 0x1F, 0x3F,
  0xF0, 0xF1, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F,
  0x0F, 0xF0, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xCF, 0xC3, 0xF3, 0xF0, 0x7D,
  0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0x7E, 0x7F, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E,
  0x3F, 0x1F, 0x1F, 0x0F, 0xBF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1,
  0xFF, 0x80, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xDF, 0xCF, 0xC3, 0xF3, 0xF0, 0x7D, 0xF8, 0x1F, 0x7E,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x07,
  0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0x7E, 0x7F, 0x1F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFB, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0x3F, 0x0F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0,
  0xFC, 0xF8, 0x7E, 0x7C, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x87, 0xCF, 0xC3,
  0xF0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xE0,
  0x87, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x40, 0x7C, 0xF1, 0xF9, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xC7,
  0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0,
  0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0x7E, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xDF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x1E, 0x0F, 0xFE, 0x0F, 0x83,
  0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x7C, 0xF8, 0x7E, 0x1F, 0x3E, 0x1F,
  0x8F, 0xCF, 0x8F, 0xE3, 0xE3, 0xE3, 0xF8, 0xF8, 0xF9, 0xFE, 0x7C, 0x3E,
  0x7F, 0x9F, 0x0F, 0xBF, 0xEF, 0x83, 0xEF, 0x7B, 0xE0, 0xFB, 0xDE, 0xF8,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x3F, 0x00,
  0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x1F,
  0x9F, 0x00, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xC1,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x00, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xBC, 0x1E, 0x78, 0x3C,
  0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xDE, 0x03, 0xC0, 0x7F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x80, 0xFC, 0xF8, 0xF0, 0xF0, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7E, 0x3E, 0xF8, 0x79,
  0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0xFF, 0x9F, 0xFE, 0x1F, 0xBC, 0x1E,
  0x78, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xDF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0xFC, 0xF9, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0xBE, 0x3F, 0x7C, 0x7E, 0xFD, 0xF9, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x1E, 0x7C, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFC,
  0x7F, 0xE7, 0xE1, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F, 0xC7,
  0xC7, 0xE3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xEF, 0x01, 0xE7, 0x80, 0x07, 0xF0, 0x7F, 0xE3,
  0xFF, 0xCF, 0xFF, 0x7E, 0x7D, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3,
  0xFE, 0x0F, 0x80, 0x3E, 0x04, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0xBF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x00, 0x07, 0xCF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0xC3, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x01, 0x01, 0xF0, 0xFC,
  0x3F, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0x80, 0x00, 0x10, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x82, 0x7E, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0xFC, 0x7C, 0x7E,
  0x1F, 0x3F, 0x07, 0xDF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0xC1, 0xF3, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x00,
  0x1F, 0x7C, 0x7C, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x3E, 0x7C, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0x7C, 0xF8, 0xF8, 0xFC,
  0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x07, 0xF0, 0x7F, 0xE1,
  0xFF, 0xCF, 0xFF, 0x7E, 0x7D, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x8F, 0xBE, 0x7E, 0xFF, 0xF1, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0,
  0x0F, 0xBE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3F, 0x7E,
  0x3F, 0xFE, 0x3F, 0xFC, 0x7D, 0xF8, 0x7D, 0xF0, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x9E,
  0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7E,
  0x3E, 0xF8, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0xFF, 0x9F, 0xFE,
  0x1F, 0xFC, 0x1E, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x78, 0xF7, 0xC7, 0xBC, 0x3F,
  0xE1, 0xFF, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xF0, 0xFF, 0xCF,
  0xFC, 0x7E, 0xE3, 0xE1, 0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0x80, 0xFD, 0x07, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xFF, 0x7F, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x8F, 0xF8, 0xFF, 0x87,
  0xF8, 0x3F, 0x80, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8,
  0xF8, 0xFD, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7E, 0xF0, 0xFC,
  0x3F, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7D,
  0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0xF8, 0x7F, 0xE7, 0xE3,
  0xEF, 0x1F, 0x8F, 0xBC, 0x7E, 0x7C, 0xF3, 0xF9, 0xF3, 0xCE, 0xE7, 0x8F,
  0x7F, 0xBE, 0x3D, 0xFE, 0xF8, 0xF7, 0x7F, 0xC3, 0xFD, 0xFF, 0x0F, 0xF7,
  0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xEF,
  0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xFC,
  0x1F, 0x8F, 0x87, 0xF1, 0xF8, 0x1F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8,
  0x3E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x0B, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x7C,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFC, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x0E, 0x00,
  0x3E, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFA, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 21, 8, 0, -21 },
  { 28, 12, 8, 13, 3, -21 },
  { 40, 18, 21, 17, 0, -21 },
  { 88, 15, 24, 16, 1, -22 },
  { 133, 23, 21, 25, 2, -21 },
  { 194, 20, 21, 20, 0, -21 },
  { 247, 6, 8, 7, 3, -21 },
  { 253, 11, 26, 10, 1, -21 },
  { 289, 11, 26, 10, -2, -21 },
  { 325, 13, 14, 15, 2, -22 },
  { 348, 14, 14, 16, 1, -17 },
  { 373, 8, 8, 8, -2, -4 },
  { 381, 9, 4, 9, 0, -10 },
  { 386, 6, 5, 8, 0, -5 },
  { 390, 16, 21, 13, -1, -21 },
  { 432, 14, 21, 16, 1, -21 },
  { 469, 13, 21, 16, 2, -21 },
  { 504, 16, 21, 16, -1, -21 },
  { 546, 15, 21, 16, 0, -21 },
  { 586, 16, 21, 16, 0, -21 },
  { 628, 16, 21, 16, 0, -21 },
  { 670, 15, 21, 16, 1, -21 },
  { 710, 16, 21, 16, 1, -21 },
  { 752, 15, 21, 16, 1, -21 },
  { 792, 14, 21, 16, 1, -21 },
  { 829, 8, 16, 8, 0, -16 },
  { 845, 10, 20, 8, -2, -16 },
  { 870, 14, 15, 16, 1, -18 },
  { 897, 14, 10, 16, 1, -15 },
  { 915, 14, 15, 16, 1, -18 },
  { 942, 12, 21, 13, 2, -21 },
  { 974, 22, 23, 24, 1, -21 },
  { 1038, 18, 21, 18, -2, -21 },
  { 1086, 17, 21, 17, 0, -21 },
  { 1131, 17, 21, 17, 1, -21 },
  { 1176, 18, 21, 18, 0, -21 },
  { 1224, 16, 21, 15, 0, -21 },
  { 1266, 16, 21, 15, 0, -21 },
  { 1308, 18, 21, 19, 1, -21 },
  { 1356, 20, 21, 19, 0, -21 },
  { 1409, 15, 21, 12, -1, -21 },
  { 1449, 15, 28, 10, -5, -21 },
  { 1502, 20, 21, 18, 0, -21 },
  { 1555, 13, 21, 14, 0, -21 },
  { 1590, 25, 21, 25, 0, -21 },
  { 1656, 21, 21, 21, 0, -21 },
  { 1712, 18, 21, 20, 1, -21 },
  { 1760, 17, 21, 17, 0, -21 },
  { 1805, 18, 26, 20, 1, -21 },
  { 1864, 17, 21, 17, 0, -21 },
  { 1909, 15, 21, 15, 0, -21 },
  { 1949, 15, 21, 15, 2, -21 },
  { 1989, 18, 21, 19, 1, -21 },
  { 2037, 17, 21, 17, 2, -21 },
  { 2082, 26, 21, 25, 2, -21 },
  { 2151, 22, 21, 17, -2, -21 },
  { 2209, 17, 21, 16, 2, -21 },
  { 2254, 17, 21, 15, -1, -21 },
  { 2299, 13, 26, 10, -1, -21 },
  { 2342, 8, 21, 13, 3, -21 },
  { 2363, 13, 26, 10, -2, -21 },
  { 2406, 15, 14, 15, 0, -21 },
  { 2433, 14, 3, 12, -3, 2 },
  { 2439, 7, 4, 10, 4, -22 },
  { 2443, 15, 16, 16, 1, -16 },
  { 2473, 15, 22, 16, 0, -22 },
  { 2515, 13, 16, 13, 1, -16 },
  { 2541, 17, 22, 16, 1, -22 },
  { 2588, 14, 16, 16, 1, -16 },
  { 2616, 17, 29, 11, -3, -22 },
  { 2678, 16, 23, 16, 0, -16 },
  { 2724, 16, 22, 17, 0, -22 },
  { 2768, 10, 23, 9, 0, -23 },
  { 2797, 14, 30, 9, -4, -23 },
  { 2850, 18, 22, 16, 0, -22 },
  { 2900, 10, 22, 9, 0, -22 },
  { 2928, 24, 16, 25, 0, -16 },
  { 2976, 16, 16, 17, 0, -16 },
  { 3008, 14, 16, 16, 1, -16 },
  { 3036, 16, 23, 16, -1, -16 },
  { 3082, 15, 23, 16, 1, -16 },
  { 3126, 13, 16, 12, 0, -16 },
  { 3152, 13, 16, 13, 0, -16 },
  { 3178, 12, 19, 12, 1, -19 },
  { 3207, 16, 16, 17, 1, -16 },
  { 3239, 16, 16, 15, 1, -16 },
  { 3271, 22, 16, 22, 2, -16 },
  { 3315, 19, 16, 15, -2, -16 },
  { 3353, 18, 23, 15, -2, -16 },
  { 3405, 15, 16, 13, -1, -16 },
  { 3435, 12, 26, 10, 0, -21 },
  { 3474, 4, 29, 15, 5, -22 },
  { 3489, 12, 26, 10, -2, -21 },
  { 3528, 14, 6, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC29PT7B_H_
