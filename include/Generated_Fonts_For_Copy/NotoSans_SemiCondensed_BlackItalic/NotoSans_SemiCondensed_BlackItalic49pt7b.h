#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x0C,
  0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x1F, 0xE3,
  0xF8, 0xFF, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0x78, 0xE0, 0x3F, 0xDE, 0x08, 0x0F, 0xE7, 0x00, 0x03, 0xFD,
  0xC0, 0x00, 0xFF, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3D,
  0xFE, 0x20, 0x0F, 0x7F, 0x86, 0x03, 0x9F, 0xE1, 0xE0, 0xE7, 0xF8, 0xFF,
  0xBF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xF8,
  0x07, 0xE0, 0x0F, 0xF7, 0xF0, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x7F, 0x00,
  0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x7F, 0x00,
  0x0F, 0xC3, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE3, 0xF0, 0x30, 0x3F, 0x1F,
  0xCF, 0xE3, 0xFC, 0x7F, 0x7F, 0x3F, 0x9F, 0xFC, 0xFF, 0xFE, 0x7E, 0x7F,
  0xFD, 0xFF, 0xF9, 0xFC, 0xFF, 0xF9, 0xFF, 0xE7, 0xF3, 0xFF, 0xF9, 0xFF,
  0x8F, 0xCF, 0xF7, 0xF1, 0xFE, 0x3F, 0x9F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x0F,
  0xC3, 0xF0, 0x03, 0xF8, 0x1F, 0x8F, 0xE0, 0x07, 0xE0, 0x3F, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x80,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0x03,
  0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFC, 0x7F, 0xC3,
  0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0x7F, 0xFF, 0xF1,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F,
  0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0x07, 0xE0, 0x0F, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0xFE,
  0x0E, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xF8, 0xFE, 0x00,
  0xE1, 0xFE, 0x00, 0xC1, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFC, 0x06, 0x0F, 0xE7, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF,
  0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0x7F, 0xC3, 0xF3, 0xFC, 0x1E, 0x3F, 0xE0, 0x61, 0xFF, 0x02, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xF1, 0xFF, 0x00, 0xF0, 0x7F, 0xC0, 0x38, 0x1F, 0xF0, 0x04,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0x83, 0xFF, 0x00, 0x80,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC8, 0x00, 0x3F, 0xE3,
  0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x7F, 0xC0,
  0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFE, 0x03, 0xF8, 0xFF,
  0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x18, 0x7F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x08, 0x00, 0xFF, 0xC3,
  0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFE, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0,
  0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0x83,
  0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xC7, 0xFE, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xF3, 0xFE,
  0x3F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xC7, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFC, 0x0F, 0xE7, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x81, 0xFC, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x06, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xC1, 0xFF, 0x18, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x81, 0xFF, 0x07, 0xE1, 0xFC, 0x1F, 0xFF, 0x9F, 0x8F, 0xE0, 0xFF,
  0xFE, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0xFC, 0xFC, 0x3F, 0xFF, 0xC3, 0xF7,
  0xE1, 0xFC, 0x3F, 0x0F, 0xDF, 0x87, 0xE1, 0xFC, 0x3F, 0x7E, 0x3F, 0x87,
  0xE0, 0xFB, 0xF0, 0xFC, 0x1F, 0x87, 0xEF, 0xC7, 0xF0, 0x7E, 0x1F, 0xBF,
  0x1F, 0xC3, 0xF8, 0x7E, 0xFC, 0x7E, 0x0F, 0xC1, 0xFB, 0xF1, 0xF8, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE1, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0xFC,
  0x7F, 0x3F, 0xCF, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xC7, 0xFF, 0xFF,
  0xF8, 0x3F, 0x0F, 0xFD, 0xFF, 0xC0, 0xFC, 0x1F, 0xE3, 0xFC, 0x03, 0xF8,
  0x1E, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F,
  0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0x1F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0x07, 0xC0, 0xFF, 0xC0, 0x18, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x80, 0x7F, 0xF0, 0x78, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF,
  0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81,
  0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x01, 0x81,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC3,
  0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xC7, 0xFC, 0x3F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xF8, 0xFF, 0xC7, 0xFF, 0xE3, 0xFE, 0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x01, 0xDF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7E,
  0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x1F, 0xDF, 0xC7, 0xF7, 0xF8, 0x0F, 0xF7, 0xF1, 0xFD, 0xFE, 0x03, 0xFD,
  0xFC, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xCF,
  0xCF, 0xF0, 0x1F, 0xF7, 0xF7, 0xF3, 0xFC, 0x07, 0xF9, 0xFD, 0xF8, 0xFF,
  0x01, 0xFE, 0x7F, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F, 0xFF, 0x9F, 0xE0, 0x1F,
  0xE7, 0xFF, 0xC7, 0xF8, 0x0F, 0xF9, 0xFF, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF1, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x01,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0xE1,
  0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0xC0, 0x3F, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F,
  0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0x87, 0xF8,
  0x07, 0xF3, 0xFC, 0x7F, 0x80, 0x7F, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFC,
  0x7F, 0x80, 0xFF, 0x3F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0xFF, 0x00, 0xFF,
  0x1F, 0xEF, 0xF0, 0x1F, 0xF1, 0xFE, 0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0xCF, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFE,
  0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00,
  0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFC, 0x06, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x10, 0x01, 0xFF, 0x07, 0x00, 0xFF, 0xC1, 0xF8, 0x7F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF,
  0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0,
  0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF9, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xC7, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0x03,
  0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xF8, 0x7F,
  0xC1, 0xFE, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFF, 0xE3, 0xFE, 0x07,
  0xF8, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xFF, 0x9F, 0xF0, 0x1F, 0xE7,
  0xF7, 0xF3, 0xFC, 0x03, 0xFC, 0xFE, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xDF,
  0xDF, 0xF0, 0x0F, 0xF7, 0xF3, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x7F, 0x7F,
  0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC3, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF9, 0xFF, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0xFF,
  0xCF, 0xE0, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F,
  0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3,
  0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB,
  0xF8, 0x0F, 0xF9, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x84, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFC, 0x7F,
  0x81, 0xFF, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8,
  0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xF7,
  0xFF, 0x83, 0xFC, 0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x21, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x20, 0xFF, 0x81, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x02, 0x07,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x07, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xF7, 0xF0, 0x03, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0x3F,
  0xE1, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0x0F, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x02,
  0x1F, 0xF8, 0x3C, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0D, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFB, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x7F,
  0xC0, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x0E,
  0x00, 0x3F, 0xCF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x04,
  0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xF8, 0xFF,
  0x03, 0xFC, 0x03, 0xFB, 0xFF, 0x8F, 0xFE, 0x07, 0xFB, 0xFF, 0x9F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xF1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07,
  0xFC, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xBF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0xE1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83,
  0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF, 0xDF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0xCF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFE,
  0x0F, 0xF9, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFB, 0xFC, 0x03, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x0F,
  0xE3, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x40,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFC, 0x1C, 0x1F,
  0xF0, 0x10, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0xC0, 0x1F, 0xF3, 0xF1,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF9, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x43, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8,
  0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8,
  0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFD,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xDF, 0xE0, 0x3F, 0xE7,
  0xF8, 0x1F, 0xF9, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0xFF,
  0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3,
  0xFE, 0x07, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0xC0, 0x3F, 0x9F, 0xE0, 0x0F,
  0xE7, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x83, 0xFD, 0xFE,
  0x1F, 0xFC, 0x3F, 0xEF, 0xF0, 0xFF, 0xE1, 0xFE, 0x7F, 0x87, 0xFF, 0x1F,
  0xF3, 0xFC, 0x7F, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F,
  0x7E, 0x7F, 0xC7, 0xF9, 0xFF, 0xF3, 0xFC, 0x3F, 0xCF, 0xFF, 0xBF, 0xE1,
  0xFE, 0xFF, 0xFD, 0xFE, 0x0F, 0xF7, 0xEF, 0xCF, 0xF0, 0x7F, 0xBF, 0x7E,
  0xFF, 0x03, 0xFF, 0xF3, 0xF7, 0xF8, 0x1F, 0xFF, 0x9F, 0xBF, 0x80, 0xFE,
  0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xFE,
  0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x83,
  0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x02, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 36, 14, 0, -35 },
  { 73, 21, 13, 22, 4, -35 },
  { 108, 31, 35, 30, 0, -35 },
  { 244, 26, 40, 27, 1, -37 },
  { 374, 39, 35, 43, 3, -35 },
  { 545, 33, 35, 34, 0, -35 },
  { 690, 10, 13, 12, 4, -35 },
  { 707, 19, 44, 17, 1, -36 },
  { 812, 18, 44, 17, -3, -36 },
  { 911, 23, 24, 25, 3, -38 },
  { 980, 23, 24, 27, 2, -29 },
  { 1049, 13, 13, 14, -3, -6 },
  { 1071, 15, 8, 16, 0, -17 },
  { 1086, 10, 10, 14, 0, -9 },
  { 1099, 27, 35, 22, -2, -35 },
  { 1218, 24, 36, 27, 2, -36 },
  { 1326, 21, 35, 27, 4, -35 },
  { 1418, 26, 35, 27, -1, -35 },
  { 1532, 26, 35, 27, 0, -35 },
  { 1646, 26, 35, 27, 0, -35 },
  { 1760, 26, 35, 27, 1, -35 },
  { 1874, 25, 35, 27, 2, -35 },
  { 1984, 28, 35, 27, 1, -35 },
  { 2107, 25, 36, 27, 1, -36 },
  { 2220, 24, 35, 27, 2, -35 },
  { 2325, 14, 28, 14, 0, -27 },
  { 2374, 17, 34, 14, -3, -27 },
  { 2447, 23, 26, 27, 2, -31 },
  { 2522, 23, 17, 27, 2, -26 },
  { 2571, 23, 26, 27, 2, -31 },
  { 2646, 21, 36, 22, 3, -35 },
  { 2741, 38, 39, 41, 2, -35 },
  { 2927, 30, 35, 31, -3, -35 },
  { 3059, 29, 35, 29, 0, -35 },
  { 3186, 28, 36, 28, 2, -36 },
  { 3312, 30, 35, 31, 0, -35 },
  { 3444, 27, 35, 25, 0, -35 },
  { 3563, 27, 35, 25, 0, -35 },
  { 3682, 30, 36, 32, 2, -36 },
  { 3817, 33, 35, 32, 0, -35 },
  { 3962, 25, 35, 20, -2, -35 },
  { 4072, 25, 46, 17, -8, -35 },
  { 4216, 34, 35, 30, 0, -35 },
  { 4365, 21, 35, 24, 0, -35 },
  { 4457, 42, 35, 42, 0, -35 },
  { 4641, 36, 35, 35, 0, -35 },
  { 4799, 30, 36, 33, 2, -36 },
  { 4934, 28, 35, 28, 0, -35 },
  { 5057, 30, 44, 33, 2, -36 },
  { 5222, 28, 35, 29, 0, -35 },
  { 5345, 26, 35, 25, 0, -35 },
  { 5459, 24, 35, 25, 4, -35 },
  { 5564, 31, 35, 32, 2, -35 },
  { 5700, 28, 35, 28, 4, -35 },
  { 5823, 43, 35, 42, 4, -35 },
  { 6012, 36, 35, 30, -3, -35 },
  { 6170, 28, 35, 28, 4, -35 },
  { 6293, 30, 35, 25, -2, -35 },
  { 6425, 22, 44, 16, -2, -36 },
  { 6546, 13, 35, 22, 5, -35 },
  { 6603, 21, 44, 16, -3, -36 },
  { 6719, 25, 23, 25, 0, -35 },
  { 6791, 23, 6, 21, -5, 3 },
  { 6809, 11, 8, 17, 7, -38 },
  { 6820, 25, 28, 28, 2, -28 },
  { 6908, 26, 37, 28, 0, -37 },
  { 7029, 22, 28, 23, 2, -28 },
  { 7106, 28, 37, 27, 2, -37 },
  { 7236, 23, 28, 26, 2, -28 },
  { 7317, 28, 49, 18, -5, -37 },
  { 7489, 27, 40, 28, 0, -28 },
  { 7624, 26, 37, 28, 0, -37 },
  { 7745, 16, 38, 15, 0, -38 },
  { 7821, 23, 50, 15, -6, -38 },
  { 7965, 31, 37, 28, 0, -37 },
  { 8109, 17, 37, 15, 0, -37 },
  { 8188, 40, 28, 42, 0, -28 },
  { 8328, 26, 28, 28, 0, -28 },
  { 8419, 24, 28, 27, 2, -28 },
  { 8503, 28, 40, 28, -2, -28 },
  { 8643, 25, 40, 28, 2, -28 },
  { 8768, 22, 28, 20, 0, -28 },
  { 8845, 22, 28, 23, 0, -28 },
  { 8922, 19, 33, 20, 2, -33 },
  { 9001, 26, 27, 28, 2, -27 },
  { 9089, 26, 27, 25, 2, -27 },
  { 9177, 37, 27, 38, 3, -27 },
  { 9302, 32, 27, 26, -3, -27 },
  { 9410, 31, 39, 25, -3, -27 },
  { 9562, 24, 27, 22, -1, -27 },
  { 9643, 21, 43, 17, 0, -35 },
  { 9756, 7, 48, 25, 9, -37 },
  { 9798, 20, 43, 17, -3, -35 },
  { 9906, 23, 9, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC49PT7B_H_
