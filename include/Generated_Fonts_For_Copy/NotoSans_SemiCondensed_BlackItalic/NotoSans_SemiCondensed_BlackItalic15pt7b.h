#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x67, 0x39, 0x80, 0x47, 0x38, 0x6E, 0xD9, 0xB6, 0x60,
  0x0D, 0x8C, 0x86, 0xCF, 0xF7, 0xF9, 0xB3, 0xFF, 0xFE, 0x6C, 0x36, 0x1B,
  0x00, 0x04, 0x3F, 0x3F, 0x78, 0x78, 0x3E, 0x0E, 0x96, 0xFE, 0xFC, 0x10,
  0x30, 0x30, 0xC7, 0x8C, 0xD9, 0x8D, 0xB0, 0xDB, 0x4F, 0x6F, 0x6D, 0xB0,
  0xDB, 0x19, 0xB3, 0x1E, 0x71, 0xC0, 0x0E, 0x07, 0xC3, 0xB0, 0xFC, 0x3E,
  0x0F, 0x77, 0xDF, 0xBE, 0xE7, 0x3F, 0xC7, 0xF8, 0x6D, 0xE0, 0x0C, 0x63,
  0x0C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x18, 0x60, 0x18, 0x61, 0xC7, 0x1C,
  0x71, 0xC6, 0x18, 0xE3, 0x1C, 0xE0, 0x10, 0x31, 0x67, 0xF3, 0xEF, 0x3B,
  0x04, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x00, 0x77, 0x6E, 0xFF, 0x80,
  0x5F, 0x80, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x38, 0x00, 0x0E, 0x3F, 0x3F, 0x77, 0x77, 0x67, 0x67, 0xE6, 0x6E,
  0x7C, 0x78, 0x0E, 0x39, 0xF7, 0xE5, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC0,
  0x1E, 0x7F, 0x37, 0x27, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xFE, 0xFC, 0x1E,
  0x7F, 0x37, 0x07, 0x3E, 0x3C, 0x3E, 0x0E, 0x8E, 0xFE, 0xFC, 0x07, 0x07,
  0x0F, 0x1E, 0x36, 0x7E, 0x6E, 0xFF, 0xFE, 0x1C, 0x1C, 0x1F, 0x3F, 0x3F,
  0x30, 0x7C, 0x7E, 0x0E, 0x0E, 0x8E, 0xFE, 0xF8, 0x1E, 0x7D, 0xCF, 0x0F,
  0xDF, 0xBB, 0xE7, 0xDD, 0xF9, 0xE0, 0x3F, 0x9F, 0xDF, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x38, 0x38, 0x3C, 0x00, 0x1E, 0x3F, 0x37, 0x37, 0x3E,
  0x1C, 0x7E, 0xE6, 0xE6, 0xFE, 0x7C, 0x38, 0xFB, 0xBF, 0x7E, 0xFF, 0xFF,
  0x06, 0x1D, 0xF3, 0xC0, 0x37, 0x00, 0x04, 0xEE, 0x19, 0xC0, 0x00, 0x01,
  0xCE, 0x66, 0x00, 0x06, 0x3D, 0xE7, 0x0F, 0x87, 0xC3, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0xC1, 0xE1, 0xF0, 0x73, 0xDE, 0x30, 0x40, 0x7B, 0xF5,
  0xC7, 0x3D, 0xC6, 0x00, 0x43, 0x8E, 0x00, 0x07, 0x81, 0xFE, 0x38, 0x73,
  0x7B, 0x6F, 0xB6, 0xDB, 0x59, 0xBD, 0xB6, 0x4F, 0xE6, 0x00, 0x71, 0x83,
  0xF8, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE6, 0x7F, 0x7F, 0xB8,
  0xF8, 0x60, 0x3E, 0x1F, 0xCE, 0xE6, 0x73, 0xF3, 0xF1, 0xFC, 0xEE, 0x67,
  0x7F, 0x3F, 0x00, 0x1E, 0x3F, 0x7A, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4,
  0xFC, 0x7C, 0x3E, 0x1F, 0x8F, 0xE6, 0x73, 0x3B, 0x9D, 0xCE, 0xE7, 0x67,
  0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x3F, 0x30, 0x3E, 0x7E, 0x7E, 0x70, 0x60,
  0xFC, 0xFC, 0x3F, 0x3F, 0x3F, 0x30, 0x30, 0x7E, 0x7E, 0x70, 0x60, 0xE0,
  0xE0, 0x0F, 0x1F, 0xDE, 0xDE, 0x0E, 0x07, 0x7B, 0xBD, 0xCE, 0xE6, 0x7F,
  0x1F, 0x80, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x3F, 0x9F, 0xE7, 0xF9, 0xCE,
  0x63, 0x39, 0xCE, 0x70, 0x1F, 0x3F, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x7C, 0xFC, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0xCF, 0x1E, 0x00, 0x39, 0xCE, 0xF3, 0xB8, 0xDC, 0x3E, 0x1F, 0x87,
  0xE1, 0xF8, 0x67, 0x39, 0xCE, 0x70, 0x38, 0xE3, 0x8C, 0x31, 0xC7, 0x1C,
  0x63, 0xFF, 0xC0, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x79, 0xE3, 0xDB, 0x3E,
  0xF9, 0xFF, 0xCD, 0xEC, 0x6F, 0x67, 0x77, 0x3B, 0xB8, 0x3C, 0x67, 0x9C,
  0xF3, 0x9E, 0x63, 0xEC, 0xFD, 0x9D, 0xF3, 0x3E, 0x67, 0x9C, 0xF3, 0x8E,
  0x00, 0x1E, 0x1F, 0x9F, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8E, 0xE7, 0x7F,
  0x1F, 0x00, 0x3E, 0x1F, 0x8F, 0xE6, 0x73, 0x33, 0xF9, 0xF8, 0xE0, 0x60,
  0x70, 0x38, 0x00, 0x1E, 0x1F, 0x9F, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8E,
  0xEF, 0x7F, 0x1F, 0x03, 0x80, 0xE0, 0x70, 0x3E, 0x1F, 0x8F, 0xE6, 0x73,
  0x73, 0xF9, 0xF8, 0xFC, 0x66, 0x73, 0xB9, 0xC0, 0x1E, 0x3F, 0x7E, 0x70,
  0x78, 0x3C, 0x1E, 0x0E, 0x8E, 0xFC, 0xF8, 0x7F, 0xFE, 0xFE, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x73, 0xB9, 0xDC, 0xCC, 0x6E, 0x77,
  0x3B, 0x9D, 0xCC, 0xEE, 0x7F, 0x1F, 0x00, 0xE3, 0xF1, 0xB9, 0xDC, 0xCE,
  0xE7, 0x61, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x00, 0xE3, 0x3F, 0x39, 0xF9,
  0xCD, 0xDE, 0xEE, 0xF7, 0x7F, 0xB3, 0xEF, 0x9F, 0x78, 0xF3, 0xC7, 0x9C,
  0x3C, 0xE0, 0x18, 0xE3, 0xB8, 0x77, 0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x3B, 0x0E, 0x73, 0x8E, 0x00, 0xE3, 0xB3, 0x9B, 0x8F, 0xC7, 0xC3,
  0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0x9F, 0xCF, 0xE0, 0xE0,
  0xE0, 0xF0, 0x70, 0x70, 0x70, 0x3F, 0xBF, 0x80, 0x1E, 0x3C, 0x60, 0xC3,
  0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x47, 0x1E, 0x00, 0xDB, 0x6D, 0xDB,
  0x6D, 0x80, 0x1E, 0x78, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x8F, 0x1E, 0x00, 0x0C, 0x0C, 0x1C, 0x36, 0x36, 0x66, 0xE7, 0xFF, 0xF0,
  0xE7, 0x3F, 0x7F, 0x77, 0x67, 0x66, 0xEE, 0x7E, 0x76, 0x38, 0x38, 0x30,
  0x3F, 0x7F, 0x77, 0x77, 0x67, 0x6E, 0xFE, 0xDC, 0x3E, 0xFD, 0xC3, 0x06,
  0x1C, 0x9F, 0x3E, 0x03, 0x81, 0xC0, 0xC7, 0xE7, 0xF3, 0xB9, 0x9C, 0xCC,
  0xEE, 0x3F, 0x1D, 0x80, 0x3E, 0x77, 0x77, 0x7E, 0xFC, 0x62, 0x7E, 0x7C,
  0x07, 0x83, 0xC3, 0x83, 0xE1, 0xF0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x0F, 0x87, 0x81, 0x80, 0x3F, 0x7F, 0x77, 0x67, 0x66, 0xEE, 0x7E,
  0x7E, 0x0E, 0xFC, 0xFC, 0x70, 0x38, 0x38, 0x30, 0x3F, 0x7F, 0x77, 0x77,
  0x67, 0x66, 0xE6, 0xEE, 0x19, 0xCE, 0x03, 0x39, 0xCE, 0x63, 0x39, 0xC0,
  0x06, 0x1C, 0x38, 0x10, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x9E,
  0x3C, 0x60, 0x38, 0x1C, 0x0E, 0x06, 0x77, 0x73, 0xF1, 0xF0, 0xF8, 0x6E,
  0x77, 0x39, 0xC0, 0x39, 0xCE, 0x67, 0x39, 0xCC, 0x67, 0x38, 0x3F, 0xF7,
  0xFF, 0x77, 0x77, 0x77, 0x67, 0x76, 0x67, 0xE6, 0x6E, 0xEE, 0x3F, 0x7F,
  0x77, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0x3E, 0x7F, 0x77, 0x67, 0x67, 0xE6,
  0x7E, 0x7C, 0x1F, 0x9F, 0xCE, 0xE7, 0x73, 0x39, 0x99, 0xFC, 0xFC, 0x70,
  0x30, 0x18, 0x1C, 0x00, 0x3F, 0x7F, 0x77, 0x67, 0x66, 0xEE, 0x7E, 0x7E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x3E, 0xF9, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0x3E,
  0xF9, 0xC3, 0xC3, 0xD3, 0xBF, 0x7C, 0x31, 0xDF, 0xBE, 0xE3, 0x8E, 0x30,
  0xF3, 0xC0, 0x67, 0xE6, 0xEE, 0xEE, 0xCE, 0xDC, 0xFC, 0xEC, 0xCF, 0xCE,
  0xDC, 0xFC, 0xD8, 0xF8, 0xF0, 0xF0, 0xCE, 0xFB, 0xDF, 0x7B, 0x6F, 0xEF,
  0x79, 0xEF, 0x39, 0xC7, 0x38, 0x3B, 0xC6, 0xC1, 0xF0, 0x78, 0x1E, 0x0F,
  0x87, 0x73, 0xDC, 0x33, 0xCE, 0xE3, 0xF0, 0xFC, 0x3E, 0x0F, 0x81, 0xC0,
  0x70, 0x38, 0x3E, 0x0F, 0x03, 0x00, 0x7E, 0xFC, 0x71, 0xC7, 0x0E, 0x3F,
  0x7E, 0x0C, 0x71, 0x8E, 0x31, 0xCE, 0x38, 0x71, 0x86, 0x1C, 0x70, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0xE1, 0x86, 0x18, 0x61, 0xCF, 0x30, 0xC7, 0x3C,
  0xE0, 0xE3, 0xFE, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 9, 11, 9, 0, -11 },
  { 25, 8, 12, 8, 0, -11 },
  { 37, 12, 11, 13, 1, -11 },
  { 54, 10, 11, 10, 0, -11 },
  { 68, 3, 4, 4, 1, -11 },
  { 70, 6, 13, 5, 0, -11 },
  { 80, 6, 13, 5, -1, -11 },
  { 90, 7, 8, 8, 1, -12 },
  { 97, 7, 7, 8, 1, -9 },
  { 104, 4, 4, 4, -1, -2 },
  { 106, 5, 2, 5, 0, -5 },
  { 108, 3, 3, 4, 0, -3 },
  { 110, 9, 11, 7, -1, -11 },
  { 123, 8, 11, 8, 0, -11 },
  { 134, 7, 11, 8, 1, -11 },
  { 144, 8, 11, 8, 0, -11 },
  { 155, 8, 11, 8, 0, -11 },
  { 166, 8, 11, 8, 0, -11 },
  { 177, 8, 11, 8, 0, -11 },
  { 188, 7, 11, 8, 1, -11 },
  { 198, 9, 11, 8, 0, -11 },
  { 211, 8, 11, 8, 0, -11 },
  { 222, 7, 11, 8, 1, -11 },
  { 232, 4, 8, 4, 0, -8 },
  { 236, 5, 10, 4, -1, -8 },
  { 243, 7, 8, 8, 1, -9 },
  { 250, 7, 5, 8, 1, -8 },
  { 255, 7, 8, 8, 1, -9 },
  { 262, 6, 11, 7, 1, -11 },
  { 271, 12, 12, 12, 0, -11 },
  { 289, 9, 11, 9, -1, -11 },
  { 302, 9, 11, 9, 0, -11 },
  { 315, 8, 11, 9, 1, -11 },
  { 326, 9, 11, 9, 0, -11 },
  { 339, 8, 11, 8, 0, -11 },
  { 350, 8, 11, 8, 0, -11 },
  { 361, 9, 11, 10, 1, -11 },
  { 374, 10, 11, 10, 0, -11 },
  { 388, 8, 11, 6, -1, -11 },
  { 399, 7, 14, 5, -2, -11 },
  { 412, 10, 11, 9, 0, -11 },
  { 426, 6, 11, 7, 0, -11 },
  { 435, 13, 11, 13, 0, -11 },
  { 453, 11, 11, 11, 0, -11 },
  { 469, 9, 11, 10, 1, -11 },
  { 482, 9, 11, 9, 0, -11 },
  { 495, 9, 14, 10, 1, -11 },
  { 511, 9, 11, 9, 0, -11 },
  { 524, 8, 11, 8, 0, -11 },
  { 535, 8, 11, 8, 1, -11 },
  { 546, 9, 11, 10, 1, -11 },
  { 559, 9, 11, 9, 1, -11 },
  { 572, 13, 11, 13, 1, -11 },
  { 590, 11, 11, 9, -1, -11 },
  { 606, 9, 11, 8, 1, -11 },
  { 619, 9, 11, 8, -1, -11 },
  { 632, 7, 14, 5, -1, -11 },
  { 645, 3, 11, 7, 2, -11 },
  { 650, 7, 14, 5, -1, -11 },
  { 663, 8, 7, 8, 0, -11 },
  { 670, 6, 2, 6, -1, 1 },
  { 672, 4, 2, 5, 2, -11 },
  { 673, 8, 8, 8, 0, -8 },
  { 681, 8, 11, 8, 0, -11 },
  { 692, 7, 8, 7, 0, -8 },
  { 699, 9, 11, 8, 0, -11 },
  { 712, 8, 8, 8, 0, -8 },
  { 720, 9, 15, 6, -2, -11 },
  { 737, 8, 12, 8, 0, -8 },
  { 749, 8, 11, 9, 0, -11 },
  { 760, 5, 12, 4, 0, -12 },
  { 768, 7, 16, 4, -2, -12 },
  { 782, 9, 11, 9, 0, -11 },
  { 795, 5, 11, 4, 0, -11 },
  { 802, 12, 8, 13, 0, -8 },
  { 814, 8, 8, 9, 0, -8 },
  { 822, 8, 8, 8, 0, -8 },
  { 830, 9, 12, 8, -1, -8 },
  { 844, 8, 12, 8, 0, -8 },
  { 856, 7, 8, 6, 0, -8 },
  { 863, 7, 8, 7, 0, -8 },
  { 870, 6, 10, 6, 1, -10 },
  { 878, 8, 8, 9, 1, -8 },
  { 886, 8, 8, 8, 1, -8 },
  { 894, 11, 8, 12, 1, -8 },
  { 905, 10, 8, 8, -1, -8 },
  { 915, 10, 12, 8, -1, -8 },
  { 930, 7, 8, 7, 0, -8 },
  { 937, 6, 13, 5, 0, -11 },
  { 947, 2, 14, 8, 3, -11 },
  { 951, 6, 13, 5, -1, -11 },
  { 961, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC15PT7B_H_
