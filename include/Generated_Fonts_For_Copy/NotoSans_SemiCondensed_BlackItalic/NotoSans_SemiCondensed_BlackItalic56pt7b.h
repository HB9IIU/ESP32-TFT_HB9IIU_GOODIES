#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0xFF, 0x8F, 0xF9,
  0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xC7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xDE, 0x3E, 0x07, 0xFC, 0xF0, 0x30, 0x3F, 0xE7, 0x80, 0x01, 0xFF, 0x3C,
  0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF7, 0xFC,
  0x00, 0x07, 0x9F, 0xE1, 0x00, 0x3C, 0xFF, 0x0E, 0x03, 0xCF, 0xF8, 0x7E,
  0x1E, 0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x00, 0x3F,
  0x8F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE3,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x87,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE3, 0xF8,
  0x0C, 0x07, 0xF8, 0xFE, 0x3F, 0xC7, 0xFC, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F,
  0xF9, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF, 0xE7, 0xFF, 0xF9, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xE7, 0xFF, 0xF8, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0x8F, 0xF3, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x04,
  0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF,
  0x87, 0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xCF,
  0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0C, 0x07, 0xF0, 0x03, 0xC1,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0xDF, 0x80, 0x1F, 0xFF, 0xE1, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xCF, 0xC1, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x0F,
  0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1E, 0x1F, 0xF0, 0x03, 0x83, 0xF8,
  0x00, 0x40, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x3F,
  0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF7, 0xFE, 0x03,
  0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xEF,
  0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFC,
  0xFF, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xE0, 0xFE, 0x3F, 0xE0,
  0x3E, 0x3F, 0xF0, 0x0C, 0x1F, 0xF8, 0x04, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xFC, 0x01, 0xF8, 0x3F,
  0xF8, 0x01, 0xE0, 0x3F, 0xF0, 0x01, 0x00, 0x7F, 0xE0, 0x02, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x81, 0xFF, 0xC0, 0x10, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF2, 0x00, 0x03,
  0xFF, 0x98, 0x00, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFB, 0xFE, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0xFF, 0x7F, 0xE0, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xCF, 0xFC, 0x01, 0xFE, 0x3F, 0xF0, 0x07, 0xF8, 0xFF,
  0xC0, 0x3F, 0xC3, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0C, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x40, 0x00, 0xFF,
  0xE3, 0x00, 0x0F, 0xFE, 0x1E, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x07,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFF, 0x01, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0xC7,
  0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xCF, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8,
  0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFC, 0xFF, 0xE1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xFE, 0xFF,
  0xE0, 0xFF, 0xDF, 0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xEF, 0xFC, 0x1F, 0xFD, 0xFF, 0xC3, 0xFF, 0xBF, 0xFD, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x1F, 0xF3, 0xFE, 0x00, 0xF8,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0x0C, 0x03, 0xFF, 0x08, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0x1F, 0xC7, 0xF0,
  0x3F, 0xFF, 0xE3, 0xF9, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x3F, 0x83, 0xFF,
  0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0x0F, 0xE0, 0xFD, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0xBF, 0x87, 0xF8, 0x3F, 0x87, 0xF7, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xF0,
  0xFE, 0x07, 0xF0, 0x7E, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xDF, 0xC7, 0xF8,
  0x3F, 0x83, 0xFB, 0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x7F, 0x1F, 0xE1, 0xFE,
  0x1F, 0xCF, 0xE3, 0xFC, 0x7F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x8F, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xF8, 0x0F, 0xFF, 0x00, 0x70, 0x1F, 0xFE,
  0x00, 0x10, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0x00, 0xFF, 0xF8,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3E, 0x03, 0xFF, 0xE0, 0x07, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x3F, 0xFF, 0x9F, 0xFC, 0x3F, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xE7,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0xF8,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xF8, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x83, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x07,
  0xFE, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x1F, 0xDF, 0xF0, 0x07, 0xFD, 0xFC, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFE,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x0F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF,
  0xC7, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xE7, 0xF9, 0xFF, 0x00, 0x7F, 0xEF,
  0xF3, 0xFD, 0xFF, 0x80, 0x3F, 0xE7, 0xFB, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3,
  0xFD, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0xFE, 0x3F, 0xE0, 0x07, 0xFC,
  0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x7F, 0xFF, 0x1F, 0xF8, 0x03, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xFF, 0xC7, 0xFC, 0x00, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF7, 0xFC, 0x1F, 0xF0, 0x07,
  0xFB, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x7F,
  0xC7, 0xFE, 0x01, 0xFF, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x9F, 0xF9, 0xFF,
  0x00, 0x7F, 0xC7, 0xFC, 0xFF, 0x80, 0x7F, 0xE3, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xDF, 0xE0, 0x0F, 0xF8, 0x7F,
  0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFD, 0xFF,
  0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0,
  0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x07,
  0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0x01,
  0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x1F, 0x80, 0x7F, 0xF0, 0x0E, 0x01, 0xFF, 0x80, 0x10,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x81, 0x00, 0x07, 0xFE, 0x06, 0x00, 0x1F, 0xF8, 0x1E,
  0x00, 0xFF, 0xE0, 0x7F, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF,
  0x9F, 0xEF, 0xF1, 0xFF, 0x00, 0xFF, 0x9F, 0xEF, 0xF3, 0xFF, 0x00, 0xFF,
  0x9F, 0xEF, 0xF3, 0xFE, 0x00, 0xFF, 0xBF, 0xCF, 0xF3, 0xFE, 0x00, 0xFF,
  0xBF, 0xCF, 0xF7, 0xFE, 0x00, 0xFF, 0x7F, 0xCF, 0xF7, 0xFC, 0x00, 0xFF,
  0x7F, 0x8F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0x8F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0xC7, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF8,
  0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFF, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF1, 0xFE, 0x07, 0xFF, 0xDF, 0xF0, 0x7F,
  0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF,
  0x81, 0xFF, 0x9F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0x00, 0xFF, 0xE7, 0xF8,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE1, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFD, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0x81,
  0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xBF, 0xFE, 0x03, 0xFE, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0x06,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x41, 0xFF, 0xC0, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0x0F,
  0xFC, 0x00, 0x7F, 0x9F, 0xF8, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xDF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x3F, 0xF9, 0xFE,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x1F, 0xF8, 0x7F, 0xE7, 0xFF, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0xBF, 0xF8,
  0x3F, 0xF7, 0xFE, 0x0F, 0xFE, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x60, 0xFF, 0xE0, 0x3C, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x84, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x01, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xBF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0xF0,
  0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x04, 0x00, 0x1F, 0xF8, 0x0E,
  0x00, 0x7F, 0xF0, 0x1F, 0xE7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE7, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xBF, 0xFE, 0x7F, 0xFE, 0x03,
  0xFD, 0xFF, 0xF9, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0xBF, 0xFE, 0x03, 0xFD, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xE3,
  0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0x7F, 0xF0,
  0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xEF, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF,
  0x8F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF7, 0xFF,
  0x00, 0x0F, 0xFB, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC,
  0x0F, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xDF, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF1, 0xFE, 0x00,
  0x1F, 0xF8, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0xF1, 0xFE, 0x07, 0xFF, 0xDF, 0xF0, 0x7F, 0xFE, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF,
  0x9F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F,
  0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xF8, 0x01, 0xFC,
  0xFF, 0xC0, 0x01, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0x9F, 0xE0,
  0x7F, 0x9F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFB,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1E, 0x07, 0xFE,
  0x02, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE2, 0x00, 0x3F, 0xF1, 0xC0, 0x1F, 0xF8, 0xFC, 0x1F, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x3F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0x00,
  0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xFD, 0xFF, 0x80,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7,
  0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xF0,
  0x7F, 0xEF, 0xFC, 0x3F, 0xFE, 0x1F, 0xF9, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0x3F, 0xE0, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xFE, 0x1F, 0xF8, 0xFF,
  0x87, 0xFF, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0xF8, 0xFF, 0xC3, 0xFE, 0x3F,
  0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFF, 0xE3, 0xFE, 0x0F, 0xF9, 0xFD, 0xFC,
  0xFF, 0xC1, 0xFF, 0x3F, 0xBF, 0x9F, 0xF0, 0x3F, 0xE7, 0xF7, 0xF3, 0xFE,
  0x07, 0xFD, 0xFC, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0x9F, 0xDF, 0xF0, 0x0F,
  0xF7, 0xF3, 0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x80, 0x0D, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xD8, 0x00, 0x7F, 0xF2, 0x00,
  0x00, 0x20, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 41, 16, 0, -40 },
  { 99, 23, 14, 25, 5, -40 },
  { 140, 35, 40, 34, 0, -40 },
  { 315, 29, 46, 30, 1, -43 },
  { 482, 45, 42, 49, 3, -41 },
  { 719, 38, 42, 38, 0, -41 },
  { 919, 11, 14, 13, 5, -40 },
  { 939, 22, 50, 19, 1, -41 },
  { 1077, 22, 50, 19, -4, -41 },
  { 1215, 26, 27, 28, 4, -43 },
  { 1303, 26, 27, 31, 3, -33 },
  { 1391, 15, 14, 16, -3, -7 },
  { 1418, 16, 8, 18, 1, -19 },
  { 1434, 11, 11, 16, 0, -10 },
  { 1450, 32, 42, 25, -3, -41 },
  { 1618, 28, 42, 30, 2, -41 },
  { 1765, 25, 40, 30, 4, -40 },
  { 1890, 31, 41, 30, -2, -41 },
  { 2049, 29, 42, 30, 0, -41 },
  { 2202, 30, 40, 30, 0, -40 },
  { 2352, 29, 41, 30, 1, -40 },
  { 2501, 29, 42, 30, 2, -41 },
  { 2654, 32, 40, 30, 1, -40 },
  { 2814, 29, 42, 30, 1, -41 },
  { 2967, 27, 42, 30, 2, -41 },
  { 3109, 16, 32, 16, 0, -31 },
  { 3173, 19, 38, 16, -3, -31 },
  { 3264, 27, 30, 31, 2, -35 },
  { 3366, 26, 20, 31, 3, -30 },
  { 3431, 26, 30, 31, 3, -35 },
  { 3529, 24, 42, 25, 3, -41 },
  { 3655, 43, 46, 46, 2, -41 },
  { 3903, 34, 40, 35, -3, -40 },
  { 4073, 33, 40, 33, 0, -40 },
  { 4238, 32, 42, 32, 3, -41 },
  { 4406, 34, 40, 35, 0, -40 },
  { 4576, 31, 40, 29, 0, -40 },
  { 4731, 30, 40, 29, 0, -40 },
  { 4881, 33, 42, 36, 3, -41 },
  { 5055, 38, 40, 37, 0, -40 },
  { 5245, 28, 40, 23, -2, -40 },
  { 5385, 29, 53, 19, -9, -40 },
  { 5578, 39, 40, 34, 0, -40 },
  { 5773, 24, 40, 27, 0, -40 },
  { 5893, 49, 40, 47, 0, -40 },
  { 6138, 41, 40, 40, 0, -40 },
  { 6343, 34, 42, 38, 3, -41 },
  { 6522, 32, 40, 32, 0, -40 },
  { 6682, 34, 51, 38, 3, -41 },
  { 6899, 32, 40, 33, 0, -40 },
  { 7059, 30, 42, 28, 0, -41 },
  { 7217, 28, 40, 28, 4, -40 },
  { 7357, 34, 41, 36, 3, -40 },
  { 7532, 33, 40, 33, 4, -40 },
  { 7697, 48, 40, 48, 5, -40 },
  { 7937, 41, 40, 34, -3, -40 },
  { 8142, 31, 40, 31, 5, -40 },
  { 8297, 34, 40, 28, -2, -40 },
  { 8467, 25, 50, 19, -2, -41 },
  { 8624, 14, 42, 25, 6, -41 },
  { 8698, 25, 50, 19, -4, -41 },
  { 8855, 29, 26, 29, -1, -40 },
  { 8950, 25, 6, 24, -5, 4 },
  { 8969, 13, 9, 19, 8, -43 },
  { 8984, 29, 33, 32, 2, -32 },
  { 9104, 30, 44, 32, 0, -43 },
  { 9269, 25, 33, 26, 2, -32 },
  { 9373, 32, 44, 31, 2, -43 },
  { 9549, 27, 33, 30, 2, -32 },
  { 9661, 33, 56, 21, -6, -43 },
  { 9892, 31, 45, 32, 0, -32 },
  { 10067, 30, 43, 32, 0, -43 },
  { 10229, 19, 44, 17, 0, -44 },
  { 10334, 26, 57, 17, -7, -44 },
  { 10520, 35, 43, 32, 0, -43 },
  { 10709, 19, 43, 17, 0, -43 },
  { 10812, 46, 32, 48, 0, -32 },
  { 10996, 30, 32, 32, 0, -32 },
  { 11116, 28, 33, 31, 2, -32 },
  { 11232, 33, 45, 32, -3, -32 },
  { 11418, 29, 45, 32, 2, -32 },
  { 11582, 25, 32, 23, 0, -32 },
  { 11682, 25, 33, 26, 0, -32 },
  { 11786, 22, 38, 23, 2, -37 },
  { 11891, 30, 32, 32, 2, -31 },
  { 12011, 29, 31, 29, 3, -31 },
  { 12124, 43, 31, 43, 3, -31 },
  { 12291, 36, 31, 30, -3, -31 },
  { 12431, 35, 44, 29, -3, -31 },
  { 12624, 29, 31, 25, -2, -31 },
  { 12737, 24, 49, 20, 0, -40 },
  { 12884, 8, 56, 28, 10, -43 },
  { 12940, 23, 49, 20, -3, -40 },
  { 13081, 27, 11, 31, 2, -25 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC56PT7B_H_
