#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x7E, 0x7E, 0xFC, 0xF9, 0xF9, 0xF3, 0xE7, 0xE7, 0xCF,
  0x8F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC1, 0xF1, 0xE0,
  0x07, 0xCF, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x07, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0x71, 0x0F, 0xD8, 0x03, 0xF6, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1D, 0xF3,
  0x06, 0x7C, 0xF1, 0xBF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0x81, 0xFE, 0x01, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFF, 0x03,
  0xC0, 0x7C, 0xF0, 0x7C, 0x07, 0x8F, 0x0F, 0x80, 0xF8, 0xF0, 0xF0, 0x0F,
  0x9F, 0x1F, 0x00, 0xF9, 0xF3, 0xE0, 0x0F, 0x9F, 0x3C, 0x00, 0xFB, 0xE7,
  0xCF, 0xCF, 0xFE, 0xF9, 0xFE, 0xFF, 0xCF, 0x3F, 0xF7, 0xF9, 0xF7, 0xFF,
  0x3F, 0x3E, 0x7D, 0xF0, 0x03, 0xCF, 0x9F, 0x00, 0x7C, 0xF9, 0xF0, 0x0F,
  0x8F, 0x9F, 0x01, 0xF0, 0xF1, 0xF0, 0x1F, 0x0F, 0x1E, 0x03, 0xE0, 0xF3,
  0xE0, 0x7C, 0x0F, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x07, 0xF8, 0x1F,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x7F, 0x1F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x7F, 0xFE, 0xFC,
  0x7F, 0x7F, 0xFC, 0xFE, 0x7F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x3F, 0xF0,
  0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBE,
  0x7C, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0x7C, 0x04, 0x3E, 0x03, 0x9F, 0x03, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC3, 0xFC, 0xE3, 0xFE, 0x07,
  0xFF, 0x81, 0xF7, 0xC0, 0x71, 0xF0, 0x18, 0xF8, 0x00, 0x60, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0xCF,
  0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0xF8, 0x00, 0x7F, 0xEF, 0xF9, 0xFF,
  0x3F, 0xEF, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0xE7, 0xE3, 0xF9, 0xFC, 0xFC, 0x7F, 0x7F, 0x1F, 0xDF, 0xC7, 0xF7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0xBF, 0x87, 0xEF, 0xE3, 0xFB, 0xF0, 0xFE,
  0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xFB, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC,
  0x7D, 0xF8, 0xF3, 0xF0, 0x8F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x9F, 0xC0, 0xC1,
  0xF8, 0x10, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0x83, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE8, 0x03, 0xFB, 0x01, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7B, 0xF0, 0x1F, 0x7E, 0x07, 0xDF, 0x81, 0xF3, 0xF0,
  0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF2,
  0x00, 0xFE, 0x70, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x18, 0x0F, 0xDF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF9,
  0xFF, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3,
  0xF0, 0xFC, 0x7F, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE1, 0xF9, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFE, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0xFD, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x1F,
  0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xEF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0x7C, 0x3F, 0x7E, 0x0E, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x8F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01,
  0x03, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0,
  0x00, 0x40, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x0F,
  0xF0, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x0F, 0xC8, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0xF0, 0xFF,
  0xCF, 0x3E, 0x3F, 0xF9, 0xE7, 0x8F, 0xFE, 0x3D, 0xF3, 0xE3, 0xC7, 0xBC,
  0x7C, 0x78, 0xF7, 0x9F, 0x1F, 0x1F, 0xF3, 0xE3, 0xE3, 0xFE, 0x78, 0x78,
  0xFF, 0x8F, 0x0F, 0x1E, 0xF1, 0xE3, 0xE7, 0xDE, 0x3E, 0xFD, 0xF3, 0xC7,
  0xFF, 0xFC, 0x7C, 0xFF, 0xFF, 0x07, 0x8F, 0xCF, 0xC0, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0,
  0x7E, 0x1F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F,
  0x9F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x7F, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFC, 0x1C, 0x3F, 0x80, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x02, 0x0F,
  0xE0, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF3, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x07, 0xF1,
  0xF8, 0x3F, 0x8F, 0xC3, 0xF8, 0xFE, 0x7F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xF0,
  0x70, 0xFF, 0x00, 0x8F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x8F, 0xF9, 0xFC, 0x7F, 0xCF, 0xC7, 0xFE, 0x7E, 0x3F, 0xF3, 0xF1, 0xFF,
  0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x87, 0xF1, 0xFE,
  0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xE1, 0xFC,
  0x07, 0xE1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0,
  0x0F, 0xCF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x1F, 0x80,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF1, 0xF7, 0xC1, 0xFF, 0xC7, 0xFF, 0x07, 0xFF,
  0x3E, 0xFC, 0x1F, 0xFC, 0xFB, 0xF0, 0x7D, 0xF3, 0xCF, 0x83, 0xF7, 0xDF,
  0x7E, 0x0F, 0xDF, 0x7D, 0xF8, 0x3F, 0x7F, 0xE7, 0xE0, 0xFD, 0xFF, 0x9F,
  0x83, 0xE7, 0xFC, 0xFC, 0x1F, 0x9F, 0xF3, 0xF0, 0x7E, 0x7F, 0x8F, 0xC1,
  0xF9, 0xFE, 0x3F, 0x07, 0xE7, 0xF0, 0xF8, 0x1F, 0x1F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0x7F, 0xC0,
  0xF8, 0x1F, 0xF0, 0x7E, 0x07, 0xFC, 0x1F, 0x83, 0xFF, 0x07, 0xE0, 0xFF,
  0xE1, 0xF8, 0x3F, 0xF8, 0x7C, 0x0F, 0xFE, 0x3F, 0x03, 0xFF, 0x8F, 0xC1,
  0xFB, 0xF3, 0xF0, 0x7E, 0xFC, 0xF8, 0x1F, 0xBF, 0x3E, 0x07, 0xCF, 0xDF,
  0x83, 0xF1, 0xFF, 0xE0, 0xFC, 0x7F, 0xF8, 0x3F, 0x1F, 0xFC, 0x0F, 0xC7,
  0xFF, 0x03, 0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x7E, 0x0F, 0xFC, 0x1F,
  0x83, 0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xF0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x01,
  0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x01, 0xFB, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x3F, 0x07, 0xF9,
  0xFC, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F, 0xCF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xF8, 0x3F, 0x3F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F,
  0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0xC7, 0xE0, 0xFE, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0x87, 0x07, 0xF0, 0x20, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0x01, 0xFC, 0x3C, 0x7F, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC7,
  0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF,
  0xC1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x07, 0xCF, 0xC0, 0x7D, 0xF8,
  0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC1, 0xFC,
  0x1F, 0xBF, 0x07, 0xF0, 0x7E, 0xFC, 0x1F, 0xC3, 0xFB, 0xF0, 0xFF, 0x0F,
  0xCF, 0xC3, 0xFC, 0x7F, 0x3F, 0x1F, 0xF1, 0xF8, 0xFC, 0x7F, 0xC7, 0xE3,
  0xF3, 0xFF, 0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F, 0x3F, 0xF3, 0xF0, 0xFD,
  0xF7, 0xDF, 0x83, 0xF7, 0xDF, 0x7E, 0x0F, 0xBE, 0x7F, 0xF0, 0x3E, 0xF9,
  0xFF, 0xC0, 0xFB, 0xE7, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xE3,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3,
  0xF0, 0x7E, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0,
  0xFB, 0xE0, 0x1F, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x7E, 0x7E, 0x3E, 0x1F, 0x0F, 0x01, 0x80, 0x20, 0xFC, 0xF8, 0x3F, 0xDF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0x7F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFE, 0xF8, 0x1F, 0x9F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x70,
  0x0F, 0xDF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0xC3, 0xE3, 0xE0, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xDC, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x18, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x18, 0xFE, 0x07, 0xEF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF1,
  0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE,
  0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x3E, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF9, 0xFC, 0xFD, 0xFC,
  0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x11, 0xFE, 0x78, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x90, 0x01, 0xFC, 0x00,
  0x0F, 0xC4, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xE0, 0x10, 0x3F, 0xBE, 0x07, 0xFB, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFD, 0xFE, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8,
  0x7F, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x80, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x38, 0x0F, 0xDF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC,
  0x7F, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7, 0xF1,
  0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x01, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC,
  0xFE, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x07, 0x01, 0x80, 0x7C, 0xFE, 0x7F, 0x03, 0xEF,
  0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF1,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF1,
  0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0x01, 0xF3, 0xF0, 0x3E, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x7F, 0x1F,
  0x8F, 0xE7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0xFE,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xF9, 0xFC, 0xFC, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x1F, 0xBF,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFB, 0xF9, 0xFD,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x1F, 0x7F, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x7F, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xDF,
  0xE0, 0x7E, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x20, 0xFE, 0xF8, 0x3F, 0xDF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF3, 0xF8, 0x7E, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x3F, 0x9F,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xBF,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x0F, 0x9F,
  0x0F, 0xBE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x8C,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x80, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0x87, 0xE3,
  0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC7, 0xF3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F,
  0x1F, 0xCF, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xF7, 0xC0, 0xFC, 0xF8, 0x00, 0xFC, 0x1F, 0xFF, 0x0F, 0xEF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3,
  0xF0, 0x7D, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x3F, 0x8F, 0xFF, 0x8F, 0xF1, 0xFB, 0xF1, 0xFE, 0x3F,
  0x7E, 0x7F, 0x8F, 0xCF, 0xCF, 0xF1, 0xF9, 0xF9, 0xFE, 0x7E, 0x3F, 0x7F,
  0xCF, 0xC7, 0xEF, 0x79, 0xF0, 0xFD, 0xEF, 0x7E, 0x1F, 0xFD, 0xEF, 0x83,
  0xFF, 0x3F, 0xF0, 0x7D, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x1F,
  0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC,
  0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x01, 0xF3, 0xF0,
  0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x03, 0xFC, 0x1F, 0xF0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0xBF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 25, 10, 0, -25 },
  { 39, 15, 9, 16, 3, -25 },
  { 56, 22, 25, 21, 0, -25 },
  { 125, 18, 29, 19, 1, -27 },
  { 191, 28, 25, 31, 2, -25 },
  { 279, 24, 25, 24, 0, -25 },
  { 354, 7, 9, 8, 3, -25 },
  { 362, 13, 32, 12, 1, -26 },
  { 414, 13, 32, 12, -2, -26 },
  { 466, 17, 17, 18, 2, -27 },
  { 503, 16, 17, 19, 2, -21 },
  { 537, 9, 9, 10, -2, -4 },
  { 548, 11, 5, 11, 0, -12 },
  { 555, 7, 6, 10, 0, -6 },
  { 561, 20, 25, 15, -2, -25 },
  { 624, 18, 25, 19, 1, -25 },
  { 681, 15, 25, 19, 3, -25 },
  { 728, 19, 25, 19, -1, -25 },
  { 788, 18, 25, 19, 0, -25 },
  { 845, 19, 25, 19, 0, -25 },
  { 905, 19, 25, 19, 0, -25 },
  { 965, 19, 25, 19, 1, -25 },
  { 1025, 20, 25, 19, 1, -25 },
  { 1088, 18, 25, 19, 1, -25 },
  { 1145, 17, 25, 19, 1, -25 },
  { 1199, 10, 20, 10, 0, -20 },
  { 1224, 12, 25, 10, -2, -20 },
  { 1262, 17, 19, 19, 1, -22 },
  { 1303, 16, 13, 19, 2, -19 },
  { 1329, 16, 19, 19, 2, -22 },
  { 1367, 15, 25, 16, 2, -25 },
  { 1414, 27, 28, 29, 1, -25 },
  { 1509, 22, 25, 22, -2, -25 },
  { 1578, 21, 25, 21, 0, -25 },
  { 1644, 20, 25, 20, 2, -25 },
  { 1707, 21, 25, 22, 0, -25 },
  { 1773, 19, 25, 18, 0, -25 },
  { 1833, 19, 25, 18, 0, -25 },
  { 1893, 21, 25, 23, 2, -25 },
  { 1959, 24, 25, 23, 0, -25 },
  { 2034, 17, 25, 14, -1, -25 },
  { 2088, 18, 33, 12, -6, -25 },
  { 2163, 24, 25, 21, 0, -25 },
  { 2238, 15, 25, 17, 0, -25 },
  { 2285, 30, 25, 30, 0, -25 },
  { 2379, 26, 25, 25, 0, -25 },
  { 2461, 21, 25, 24, 2, -25 },
  { 2527, 20, 25, 20, 0, -25 },
  { 2590, 21, 31, 24, 2, -25 },
  { 2672, 20, 25, 21, 0, -25 },
  { 2735, 19, 25, 18, 0, -25 },
  { 2795, 17, 25, 18, 3, -25 },
  { 2849, 21, 25, 23, 2, -25 },
  { 2915, 20, 25, 20, 3, -25 },
  { 2978, 30, 25, 30, 3, -25 },
  { 3072, 26, 25, 21, -2, -25 },
  { 3154, 20, 25, 20, 3, -25 },
  { 3217, 22, 25, 18, -2, -25 },
  { 3286, 15, 32, 12, -1, -26 },
  { 3346, 9, 25, 15, 4, -25 },
  { 3375, 15, 32, 12, -2, -26 },
  { 3435, 18, 16, 18, 0, -25 },
  { 3471, 16, 4, 15, -3, 2 },
  { 3479, 8, 6, 12, 5, -27 },
  { 3485, 19, 20, 20, 1, -20 },
  { 3533, 19, 27, 20, 0, -27 },
  { 3598, 16, 20, 16, 1, -20 },
  { 3638, 20, 27, 20, 1, -27 },
  { 3706, 17, 20, 19, 1, -20 },
  { 3749, 21, 35, 13, -4, -27 },
  { 3841, 20, 28, 20, 0, -20 },
  { 3911, 19, 27, 20, 0, -27 },
  { 3976, 12, 27, 10, 0, -27 },
  { 4017, 16, 35, 10, -4, -27 },
  { 4087, 22, 27, 20, 0, -27 },
  { 4162, 12, 27, 10, 0, -27 },
  { 4203, 29, 20, 30, 0, -20 },
  { 4276, 19, 20, 20, 0, -20 },
  { 4324, 17, 20, 20, 1, -20 },
  { 4367, 21, 28, 20, -2, -20 },
  { 4441, 19, 28, 20, 1, -20 },
  { 4508, 16, 20, 14, 0, -20 },
  { 4548, 16, 20, 16, 0, -20 },
  { 4588, 14, 23, 15, 1, -23 },
  { 4629, 19, 19, 20, 1, -19 },
  { 4675, 18, 19, 18, 2, -19 },
  { 4718, 27, 19, 27, 2, -19 },
  { 4783, 23, 19, 18, -2, -19 },
  { 4838, 22, 27, 18, -2, -19 },
  { 4913, 18, 19, 16, -1, -19 },
  { 4956, 15, 31, 12, 0, -25 },
  { 5015, 5, 35, 18, 6, -27 },
  { 5037, 14, 31, 12, -2, -25 },
  { 5092, 17, 7, 19, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC35PT7B_H_
