#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70, 0x00, 0x87, 0x8F,
  0x1E, 0x00, 0xF7, 0xE7, 0xEE, 0xEE, 0xCE, 0x07, 0x70, 0x33, 0x03, 0xB8,
  0x1D, 0xD7, 0xFF, 0x3F, 0xF8, 0x77, 0x03, 0x30, 0xFF, 0xE7, 0xFF, 0x0C,
  0xC0, 0x66, 0x07, 0x70, 0x3B, 0x80, 0x01, 0x00, 0xF8, 0x7F, 0x9F, 0xE3,
  0xA4, 0x74, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFA, 0x17, 0x3F, 0xC7, 0xF9,
  0xFE, 0x02, 0x00, 0xC0, 0x3E, 0x1C, 0x7E, 0x38, 0x66, 0x30, 0xEE, 0x70,
  0xEE, 0xE0, 0xEE, 0xCE, 0xFD, 0xDF, 0x7B, 0xBF, 0x03, 0x73, 0x07, 0x77,
  0x0E, 0x77, 0x0C, 0x77, 0x1C, 0x7E, 0x38, 0x3C, 0x0F, 0xC0, 0x7F, 0x81,
  0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x7F, 0x01, 0xF3, 0xDF, 0xDE, 0x77, 0xFB,
  0xCF, 0xCF, 0x3E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFE, 0xEE, 0xC0,
  0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x1C, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x3C, 0x71, 0xC0, 0x0E, 0x13,
  0x87, 0xE3, 0xFF, 0x3F, 0xCF, 0xF7, 0xE1, 0xDC, 0x17, 0x00, 0x1C, 0x0E,
  0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x3B, 0xDC,
  0xEE, 0x70, 0x7D, 0xFF, 0xC0, 0x2F, 0xFE, 0x00, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x01, 0xE0, 0x00, 0x04, 0x07, 0xC3, 0xF9, 0xFE, 0x7B, 0xFC, 0xFF, 0x3F,
  0xCE, 0xE3, 0xB9, 0xEE, 0x7B, 0x9C, 0xFF, 0x3F, 0x87, 0xC0, 0x0F, 0x1F,
  0x7F, 0xFE, 0xEE, 0x5E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x0F, 0xC3, 0xFC, 0x7F, 0x84, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0x1F, 0xCF, 0xF1, 0xFC,
  0x07, 0x03, 0xC7, 0xE1, 0xE0, 0x7E, 0x03, 0x80, 0xF8, 0x3F, 0xFE, 0xFF,
  0x3F, 0x80, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x8E, 0xE3,
  0x9C, 0x7F, 0xDF, 0xFB, 0xFF, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x1F, 0xE3,
  0xF8, 0x7F, 0x1E, 0x03, 0x80, 0x7F, 0x0F, 0xE3, 0xFE, 0x03, 0xC0, 0x7A,
  0x1E, 0x7F, 0xCF, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xF3, 0xED, 0xE0, 0x72,
  0x3F, 0xCF, 0xFB, 0xDE, 0xF7, 0xB9, 0xEE, 0x7B, 0xFC, 0xFF, 0x1F, 0x80,
  0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x02, 0x01, 0xF8,
  0x7F, 0x9E, 0xF3, 0xDE, 0x7B, 0x87, 0xE0, 0xF8, 0x3F, 0x8F, 0x79, 0xCF,
  0x79, 0xEF, 0xF8, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0xE7, 0xFB, 0xCE, 0xF3,
  0xFC, 0xEF, 0xFB, 0xFE, 0x7F, 0x81, 0xC0, 0xF3, 0xF8, 0xFC, 0x3E, 0x00,
  0x3C, 0xF3, 0xC4, 0x00, 0x00, 0x08, 0xF3, 0xCF, 0x00, 0x1E, 0x3C, 0x78,
  0x40, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0x80,
  0xC1, 0xE3, 0xF7, 0xE7, 0x83, 0xE0, 0xFE, 0x0F, 0x81, 0xC0, 0x20, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x3C, 0x1F,
  0x83, 0xF0, 0x3C, 0x3E, 0x7E, 0xFC, 0x70, 0x20, 0x00, 0x7F, 0x3F, 0x9F,
  0xE8, 0xF0, 0xF0, 0xF8, 0xF0, 0x70, 0x70, 0x00, 0x08, 0x1E, 0x0F, 0x07,
  0x80, 0x07, 0xF8, 0x3F, 0xF8, 0xE0, 0x73, 0x8E, 0x76, 0x7F, 0x7D, 0xEC,
  0xF3, 0xB9, 0xE6, 0x73, 0xDC, 0xCF, 0xBB, 0xBB, 0x3F, 0xE7, 0x73, 0x8E,
  0x00, 0x0F, 0x38, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0xEF, 0x1E, 0xF1, 0xCF, 0x3F, 0xF3, 0xFF, 0x7F, 0xF7,
  0x87, 0x70, 0x7F, 0x07, 0x1F, 0xE1, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xE3,
  0xFE, 0x3F, 0x83, 0xFC, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xFC, 0xFF, 0x8F,
  0xF0, 0x01, 0x01, 0xFC, 0x7F, 0x9F, 0xE7, 0x84, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x4F, 0xF8, 0xFF, 0x0F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0x38, 0xF3, 0x8F, 0x78, 0xF7,
  0x9E, 0x7B, 0xE7, 0xFC, 0xFF, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x7F, 0x1E,
  0x03, 0xC0, 0x7F, 0x8F, 0xE1, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xCF,
  0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0xE1, 0xFC, 0x7F, 0x8F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0x00, 0xFF, 0x1F, 0xE3, 0xFE, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x3E, 0xF7,
  0xEF, 0x7E, 0xF1, 0xCF, 0x1C, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x1E, 0x3C,
  0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x78, 0xF1, 0xE3, 0x87, 0x8E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x1F,
  0xC7, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0xF8, 0x7F, 0x3F, 0x80, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE3,
  0xF8, 0xFC, 0x3E, 0x04, 0x00, 0x1E, 0x7C, 0x73, 0xE1, 0xCF, 0x0F, 0x78,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xEF, 0x07, 0xBC,
  0x1C, 0xF0, 0xF1, 0xE3, 0xC7, 0x80, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xF7, 0xF8, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFD,
  0xDC, 0x7E, 0xFE, 0x7F, 0xEE, 0x3B, 0xF7, 0x1D, 0xF3, 0x8E, 0xFB, 0xCF,
  0x79, 0xE7, 0xBC, 0xE0, 0x1F, 0x1E, 0x3E, 0x38, 0x7C, 0x71, 0xF8, 0xE3,
  0xFB, 0xC7, 0x77, 0x8E, 0xEE, 0x1D, 0xDC, 0x7B, 0xF8, 0xE3, 0xF1, 0xC7,
  0xE3, 0x8F, 0x8F, 0x1F, 0x1E, 0x1E, 0x00, 0x01, 0x00, 0xFE, 0x1F, 0xE3,
  0xFF, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF,
  0x1E, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xCF,
  0x3C, 0xE3, 0xDE, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0x00, 0xFE, 0x1F, 0xE3, 0xFF, 0x78, 0xF7, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0x3E, 0xFF, 0xC7, 0xF8,
  0x3F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xCF,
  0x3C, 0xE3, 0xDE, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0xB8, 0x7B, 0xC7, 0x3C,
  0xF1, 0xCF, 0x1E, 0x1F, 0xE3, 0xF8, 0xFF, 0x1E, 0x23, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF3, 0x1E, 0x7F, 0xCF, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE7, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x0F, 0x07, 0x80, 0x3C, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x9E,
  0x71, 0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0xF3, 0xCF, 0xF8, 0x7F, 0x83, 0xF0,
  0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x79, 0xCE, 0x39, 0xC7, 0x78, 0xEE,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0xE3, 0xC7, 0xF1, 0xE3,
  0xB8, 0xF3, 0xDC, 0xF9, 0xCE, 0x7C, 0xE7, 0x7E, 0xF3, 0xBF, 0x71, 0xDB,
  0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x1F, 0x07,
  0x8F, 0x00, 0x1E, 0x3E, 0x1C, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xF7, 0x81, 0xCF,
  0x07, 0x8E, 0x1E, 0x1E, 0x00, 0xF1, 0xFE, 0x7B, 0xDE, 0x3B, 0xC7, 0xF0,
  0xFC, 0x1F, 0x83, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0xFC, 0xFF, 0xCF, 0xFC, 0x0F, 0x87,
  0xC3, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x7C, 0x7C, 0x00, 0xE7, 0x18, 0xE7, 0x39, 0xCE,
  0x71, 0xCE, 0x73, 0x9C, 0x1F, 0x1F, 0x1F, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0xF8, 0xF8, 0x07, 0x01,
  0xC0, 0xF0, 0x7E, 0x1F, 0x8E, 0xE3, 0x19, 0xC7, 0xE1, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xF3, 0x8E, 0x3D, 0xDF, 0xF7, 0xFF, 0xCE, 0xF3, 0xB8, 0xEE,
  0x7B, 0x9E, 0xFF, 0x3F, 0xC7, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xFC, 0x7F, 0x8F, 0xF9, 0xCF, 0x79, 0xEF, 0x39, 0xC7, 0x39, 0xE7, 0xF9,
  0xFF, 0x3B, 0xC0, 0x1F, 0x9F, 0x9F, 0xDE, 0x0F, 0x07, 0x03, 0x81, 0xC4,
  0xFE, 0x7F, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE3, 0xDC, 0xFF,
  0x9F, 0xF7, 0x9C, 0xF3, 0x9C, 0x73, 0x9E, 0x73, 0xCF, 0xF1, 0xFE, 0x1D,
  0xC0, 0x1F, 0x1F, 0xDE, 0xFE, 0x7F, 0xFF, 0xFB, 0xF1, 0xC0, 0xF7, 0x7F,
  0x9F, 0x80, 0x01, 0xF0, 0x3E, 0x07, 0xA0, 0x78, 0x0F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x1E, 0xE7, 0xFC, 0xFF,
  0xBC, 0xE7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9E, 0x7F, 0x8F, 0xF0, 0xEE, 0x03,
  0xC8, 0x71, 0xFE, 0x3F, 0x83, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xFC, 0x7F, 0xCF, 0xF9, 0xCF, 0x79, 0xEF, 0x39, 0xE7, 0x39, 0xE7, 0x3D,
  0xE7, 0xBC, 0xE0, 0x08, 0x3C, 0x78, 0xE0, 0x07, 0x8F, 0x1C, 0x38, 0xF1,
  0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0x00, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x01,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x0F, 0xC3, 0xE0, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0xF3, 0xDE, 0x3B, 0xC3, 0xB8, 0x7F, 0x07, 0xF0, 0x7F,
  0x87, 0xF8, 0x73, 0x8F, 0x3C, 0xF3, 0xC0, 0x1E, 0x38, 0x71, 0xE3, 0xC7,
  0x8E, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x00, 0x3B, 0xCF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x39, 0xE7, 0x79, 0xE7, 0x79, 0xCF, 0x79, 0xCF, 0x73,
  0xCF, 0x73, 0xCE, 0xF3, 0xCE, 0xF3, 0x9E, 0x3B, 0xC7, 0xFC, 0xFF, 0x9C,
  0xF7, 0x9E, 0xF3, 0x9E, 0x73, 0x9E, 0x73, 0xDE, 0x7B, 0xCE, 0x00, 0x1F,
  0x0F, 0xE7, 0xFB, 0xCF, 0xF3, 0xF8, 0xEE, 0x3B, 0x9E, 0xFF, 0x3F, 0xC7,
  0xC0, 0x1D, 0xE1, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0xCE, 0x38, 0xE3,
  0x9E, 0x3F, 0xC7, 0xFC, 0x7F, 0x87, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0x3D, 0xDF, 0xF7, 0xFF, 0xCE, 0xF3, 0xB8, 0xEE, 0x7B, 0x9E, 0xFF,
  0x3F, 0xC7, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x3B, 0x9F, 0xCF,
  0xC7, 0x97, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x00, 0x1F, 0x9F,
  0xDE, 0x4F, 0x07, 0xE1, 0xF8, 0x7C, 0x1E, 0xFF, 0x7F, 0x3F, 0x00, 0x1C,
  0x38, 0x7F, 0xFE, 0xFE, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xFC, 0xFC, 0x7C,
  0x79, 0xDE, 0x77, 0x3D, 0xCF, 0xF3, 0xBC, 0xEE, 0x7B, 0x9E, 0xFF, 0xBF,
  0xC7, 0x70, 0xF3, 0xFC, 0xFF, 0x7B, 0xDE, 0xF7, 0x1F, 0xC7, 0xE1, 0xF0,
  0x7C, 0x1E, 0x07, 0x80, 0xF3, 0xCF, 0xE7, 0xDE, 0xE7, 0xDC, 0xEF, 0x9C,
  0xEF, 0xB8, 0xED, 0xB8, 0xFD, 0xF8, 0xFD, 0xF0, 0xF9, 0xF0, 0xF9, 0xE0,
  0xF1, 0xE0, 0x3C, 0xF8, 0xF7, 0x87, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x3B, 0xC3, 0xDE, 0x3C, 0xF0, 0x3C, 0xF3, 0xCF, 0x3D,
  0xE3, 0xDE, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x0E, 0x00, 0x1F, 0xE3, 0xF8, 0xFF,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x7F, 0x8F, 0xF3, 0xFC, 0x00,
  0x07, 0x87, 0x87, 0x83, 0x81, 0xC0, 0xE0, 0xF1, 0xF0, 0xE0, 0x78, 0x1E,
  0x0F, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1C, 0x1E, 0x3E, 0x0E, 0x0E, 0x1C, 0x1E, 0x0F, 0x07, 0x1F, 0x3C,
  0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0x78, 0xFF, 0xFF, 0xF0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 14, 6, 0, -14 },
  { 14, 8, 5, 9, 2, -14 },
  { 19, 13, 14, 12, 0, -14 },
  { 42, 11, 16, 11, 0, -15 },
  { 64, 16, 14, 18, 1, -14 },
  { 92, 14, 14, 14, 0, -14 },
  { 117, 4, 5, 5, 2, -14 },
  { 120, 8, 18, 7, 0, -15 },
  { 138, 7, 18, 7, -1, -15 },
  { 154, 10, 9, 10, 1, -15 },
  { 166, 9, 10, 11, 1, -12 },
  { 178, 5, 6, 6, -1, -3 },
  { 182, 6, 3, 6, 0, -7 },
  { 185, 4, 4, 6, 0, -4 },
  { 187, 11, 14, 9, -1, -14 },
  { 207, 10, 15, 11, 1, -15 },
  { 226, 8, 14, 11, 2, -14 },
  { 240, 11, 14, 11, -1, -14 },
  { 260, 10, 14, 11, 0, -14 },
  { 278, 11, 14, 11, 0, -14 },
  { 298, 11, 14, 11, 0, -14 },
  { 318, 10, 14, 11, 1, -14 },
  { 336, 12, 14, 11, 0, -14 },
  { 357, 11, 15, 11, 0, -15 },
  { 378, 10, 14, 11, 1, -14 },
  { 396, 6, 11, 6, 0, -11 },
  { 405, 7, 14, 6, -1, -11 },
  { 418, 9, 11, 11, 1, -13 },
  { 431, 9, 8, 11, 1, -11 },
  { 440, 9, 11, 11, 1, -13 },
  { 453, 9, 14, 9, 1, -14 },
  { 469, 15, 16, 17, 1, -14 },
  { 499, 12, 14, 12, -1, -14 },
  { 520, 12, 14, 12, 0, -14 },
  { 541, 11, 15, 11, 1, -15 },
  { 562, 12, 14, 13, 0, -14 },
  { 583, 11, 14, 10, 0, -14 },
  { 603, 11, 14, 10, 0, -14 },
  { 623, 12, 15, 13, 1, -15 },
  { 646, 14, 14, 13, 0, -14 },
  { 671, 10, 14, 8, -1, -14 },
  { 689, 10, 19, 7, -3, -14 },
  { 713, 14, 14, 12, 0, -14 },
  { 738, 9, 14, 10, 0, -14 },
  { 754, 17, 14, 17, 0, -14 },
  { 784, 15, 14, 14, 0, -14 },
  { 811, 12, 15, 14, 1, -15 },
  { 834, 12, 14, 11, 0, -14 },
  { 855, 12, 18, 14, 1, -15 },
  { 882, 12, 14, 12, 0, -14 },
  { 903, 11, 14, 10, 0, -14 },
  { 923, 9, 14, 10, 2, -14 },
  { 939, 12, 14, 13, 1, -14 },
  { 960, 11, 14, 12, 2, -14 },
  { 980, 17, 14, 17, 2, -14 },
  { 1010, 15, 14, 12, -1, -14 },
  { 1037, 11, 14, 11, 2, -14 },
  { 1057, 12, 14, 10, -1, -14 },
  { 1078, 9, 18, 7, -1, -15 },
  { 1099, 5, 14, 9, 2, -14 },
  { 1108, 8, 18, 7, -1, -15 },
  { 1126, 10, 9, 10, 0, -14 },
  { 1138, 9, 3, 9, -2, 1 },
  { 1142, 5, 3, 7, 3, -15 },
  { 1144, 10, 11, 11, 1, -11 },
  { 1158, 11, 15, 11, 0, -15 },
  { 1179, 9, 11, 9, 1, -11 },
  { 1192, 11, 15, 11, 1, -15 },
  { 1213, 9, 11, 11, 1, -11 },
  { 1226, 12, 20, 7, -2, -15 },
  { 1256, 11, 16, 11, 0, -11 },
  { 1278, 11, 15, 11, 0, -15 },
  { 1299, 7, 16, 6, 0, -16 },
  { 1313, 10, 21, 6, -3, -16 },
  { 1340, 12, 15, 11, 0, -15 },
  { 1363, 7, 15, 6, 0, -15 },
  { 1377, 16, 11, 17, 0, -11 },
  { 1399, 11, 11, 11, 0, -11 },
  { 1415, 10, 11, 11, 1, -11 },
  { 1429, 12, 16, 11, -1, -11 },
  { 1453, 10, 16, 11, 1, -11 },
  { 1473, 9, 11, 8, 0, -11 },
  { 1486, 9, 11, 9, 0, -11 },
  { 1499, 8, 13, 8, 1, -13 },
  { 1512, 10, 11, 11, 1, -11 },
  { 1526, 10, 11, 10, 1, -11 },
  { 1540, 16, 11, 15, 1, -11 },
  { 1562, 13, 11, 11, -1, -11 },
  { 1580, 12, 16, 10, -1, -11 },
  { 1604, 11, 11, 9, -1, -11 },
  { 1620, 9, 17, 7, 0, -14 },
  { 1640, 2, 20, 10, 4, -15 },
  { 1645, 8, 17, 7, -1, -14 },
  { 1662, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC20PT7B_H_
