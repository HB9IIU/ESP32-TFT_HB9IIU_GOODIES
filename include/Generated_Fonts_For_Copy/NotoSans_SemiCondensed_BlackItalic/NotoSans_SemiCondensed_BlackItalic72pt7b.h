#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xE3, 0xF8,
  0x07, 0xFF, 0x9F, 0x03, 0xC0, 0x3F, 0xF8, 0xF8, 0x04, 0x01, 0xFF, 0xC7,
  0xC0, 0x00, 0x0F, 0xFE, 0x7C, 0x00, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x03,
  0xFF, 0xDF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xEF, 0xFF, 0x00, 0x00, 0x1F, 0x7F,
  0xF8, 0x00, 0x00, 0xF9, 0xFF, 0xC2, 0x00, 0x0F, 0x8F, 0xFE, 0x1C, 0x00,
  0x7C, 0x7F, 0xF0, 0xF8, 0x03, 0xE7, 0xFF, 0x87, 0xF8, 0x1F, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x03, 0x80, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0x3F, 0xF8, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC1, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x60, 0x0F, 0xFC, 0x00, 0x3C, 0x07, 0xFC, 0x00, 0x1F, 0x03, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0x83, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0xC0, 0x01, 0xC0, 0x7F, 0xC0, 0x00,
  0x40, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x03, 0xC0, 0x3F, 0xC3,
  0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F,
  0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF,
  0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xC0,
  0x1F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F,
  0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF,
  0xEF, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0x80,
  0x7F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xCF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFE, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xE7,
  0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0x80, 0xFC, 0x1F, 0xFE, 0x00, 0xF0, 0x7F,
  0xFC, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0xF0, 0x01, 0xFE, 0x03,
  0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x0F, 0xFF, 0x80,
  0x03, 0x00, 0x1F, 0xFF, 0x00, 0x04, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x1C, 0x00,
  0xFF, 0xFC, 0x00, 0x40, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x88, 0x00, 0x00, 0x7F, 0xFC, 0x30, 0x00, 0x03, 0xFF, 0xF0, 0xF0, 0x00,
  0x1F, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0xDF,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x1F, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0x87,
  0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x82, 0x00, 0x00, 0x7F, 0xFE, 0x0C, 0x00, 0x01,
  0xFF, 0xF8, 0x3C, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xF0,
  0x03, 0xFF, 0xCF, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xEF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xC3,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF,
  0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE,
  0x07, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F,
  0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF,
  0xBF, 0xFE, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xF8, 0x0F,
  0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFB, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x10, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0x01, 0xFF, 0xF0, 0xF0, 0x03, 0xFF, 0xE0, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x7F, 0x83, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xFE,
  0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF,
  0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE1,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE1, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF7,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x00,
  0x1E, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x20, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE3,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFD,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7,
  0xFE, 0x0F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF0, 0xFF, 0xCF, 0xFF,
  0x00, 0x3F, 0xFD, 0xFF, 0x87, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFC,
  0x7F, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE3, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0xF3, 0xFF, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xF9, 0xFF,
  0x8F, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xCF, 0xFC, 0x7F, 0xF8, 0x01, 0xFF,
  0xE7, 0xFE, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF7, 0xFE, 0x3F,
  0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x8F,
  0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x07,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F,
  0xF9, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xF9, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x07,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF1,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF3, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xCF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x9F, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF, 0xC7, 0xFF,
  0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x01, 0x00, 0x00, 0x7F, 0xFC,
  0x07, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x8F, 0xFF, 0x80, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00,
  0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F,
  0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xF7, 0xFE, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x7F, 0xF1, 0xFF, 0xE0, 0x03, 0xFF,
  0xCF, 0xFE, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xF9, 0xFF, 0x8F,
  0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0xE7, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0xFF,
  0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x1F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFC, 0x3F, 0xF7, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xBF,
  0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80,
  0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF,
  0x00, 0xFF, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF9,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x81, 0x80,
  0x00, 0x1F, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x03, 0xFF,
  0xDF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xF8,
  0x03, 0xFF, 0x87, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0x01, 0xFF, 0xFC, 0x01, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x04, 0x03, 0xFF, 0xE0, 0x0E, 0x01, 0xFF, 0xF8, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x04, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xDF, 0xFF, 0x00, 0x0F, 0xFF, 0xF7, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF9, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFF, 0xCF, 0xFE, 0x00, 0x03,
  0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xF8, 0x1F, 0xFE,
  0x3F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xF0, 0x1F,
  0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x10, 0x1F, 0xFF, 0x00, 0x0E, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x20, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x39, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF9, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0x8F,
  0xFF, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x03, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xFB,
  0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F,
  0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE7,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x1F, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F,
  0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE, 0x01, 0xFF,
  0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0xC0,
  0x3F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF,
  0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF,
  0xCF, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x9F, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xC7,
  0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xF9, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xC1, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x80, 0x3F,
  0xF0, 0x7F, 0x80, 0x3F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF8, 0x03,
  0xFF, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x40, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x80, 0x70, 0x0F, 0xFF, 0x80, 0x10,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x80, 0x01, 0xFF, 0xF0, 0xF0, 0x03, 0xFF, 0xF0,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x00,
  0x7F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xEF,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xDF,
  0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF, 0xBF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF3,
  0xFE, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xE7, 0xFD, 0xFF, 0x1F, 0xFE, 0x03,
  0xFF, 0xCF, 0xFB, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF,
  0xF0, 0x07, 0xFF, 0x7F, 0xCF, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0x9F,
  0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x3F, 0xEF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x7F, 0xDF, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC7,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x47, 0xFF, 0xE0,
  0x00, 0x37, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFB, 0x00, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x0F, 0xFC,
  0x20, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 24, 52, 21, 0, -51 },
  { 157, 31, 18, 33, 6, -51 },
  { 227, 45, 51, 43, 0, -51 },
  { 514, 37, 59, 39, 2, -55 },
  { 787, 58, 53, 63, 4, -52 },
  { 1172, 49, 53, 49, 0, -52 },
  { 1497, 15, 18, 17, 6, -51 },
  { 1531, 28, 64, 24, 2, -53 },
  { 1755, 28, 64, 24, -5, -53 },
  { 1979, 33, 35, 36, 5, -55 },
  { 2124, 34, 35, 40, 3, -43 },
  { 2273, 19, 19, 21, -4, -9 },
  { 2319, 21, 11, 23, 1, -25 },
  { 2348, 14, 14, 21, 0, -13 },
  { 2373, 41, 53, 32, -4, -52 },
  { 2645, 36, 53, 39, 2, -52 },
  { 2884, 31, 51, 39, 6, -51 },
  { 3082, 39, 52, 39, -2, -52 },
  { 3336, 38, 53, 39, 0, -52 },
  { 3588, 39, 51, 39, 0, -51 },
  { 3837, 38, 52, 39, 1, -51 },
  { 4084, 37, 53, 39, 3, -52 },
  { 4330, 40, 51, 39, 2, -51 },
  { 4585, 38, 53, 39, 1, -52 },
  { 4837, 35, 53, 39, 3, -52 },
  { 5069, 21, 41, 21, 0, -40 },
  { 5177, 25, 50, 21, -4, -40 },
  { 5334, 34, 38, 40, 3, -45 },
  { 5496, 34, 25, 40, 3, -38 },
  { 5603, 34, 38, 40, 3, -45 },
  { 5765, 31, 53, 32, 4, -52 },
  { 5971, 56, 58, 60, 2, -52 },
  { 6377, 44, 51, 45, -4, -51 },
  { 6658, 41, 51, 43, 1, -51 },
  { 6920, 41, 53, 41, 3, -52 },
  { 7192, 43, 51, 46, 1, -51 },
  { 7467, 38, 51, 37, 1, -51 },
  { 7710, 38, 51, 37, 1, -51 },
  { 7953, 44, 53, 46, 3, -52 },
  { 8245, 48, 51, 47, 1, -51 },
  { 8551, 37, 51, 29, -3, -51 },
  { 8787, 37, 67, 24, -11, -51 },
  { 9097, 49, 51, 44, 1, -51 },
  { 9410, 30, 51, 35, 1, -51 },
  { 9602, 61, 51, 61, 1, -51 },
  { 9991, 52, 51, 52, 1, -51 },
  { 10323, 44, 53, 49, 3, -52 },
  { 10615, 40, 51, 41, 1, -51 },
  { 10870, 44, 64, 49, 3, -52 },
  { 11222, 41, 51, 43, 1, -51 },
  { 11484, 38, 53, 37, 0, -52 },
  { 11736, 35, 51, 37, 6, -51 },
  { 11960, 44, 52, 46, 4, -51 },
  { 12246, 42, 51, 42, 6, -51 },
  { 12514, 63, 51, 62, 6, -51 },
  { 12916, 53, 51, 43, -4, -51 },
  { 13254, 41, 51, 40, 6, -51 },
  { 13516, 44, 51, 36, -3, -51 },
  { 13797, 32, 65, 24, -3, -53 },
  { 14057, 19, 53, 32, 7, -52 },
  { 14183, 32, 65, 24, -5, -53 },
  { 14443, 38, 33, 37, -1, -51 },
  { 14600, 33, 8, 31, -7, 5 },
  { 14633, 17, 11, 25, 10, -55 },
  { 14657, 38, 42, 41, 2, -41 },
  { 14857, 38, 56, 41, 0, -55 },
  { 15123, 33, 42, 33, 2, -41 },
  { 15297, 42, 56, 40, 2, -55 },
  { 15591, 35, 42, 39, 2, -41 },
  { 15775, 42, 72, 27, -8, -55 },
  { 16153, 40, 58, 41, 0, -41 },
  { 16443, 39, 55, 41, 0, -55 },
  { 16712, 24, 56, 21, 0, -56 },
  { 16880, 33, 73, 21, -9, -56 },
  { 17182, 45, 55, 41, 0, -55 },
  { 17492, 25, 55, 21, 0, -55 },
  { 17664, 59, 41, 61, 0, -41 },
  { 17967, 39, 41, 41, 0, -41 },
  { 18167, 36, 42, 40, 2, -41 },
  { 18356, 41, 58, 41, -3, -41 },
  { 18654, 38, 58, 41, 2, -41 },
  { 18930, 33, 41, 29, 0, -41 },
  { 19100, 32, 42, 33, 1, -41 },
  { 19268, 28, 49, 30, 3, -48 },
  { 19440, 38, 41, 41, 3, -40 },
  { 19635, 37, 40, 37, 4, -40 },
  { 19820, 55, 40, 55, 4, -40 },
  { 20095, 46, 40, 38, -4, -40 },
  { 20325, 45, 57, 37, -4, -40 },
  { 20646, 36, 40, 32, -2, -40 },
  { 20826, 31, 62, 25, 0, -51 },
  { 21067, 10, 71, 36, 13, -55 },
  { 21156, 30, 62, 25, -4, -51 },
  { 21389, 34, 14, 40, 3, -32 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC72PT7B_H_
