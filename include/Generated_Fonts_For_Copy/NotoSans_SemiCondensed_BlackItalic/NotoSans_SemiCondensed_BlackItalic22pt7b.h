#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF0, 0x00, 0x07,
  0x1E, 0x3C, 0x78, 0x77, 0xBB, 0xFD, 0xFE, 0xEE, 0x77, 0x38, 0x03, 0x38,
  0x1C, 0xE0, 0x77, 0x01, 0x9C, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xC3, 0x38,
  0x1C, 0xC3, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0x3B, 0x80, 0xEE, 0x07, 0x38,
  0x1D, 0xC0, 0x03, 0x00, 0x60, 0x7F, 0x1F, 0xF7, 0xFC, 0xFC, 0x9F, 0x83,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE8, 0xBD, 0xFF, 0x3F, 0xE7, 0xF0,
  0x18, 0x02, 0x00, 0x1E, 0x07, 0x0F, 0xC3, 0x87, 0xF1, 0xC1, 0xDC, 0x70,
  0xE7, 0x38, 0x39, 0xDC, 0x0E, 0xF7, 0x33, 0xFB, 0xBE, 0x7D, 0xDF, 0xCE,
  0x77, 0x70, 0x3B, 0x9C, 0x1C, 0xE7, 0x07, 0x3B, 0x83, 0x8E, 0xE1, 0xC3,
  0xF8, 0xF0, 0x7C, 0x03, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0x3F, 0x9E, 0xFF, 0xFB, 0xCF, 0xF7,
  0x9F, 0xCF, 0x1F, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xBE, 0x77, 0xFF, 0xEE,
  0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x07, 0x03, 0x81, 0xE0, 0xF0,
  0x78, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1C, 0x3E, 0x00, 0x0C, 0x03, 0x8C, 0xE3, 0xB0, 0xFF, 0xDF,
  0xF3, 0xFD, 0xF8, 0xF7, 0x09, 0xC0, 0x40, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3D, 0xE7, 0x9C,
  0xF3, 0x80, 0x7E, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x83, 0xF8, 0xFF,
  0x3F, 0xF7, 0x9E, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xDE, 0x7B, 0xCF, 0x79,
  0xEF, 0x79, 0xFF, 0x3F, 0xC3, 0xE0, 0x03, 0x87, 0xC7, 0xEF, 0xFF, 0xF7,
  0xF9, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78,
  0x03, 0xC0, 0xFF, 0x1F, 0xF0, 0xFF, 0x08, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFE, 0x7F, 0xEF, 0xFC,
  0x0F, 0x83, 0xFE, 0x1F, 0xE1, 0x9F, 0x00, 0xE0, 0x1E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xFC, 0x03, 0xE0, 0x3E, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0,
  0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xFE, 0x1D, 0xE3, 0xFC,
  0x3B, 0xC7, 0x3C, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1C, 0x03, 0xC0, 0x3F, 0x83, 0xFC,
  0x3F, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0xC3, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0,
  0x03, 0xE1, 0xFC, 0x7F, 0x9F, 0x17, 0x80, 0xF2, 0x3D, 0xE7, 0xFE, 0xFF,
  0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0x7D, 0xFF, 0x1F, 0xC1, 0xF0, 0x1F, 0xF9,
  0xFF, 0xCF, 0xFC, 0x7F, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x1F, 0xE1, 0xF8,
  0x1F, 0xC7, 0xFC, 0x79, 0xE7, 0x1E, 0xF1, 0xE7, 0xFC, 0x7F, 0xC3, 0xF0,
  0x0F, 0x07, 0xF1, 0xFF, 0x3D, 0xE7, 0x9F, 0xE3, 0xFC, 0xFF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xEF, 0x03, 0xC0, 0xF1, 0xFE, 0x3F, 0x87, 0xC0, 0x1C, 0xF3,
  0xC6, 0x00, 0x00, 0x00, 0x73, 0xCF, 0x3C, 0x0E, 0x3C, 0x78, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x71, 0xE3, 0xC7, 0x1E, 0x38, 0x00, 0x00, 0x40, 0x30,
  0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x81, 0xF8, 0x1F, 0xC1, 0xF0, 0x1C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x0F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x7C, 0x7F, 0x7E, 0x3E, 0x0E, 0x02,
  0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0xCF, 0x43, 0xC1, 0xE0, 0xF8, 0x78, 0x3C,
  0x0E, 0x04, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xC0, 0x01, 0xF8, 0x03,
  0xFE, 0x07, 0xC7, 0x87, 0x80, 0xE3, 0x8F, 0x3B, 0x9F, 0xDD, 0x9F, 0xCF,
  0xCE, 0xE7, 0xEE, 0x73, 0xE7, 0x39, 0xB3, 0x99, 0xD9, 0xFF, 0xCE, 0xFF,
  0xC7, 0x19, 0xC3, 0xC0, 0x00, 0xFB, 0xE0, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1,
  0xEF, 0x1E, 0x78, 0xF3, 0xCF, 0xFE, 0x7F, 0xF7, 0xFF, 0xBC, 0x3F, 0xE1,
  0xFE, 0x0F, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3D, 0xF1, 0xE7, 0x9E, 0x3C,
  0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xEF, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F,
  0xF3, 0xFF, 0x1F, 0xF0, 0x07, 0xE0, 0x7F, 0xC7, 0xFC, 0x7C, 0xC7, 0xC2,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x8C, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F,
  0xF1, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xDE, 0x3E,
  0xF1, 0xE7, 0xBF, 0x3F, 0xF3, 0xFF, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x1E, 0x03, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x7F, 0xC7,
  0xFE, 0x7E, 0xE7, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x7E, 0xF3, 0xF7, 0x9F,
  0xBC, 0x3D, 0xE1, 0xCF, 0x9E, 0x3F, 0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x1E,
  0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E,
  0x3E, 0x3C, 0x78, 0x78, 0x1F, 0xE3, 0xFC, 0x7F, 0x83, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xFE, 0x1F,
  0xC7, 0xF8, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x05, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x1E,
  0x3C, 0x78, 0x79, 0xF0, 0xF7, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x3E, 0x7C, 0x78, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x5F, 0xEF, 0xFB, 0xFE,
  0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFD, 0xDE, 0x3B, 0xBB, 0x87, 0x7F, 0xF1,
  0xEF, 0xDE, 0x3D, 0xFB, 0xC7, 0xBE, 0x70, 0xE7, 0xCE, 0x3C, 0xF3, 0xC7,
  0x9E, 0x78, 0x1F, 0x07, 0x1F, 0x0F, 0x1F, 0x8F, 0x1F, 0x8F, 0x1F, 0x8E,
  0x3F, 0x8E, 0x3F, 0xDE, 0x3F, 0xDE, 0x39, 0xDE, 0x39, 0xDC, 0x79, 0xFC,
  0x79, 0xFC, 0x78, 0xFC, 0x70, 0xF8, 0xF0, 0xF8, 0xF0, 0xF8, 0x03, 0xE0,
  0x7F, 0x87, 0xFE, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xEF, 0x9F, 0x3F, 0xF1, 0xFF, 0x07, 0xF0,
  0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7,
  0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xEF, 0x9F, 0x3F,
  0xF1, 0xFF, 0x07, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x80, 0xFF, 0x87, 0xFC, 0x3D, 0xF1, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0xFE,
  0x3F, 0xE1, 0xFE, 0x1E, 0xF0, 0xF7, 0x87, 0x9E, 0x3C, 0xF3, 0xE7, 0xDE,
  0x1E, 0x07, 0xC1, 0xFF, 0x1F, 0xE3, 0xEE, 0x3C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC8, 0x3C, 0xE7, 0xCF, 0xF8, 0xFF, 0x87,
  0xE0, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xE1, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0x3C,
  0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xFB, 0xE3, 0xFF, 0x07,
  0xFC, 0x0F, 0xC0, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x79,
  0xE3, 0xCF, 0x1E, 0xF0, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x3B, 0xC7, 0x8F,
  0x79, 0xF1, 0xEE, 0x3E, 0x79, 0xCF, 0xCF, 0x39, 0xF9, 0xC7, 0x3F, 0x78,
  0xEE, 0xEF, 0x1D, 0xDF, 0xC3, 0xFB, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x0F, 0x1E, 0x0F,
  0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78,
  0xF8, 0xF0, 0xF8, 0xF0, 0xFF, 0x1E, 0xF1, 0xE7, 0x3C, 0x7B, 0xC7, 0xF8,
  0x7F, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x3F, 0xF3, 0xFF, 0x9F, 0xF8, 0x0F, 0xC3, 0xF0, 0xF8, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1F, 0x0F, 0xC3, 0xF0, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1E,
  0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xC7, 0x07, 0xC3, 0xF0, 0xFC, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x1F, 0x07, 0xC3, 0xF0, 0x03, 0x00, 0x70, 0x1E, 0x07,
  0xC0, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x70, 0xEE, 0x1F, 0x83, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0xF3, 0xCE, 0x30, 0x1E, 0xE7, 0xFD, 0xFF, 0xBD, 0xFF,
  0x1D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF7, 0xDF, 0xF3, 0xFE, 0x3D, 0xC0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xDE, 0x3F, 0xE3, 0xFF, 0x3C,
  0xF3, 0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xE7, 0xBE, 0x7F, 0xCF, 0xFC, 0xE7,
  0x80, 0x1F, 0xCF, 0xE7, 0xF9, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF1,
  0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE1,
  0xFE, 0x3F, 0xE7, 0xFE, 0x7B, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x7C, 0xFF, 0x8F, 0xF8, 0x7B, 0x80, 0x1F, 0x8F, 0xF7, 0xBD, 0xE7, 0xF3,
  0xFF, 0xFF, 0xF3, 0xC0, 0xF0, 0xBF, 0xEF, 0xF8, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xA0, 0x78, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x71, 0xFF,
  0x3F, 0xF3, 0xDF, 0x78, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x7B, 0xE7, 0xFC,
  0x7F, 0xC3, 0xFC, 0x03, 0xC8, 0x78, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xDE, 0x3F, 0xF3, 0xFF, 0x3C,
  0xF3, 0xCF, 0x78, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x1C, 0xF3,
  0xC0, 0x0E, 0x3C, 0x78, 0x60, 0x07, 0xCF, 0x1E, 0x3C, 0x79, 0xE3, 0xC7,
  0x8F, 0x1E, 0x78, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE3, 0xF0, 0xFC, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x04, 0xF1, 0xE3, 0xCF, 0x0F, 0x78, 0x3F, 0xC0,
  0xEF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0x78,
  0xF1, 0xE0, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x3D, 0xE7, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x38, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x1C, 0x7B, 0xCF, 0x3C, 0x3F, 0xE3,
  0xFF, 0x3F, 0xF3, 0xCF, 0x3C, 0xF7, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0xF1, 0xCF, 0x3C, 0x1F, 0x87, 0xF9, 0xFF, 0x3C, 0xFF, 0x1F, 0xE3,
  0xFC, 0xF7, 0x9E, 0xF3, 0xDF, 0xF3, 0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0xFF,
  0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C, 0xF3, 0xC7, 0x9E, 0x3D, 0xF1,
  0xFF, 0x1F, 0xF8, 0xF7, 0x87, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xBD, 0xFF, 0x1D, 0xE7, 0xBC, 0xF7, 0x9E,
  0xF7, 0xDF, 0xF3, 0xFE, 0x3F, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x3D, 0xCF, 0xF3, 0xF8, 0xFE, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0x1F, 0xCF, 0xF3, 0xD9, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x87, 0xBF, 0xEF, 0xF3, 0xF8, 0x0C, 0x0E, 0x07, 0x2F, 0xEF,
  0xF7, 0xF9, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0xC7, 0xE1, 0xF0,
  0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF7, 0xCF, 0xFC, 0xFF, 0x87, 0xB8, 0xF1, 0xFF, 0x1E, 0xF3, 0xCF, 0x3C,
  0x77, 0x87, 0x78, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xF3, 0xE7, 0xF9, 0xF3, 0xBD, 0xFB, 0xDE, 0xFD, 0xEF, 0x7D, 0xE7, 0xF6,
  0xF3, 0xFB, 0x71, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0xFC, 0x1E, 0x7C, 0x0F,
  0x3E, 0x00, 0x1E, 0x7C, 0x7B, 0xE1, 0xEF, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9E, 0x3E, 0x78, 0x3C,
  0x7C, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x1D, 0xE0, 0x77, 0x81, 0xDC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x0F,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0xF9, 0xFE, 0x7F, 0xC0, 0x03, 0x83,
  0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x38, 0xFC, 0x7C, 0x3C, 0x0F, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x70,
  0x38, 0x3C, 0x0F, 0x83, 0xC3, 0xC3, 0xE3, 0xC1, 0xE0, 0xE0, 0x70, 0xF8,
  0x78, 0x3C, 0x00, 0x78, 0x7F, 0xFF, 0xFE, 0x3F,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 10, 2, -16 },
  { 22, 14, 16, 13, 0, -16 },
  { 50, 11, 18, 12, 1, -17 },
  { 75, 18, 16, 19, 1, -16 },
  { 111, 15, 16, 15, 0, -16 },
  { 141, 4, 6, 5, 2, -16 },
  { 144, 8, 19, 7, 1, -16 },
  { 163, 9, 19, 7, -2, -16 },
  { 185, 10, 11, 11, 2, -17 },
  { 199, 10, 11, 12, 1, -13 },
  { 213, 6, 6, 6, -1, -3 },
  { 218, 7, 4, 7, 0, -8 },
  { 222, 4, 4, 6, 0, -4 },
  { 224, 12, 16, 10, -1, -16 },
  { 248, 11, 16, 12, 1, -16 },
  { 270, 9, 16, 12, 2, -16 },
  { 288, 12, 16, 12, -1, -16 },
  { 312, 12, 16, 12, 0, -16 },
  { 336, 12, 16, 12, 0, -16 },
  { 360, 12, 16, 12, 0, -16 },
  { 384, 11, 16, 12, 1, -16 },
  { 406, 13, 16, 12, 0, -16 },
  { 432, 12, 16, 12, 0, -16 },
  { 456, 11, 16, 12, 1, -16 },
  { 478, 6, 12, 6, 0, -12 },
  { 487, 7, 15, 6, -1, -12 },
  { 501, 10, 12, 12, 1, -14 },
  { 516, 10, 8, 12, 1, -12 },
  { 526, 10, 12, 12, 1, -14 },
  { 541, 10, 16, 10, 1, -16 },
  { 561, 17, 18, 18, 1, -16 },
  { 600, 13, 16, 14, -1, -16 },
  { 626, 13, 16, 13, 0, -16 },
  { 652, 13, 16, 13, 1, -16 },
  { 678, 13, 16, 14, 0, -16 },
  { 704, 12, 16, 11, 0, -16 },
  { 728, 12, 16, 11, 0, -16 },
  { 752, 13, 16, 14, 1, -16 },
  { 778, 15, 16, 15, 0, -16 },
  { 808, 11, 16, 9, -1, -16 },
  { 830, 12, 21, 7, -4, -16 },
  { 862, 15, 16, 13, 0, -16 },
  { 892, 10, 16, 11, 0, -16 },
  { 912, 19, 16, 19, 0, -16 },
  { 950, 16, 16, 16, 0, -16 },
  { 982, 13, 16, 15, 1, -16 },
  { 1008, 13, 16, 13, 0, -16 },
  { 1034, 13, 20, 15, 1, -16 },
  { 1067, 13, 16, 13, 0, -16 },
  { 1093, 12, 16, 11, 0, -16 },
  { 1117, 11, 16, 11, 2, -16 },
  { 1139, 14, 16, 14, 1, -16 },
  { 1167, 13, 16, 13, 2, -16 },
  { 1193, 19, 16, 19, 2, -16 },
  { 1231, 16, 16, 13, -1, -16 },
  { 1263, 12, 16, 12, 2, -16 },
  { 1287, 13, 16, 11, -1, -16 },
  { 1313, 10, 20, 7, -1, -16 },
  { 1338, 6, 16, 10, 2, -16 },
  { 1350, 10, 20, 7, -2, -16 },
  { 1375, 11, 11, 11, 0, -16 },
  { 1391, 10, 3, 9, -2, 1 },
  { 1395, 5, 4, 8, 3, -17 },
  { 1398, 11, 12, 12, 1, -12 },
  { 1415, 12, 17, 12, 0, -17 },
  { 1441, 10, 12, 10, 1, -12 },
  { 1456, 12, 17, 12, 1, -17 },
  { 1482, 10, 12, 12, 1, -12 },
  { 1497, 13, 22, 8, -2, -17 },
  { 1533, 12, 17, 12, 0, -12 },
  { 1559, 12, 17, 13, 0, -17 },
  { 1585, 7, 17, 7, 0, -17 },
  { 1600, 10, 22, 7, -3, -17 },
  { 1628, 14, 17, 13, 0, -17 },
  { 1658, 8, 17, 7, 0, -17 },
  { 1675, 18, 12, 19, 0, -12 },
  { 1702, 12, 12, 13, 0, -12 },
  { 1720, 11, 12, 12, 1, -12 },
  { 1737, 13, 17, 12, -1, -12 },
  { 1765, 11, 17, 12, 1, -12 },
  { 1789, 10, 12, 9, 0, -12 },
  { 1804, 10, 12, 10, 0, -12 },
  { 1819, 9, 15, 9, 1, -15 },
  { 1836, 12, 12, 13, 1, -12 },
  { 1854, 12, 12, 11, 1, -12 },
  { 1872, 17, 12, 17, 1, -12 },
  { 1898, 14, 12, 12, -1, -12 },
  { 1919, 14, 17, 11, -1, -12 },
  { 1949, 11, 12, 10, -1, -12 },
  { 1966, 9, 19, 8, 0, -16 },
  { 1988, 3, 22, 11, 4, -17 },
  { 1997, 9, 19, 8, -1, -16 },
  { 2019, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC22PT7B_H_
