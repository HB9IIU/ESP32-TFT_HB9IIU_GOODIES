#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x67, 0x39, 0xC0, 0x67, 0x38, 0x7E, 0xDD, 0xB7, 0x60,
  0x0D, 0x83, 0x61, 0xB1, 0xFF, 0x7F, 0xCC, 0xCF, 0xFB, 0xFE, 0x66, 0x1B,
  0x06, 0xC0, 0x06, 0x0F, 0xCF, 0xC6, 0xA7, 0xC1, 0xE0, 0x78, 0x1E, 0x8F,
  0x7F, 0x3F, 0x82, 0x01, 0x00, 0x10, 0x03, 0xC7, 0x3F, 0x31, 0xBB, 0x0D,
  0xB8, 0x6D, 0xBB, 0xDB, 0xED, 0xFB, 0x0D, 0x98, 0xCD, 0x8E, 0x7C, 0xE1,
  0xC0, 0x06, 0x03, 0xE0, 0xEE, 0x1D, 0xC3, 0xF0, 0x3C, 0x1F, 0x3F, 0xFE,
  0xEF, 0xDC, 0xF3, 0xFE, 0x3F, 0xE0, 0x76, 0x6E, 0x0E, 0x38, 0x61, 0x83,
  0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x00, 0x18, 0x71,
  0xC3, 0x0C, 0x31, 0xC7, 0x1C, 0x63, 0x8C, 0x71, 0x8C, 0x00, 0x1C, 0x58,
  0xFB, 0x7E, 0x39, 0xEC, 0x2C, 0x08, 0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E,
  0x1C, 0x77, 0x6E, 0x7F, 0xFC, 0x7F, 0x80, 0x01, 0x81, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x00, 0x04, 0x0F, 0x8F,
  0xC6, 0x67, 0x3B, 0x99, 0xDC, 0xCE, 0xE7, 0x37, 0x1F, 0x87, 0x80, 0x1E,
  0x7F, 0xFB, 0x65, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE0, 0x0C, 0x3F, 0x7F,
  0x27, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x0C, 0x3F, 0x3F,
  0x07, 0x07, 0x1E, 0x3E, 0x0F, 0x07, 0x8F, 0xFE, 0xFC, 0x07, 0x87, 0x83,
  0xC3, 0xE3, 0x73, 0xB1, 0xB9, 0xFE, 0xFF, 0x07, 0x07, 0x00, 0x1F, 0x9F,
  0x8E, 0x06, 0x07, 0xE3, 0xF8, 0x1C, 0x0E, 0x8E, 0x7F, 0x3F, 0x00, 0x06,
  0x3F, 0x7F, 0x70, 0xEC, 0xFE, 0xFE, 0xEE, 0xCE, 0xEE, 0xFC, 0x78, 0x3F,
  0x9F, 0xD1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x00,
  0x0C, 0x0F, 0x8F, 0xE6, 0x73, 0xF1, 0xF0, 0xF8, 0xEE, 0xE7, 0x73, 0x9F,
  0x8F, 0x80, 0x18, 0xFD, 0xFF, 0x3E, 0x7D, 0xFF, 0xBF, 0x0C, 0x3B, 0xE7,
  0x80, 0x33, 0xCC, 0x00, 0x01, 0x9C, 0xE0, 0x18, 0xF1, 0x80, 0x00, 0x00,
  0x1C, 0x71, 0x8E, 0x00, 0x02, 0x1C, 0xFF, 0xCE, 0x0F, 0x87, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC3, 0xE1, 0xF0, 0xEF, 0xBC, 0x60, 0x19,
  0xF9, 0xFA, 0x71, 0xC7, 0x9C, 0x30, 0x00, 0xC3, 0x87, 0x00, 0x03, 0x01,
  0xFC, 0x38, 0x66, 0x33, 0xCF, 0xBD, 0x9B, 0xDB, 0x3D, 0xB2, 0x9B, 0x6D,
  0xDC, 0xC0, 0x0F, 0x30, 0x7F, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x37, 0x1D,
  0xC6, 0x73, 0xFC, 0xFF, 0x7F, 0xDC, 0x7E, 0x1C, 0x3F, 0x9F, 0xCE, 0xE7,
  0x73, 0xF3, 0xF9, 0xDC, 0xE7, 0x77, 0x7F, 0xBF, 0x80, 0x0E, 0x1F, 0xDF,
  0xCE, 0x2E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0x3F, 0x8F, 0xC0, 0x3F,
  0x8F, 0xE3, 0xBC, 0xE7, 0x31, 0xDC, 0x77, 0x39, 0xCE, 0x7F, 0x3F, 0xCF,
  0xC0, 0x3F, 0x9F, 0x8E, 0x07, 0x03, 0xF3, 0xF1, 0xC0, 0xE0, 0x70, 0x7F,
  0x3F, 0x00, 0x3F, 0x9F, 0x8E, 0x07, 0x03, 0xE3, 0xF1, 0xF8, 0xE0, 0x70,
  0x70, 0x38, 0x00, 0x06, 0x0F, 0xCF, 0xEE, 0x1F, 0x07, 0x7F, 0xBF, 0xDE,
  0xE7, 0x73, 0xBF, 0xCF, 0xC0, 0x38, 0xE7, 0x18, 0xE7, 0x1C, 0xE3, 0xFC,
  0xFF, 0x9C, 0xE3, 0x9C, 0x73, 0x9C, 0x73, 0x9E, 0x00, 0x1F, 0x9F, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x3E, 0x3F, 0x00, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x87,
  0xC3, 0xC3, 0x80, 0x39, 0xE7, 0x78, 0xEE, 0x1F, 0x83, 0xE0, 0xFC, 0x1F,
  0xC3, 0xB8, 0x77, 0x1C, 0xE3, 0x9E, 0x00, 0x38, 0x70, 0xE1, 0xC3, 0x0E,
  0x1C, 0x38, 0x71, 0xFF, 0xF8, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E,
  0x3C, 0xF9, 0xF6, 0xE7, 0xDB, 0x1F, 0xFC, 0x6F, 0x73, 0xBD, 0xCE, 0xE7,
  0x00, 0x3C, 0x73, 0xC6, 0x3E, 0x63, 0xEE, 0x3E, 0xE7, 0x6E, 0x77, 0xC7,
  0x7C, 0x67, 0xCE, 0x3C, 0xE3, 0xC0, 0x06, 0x0F, 0xE7, 0xF9, 0xCE, 0xE1,
  0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xCF, 0xE1, 0xF0, 0x3F, 0x1F, 0xCE,
  0xE7, 0x73, 0x3B, 0xF9, 0xF8, 0xE0, 0x70, 0x70, 0x38, 0x00, 0x06, 0x0F,
  0xE7, 0xF9, 0xCE, 0xE1, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xBB, 0xCF, 0xE1,
  0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x3F, 0x1F, 0xCE, 0xE7, 0x73, 0x7B, 0xF9,
  0xF8, 0xEE, 0x77, 0x73, 0xB9, 0xE0, 0x0C, 0x1F, 0xCF, 0xCE, 0x27, 0x81,
  0xE0, 0xF8, 0x3C, 0x0E, 0x67, 0x3F, 0x9F, 0x80, 0x7F, 0xFF, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x71, 0xDC, 0xE7, 0x39, 0xCE,
  0xE3, 0xB9, 0xCE, 0x73, 0x9C, 0xEF, 0x3F, 0x87, 0xC0, 0xE3, 0xF8, 0xEE,
  0x73, 0x9C, 0x6E, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0xE3,
  0x9F, 0x9C, 0x6E, 0x73, 0xBB, 0xCE, 0xEF, 0x73, 0xBD, 0xCF, 0xB6, 0x3E,
  0xF8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x00, 0x1C, 0xF1, 0xDE, 0x1D, 0xC0,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xF8, 0x3B, 0x87, 0x38, 0xF3, 0xC0,
  0xF3, 0xBB, 0x9D, 0x8F, 0xC7, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x00, 0x1F, 0xCF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70,
  0x1F, 0xCF, 0xF0, 0x1E, 0x3C, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61,
  0xC3, 0x86, 0x0F, 0x3C, 0x00, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x77, 0x1E,
  0x3C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x1E, 0x3C,
  0x00, 0x0C, 0x1E, 0x1E, 0x36, 0x36, 0x63, 0xE3, 0xFF, 0xF8, 0xE7, 0x1F,
  0x9F, 0xDF, 0xCE, 0xE7, 0x73, 0x3B, 0xDC, 0xFC, 0x76, 0x00, 0x38, 0x1C,
  0x0E, 0x07, 0xE3, 0xF3, 0xFD, 0xCE, 0xEE, 0x77, 0x3B, 0xBF, 0x9F, 0x80,
  0x3E, 0xFB, 0xD7, 0x0E, 0x18, 0x3A, 0x7C, 0x78, 0x01, 0xC0, 0xE0, 0x38,
  0x7E, 0x3F, 0x9F, 0xC7, 0x71, 0xDC, 0x67, 0x3D, 0xC7, 0xE1, 0xD8, 0x3C,
  0xFF, 0x9F, 0x7F, 0xDE, 0x31, 0x7E, 0x7C, 0x03, 0xC1, 0xE0, 0xE0, 0x3E,
  0x1F, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x3E,
  0x0F, 0x03, 0x80, 0x1F, 0x9F, 0xDF, 0xCE, 0xE7, 0x73, 0x3B, 0xDC, 0xFC,
  0x7E, 0x07, 0x37, 0x9F, 0x8F, 0x80, 0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xF3,
  0xFD, 0xCE, 0xEE, 0x77, 0x33, 0xB9, 0xDC, 0xC0, 0x39, 0xC0, 0x73, 0x39,
  0xCE, 0x73, 0x39, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE3, 0x87, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x9F, 0x3C, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x33,
  0x9D, 0xC7, 0xE1, 0xF8, 0x7E, 0x1B, 0x8E, 0x73, 0x9C, 0x39, 0xCE, 0x73,
  0x39, 0xCE, 0x73, 0x39, 0xC0, 0x37, 0x71, 0xFF, 0xDE, 0xEE, 0xE7, 0x77,
  0x73, 0xBB, 0x9D, 0x9D, 0xDC, 0xEE, 0xE6, 0x70, 0x37, 0x1F, 0xDE, 0xEE,
  0x77, 0x73, 0xB9, 0x9D, 0xCE, 0xE6, 0x00, 0x3C, 0xFF, 0xBF, 0x3E, 0xF9,
  0xFB, 0xFE, 0x78, 0x1B, 0x87, 0xE3, 0xF8, 0xE7, 0x3B, 0x8E, 0xE3, 0xB9,
  0xFC, 0x7E, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x1F, 0x9F, 0xDF, 0xCE,
  0xE7, 0x73, 0x3B, 0xDC, 0xFC, 0x7E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x36,
  0x7D, 0xFB, 0x87, 0x0E, 0x18, 0x70, 0xE0, 0x3E, 0xFD, 0xCB, 0xC3, 0xC3,
  0xA7, 0x7E, 0xF8, 0x30, 0xC7, 0xFF, 0x63, 0x8E, 0x38, 0xEB, 0xCF, 0x00,
  0x77, 0x67, 0xE7, 0xE6, 0xEE, 0xEE, 0xEE, 0xFE, 0xEC, 0xE7, 0xEE, 0xEE,
  0xEC, 0xFC, 0xF8, 0xF8, 0xF0, 0x70, 0xEF, 0x7E, 0xE7, 0xEE, 0xEF, 0xEE,
  0xFE, 0xCD, 0x7C, 0xF7, 0x8F, 0x78, 0xE7, 0x00, 0x39, 0xC7, 0xE1, 0xF8,
  0x7C, 0x0E, 0x07, 0x83, 0xF1, 0xDC, 0xF7, 0x80, 0x39, 0xCE, 0xE3, 0xB8,
  0xEC, 0x3F, 0x0F, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x0F, 0x83, 0xC0, 0xE0,
  0x00, 0x3F, 0x7E, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xFC, 0xFC, 0x1E, 0x38,
  0x61, 0xC3, 0x9E, 0x38, 0x78, 0x70, 0xE1, 0x83, 0x87, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x38, 0x78, 0x70, 0xE1, 0x83, 0xC3, 0x1E, 0x38, 0x61,
  0xC7, 0x8E, 0x10, 0x00, 0xF3, 0xFE, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 5, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 10, 11, 10, 0, -11 },
  { 26, 9, 13, 9, 0, -12 },
  { 41, 13, 12, 14, 1, -12 },
  { 61, 11, 12, 11, 0, -12 },
  { 78, 4, 4, 4, 1, -11 },
  { 80, 7, 15, 5, 0, -12 },
  { 94, 6, 15, 5, -1, -12 },
  { 106, 8, 8, 8, 1, -12 },
  { 114, 7, 8, 9, 1, -10 },
  { 121, 4, 4, 5, -1, -2 },
  { 123, 5, 3, 5, 0, -6 },
  { 125, 3, 3, 5, 0, -3 },
  { 127, 9, 12, 7, -1, -12 },
  { 141, 9, 12, 9, 0, -12 },
  { 155, 7, 11, 9, 1, -11 },
  { 165, 8, 12, 9, 0, -12 },
  { 177, 8, 12, 9, 0, -12 },
  { 189, 9, 11, 9, 0, -11 },
  { 202, 9, 11, 9, 0, -11 },
  { 215, 8, 12, 9, 1, -12 },
  { 227, 9, 11, 9, 0, -11 },
  { 240, 9, 12, 9, 0, -12 },
  { 254, 7, 12, 9, 1, -12 },
  { 265, 5, 9, 5, 0, -9 },
  { 271, 6, 11, 5, -1, -9 },
  { 280, 7, 8, 9, 1, -10 },
  { 287, 7, 5, 9, 1, -8 },
  { 292, 7, 8, 9, 1, -10 },
  { 299, 7, 12, 7, 1, -12 },
  { 310, 12, 13, 13, 1, -12 },
  { 330, 10, 11, 10, -1, -11 },
  { 344, 9, 11, 9, 0, -11 },
  { 357, 9, 12, 9, 1, -12 },
  { 371, 10, 11, 10, 0, -11 },
  { 385, 9, 11, 8, 0, -11 },
  { 398, 9, 11, 8, 0, -11 },
  { 411, 9, 12, 10, 1, -12 },
  { 425, 11, 11, 11, 0, -11 },
  { 441, 9, 11, 7, -1, -11 },
  { 454, 9, 15, 5, -3, -11 },
  { 471, 11, 11, 10, 0, -11 },
  { 487, 7, 11, 8, 0, -11 },
  { 497, 14, 11, 14, 0, -11 },
  { 517, 12, 11, 12, 0, -11 },
  { 534, 10, 12, 11, 1, -12 },
  { 549, 9, 11, 9, 0, -11 },
  { 562, 10, 15, 11, 1, -12 },
  { 581, 9, 11, 10, 0, -11 },
  { 594, 9, 12, 8, 0, -12 },
  { 608, 8, 11, 8, 1, -11 },
  { 619, 10, 11, 10, 1, -11 },
  { 633, 10, 11, 9, 1, -11 },
  { 647, 14, 11, 14, 1, -11 },
  { 667, 12, 11, 10, -1, -11 },
  { 684, 9, 11, 9, 1, -11 },
  { 697, 10, 11, 8, -1, -11 },
  { 711, 7, 15, 5, -1, -12 },
  { 725, 4, 12, 7, 2, -12 },
  { 731, 7, 15, 5, -1, -12 },
  { 745, 8, 7, 8, 0, -11 },
  { 752, 7, 2, 7, -1, 1 },
  { 754, 4, 2, 6, 2, -12 },
  { 755, 9, 9, 9, 0, -9 },
  { 766, 9, 12, 9, 0, -12 },
  { 780, 7, 9, 7, 1, -9 },
  { 788, 10, 12, 9, 0, -12 },
  { 803, 7, 9, 9, 1, -9 },
  { 811, 10, 16, 6, -2, -12 },
  { 831, 9, 13, 9, 0, -9 },
  { 846, 9, 12, 9, 0, -12 },
  { 860, 5, 12, 5, 0, -12 },
  { 868, 7, 16, 5, -2, -12 },
  { 882, 10, 12, 9, 0, -12 },
  { 897, 5, 12, 5, 0, -12 },
  { 905, 13, 9, 14, 0, -9 },
  { 920, 9, 9, 9, 0, -9 },
  { 931, 7, 9, 9, 1, -9 },
  { 939, 10, 13, 9, -1, -9 },
  { 956, 9, 13, 9, 0, -9 },
  { 971, 7, 9, 7, 0, -9 },
  { 979, 7, 9, 7, 0, -9 },
  { 987, 6, 11, 7, 1, -11 },
  { 996, 8, 9, 9, 1, -9 },
  { 1005, 8, 9, 8, 1, -9 },
  { 1014, 12, 9, 12, 1, -9 },
  { 1028, 10, 9, 8, -1, -9 },
  { 1040, 10, 13, 8, -1, -9 },
  { 1057, 8, 9, 7, 0, -9 },
  { 1066, 7, 14, 6, 0, -11 },
  { 1079, 2, 16, 8, 3, -12 },
  { 1083, 7, 14, 6, -1, -11 },
  { 1096, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC16PT7B_H_
