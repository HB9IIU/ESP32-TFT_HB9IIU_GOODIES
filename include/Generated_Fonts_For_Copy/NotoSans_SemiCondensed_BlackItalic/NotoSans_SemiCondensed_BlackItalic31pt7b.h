#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x7D, 0xFB, 0xEF, 0x9E, 0x7D, 0xF3, 0xEF,
  0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x7C, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8E, 0x0F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3E, 0xC4, 0x3E, 0xC0, 0x3E, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0x7C, 0xC3, 0x7C, 0xFB,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1F, 0x80, 0x7C, 0x1F, 0xE0, 0x7C, 0x1F, 0xF0, 0x3C,
  0x0F, 0x7C, 0x3C, 0x0F, 0x9E, 0x3E, 0x07, 0x9F, 0x1E, 0x03, 0xCF, 0x1E,
  0x01, 0xE7, 0x9F, 0x00, 0xF3, 0xCF, 0x18, 0x7B, 0xEF, 0x3F, 0x3F, 0xEF,
  0xBF, 0xDF, 0xE7, 0xBF, 0xE7, 0xE7, 0x9E, 0xF8, 0x07, 0xDF, 0x7C, 0x03,
  0xCF, 0x3E, 0x03, 0xC7, 0x9E, 0x03, 0xC3, 0xCF, 0x01, 0xE1, 0xE7, 0x81,
  0xE0, 0xF7, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xC1, 0xF0, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x7E, 0x7F, 0xF3, 0xE7, 0xFF, 0xBF, 0x3F, 0x7F,
  0xF3, 0xF3, 0xFF, 0x9F, 0x8F, 0xF8, 0xFC, 0x7F, 0xC7, 0xF3, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x7D, 0xF7,
  0xBE, 0xFB, 0xCF, 0x3C, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0x03, 0x00, 0x0F, 0x80, 0x3E, 0x18, 0xF0, 0x7B,
  0xC1, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x7F, 0x13, 0xFE, 0x1F,
  0x78, 0x3D, 0xF0, 0x63, 0xC0, 0x8C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x7F, 0xBF, 0xDF,
  0xEF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xF3, 0xE7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F,
  0x7E, 0x3E, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1F, 0x7C, 0x7E, 0xFC, 0xF9, 0xFB, 0xF3, 0xFF, 0xC3, 0xFF, 0x87, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0xF9,
  0xFF, 0xEF, 0xFF, 0x1F, 0x7C, 0x33, 0xF0, 0x8F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x38, 0xFC, 0x08, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x0E, 0x3F, 0x08, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x07, 0xFE, 0x07,
  0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x80, 0x7E, 0xF1, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xBF, 0x07, 0xDF,
  0x07, 0xCF, 0x83, 0xC7, 0xC3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x8F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x80, 0x7E,
  0x78, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x70, 0x7D, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0xFE,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0xFD, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3F, 0x7E, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0x7C, 0xFC, 0xFC, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF3, 0xF7, 0xEF,
  0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x7E, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xE7, 0xEF, 0x83, 0x1F, 0x00, 0x7C, 0x01, 0xF9, 0x0F, 0xE3,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x80, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xFC, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0,
  0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x1F, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF,
  0xF7, 0x9F, 0x90, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0x00, 0x1E, 0x1E, 0x0E, 0x1F,
  0x3C, 0x3F, 0xCF, 0x3C, 0x7F, 0xCF, 0x78, 0xFF, 0xCF, 0x79, 0xE3, 0xCF,
  0x71, 0xE3, 0xCF, 0xF3, 0xC7, 0x8F, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E,
  0xF3, 0xCF, 0x9E, 0xF3, 0xFF, 0xFC, 0xF3, 0xFF, 0xF8, 0xF1, 0xFB, 0xF0,
  0xF8, 0xE0, 0xC0, 0x78, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x83,
  0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFC, 0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xF8,
  0x07, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xDF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xC7, 0xC3, 0xF1, 0xF8,
  0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xE7, 0x0F, 0xE0, 0x43, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x04, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x1F, 0xC3, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7C, 0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0x38, 0x3F, 0x01, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xF9, 0xF9, 0xFF, 0x3E,
  0x3F, 0xCF, 0xC7, 0xF9, 0xF9, 0xFF, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E,
  0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0,
  0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x80,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x1F, 0x0F, 0xC0,
  0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7E, 0x00, 0xFB,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0x9F, 0x80, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3F, 0x83, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFE,
  0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1,
  0xFF, 0x83, 0xFE, 0x3D, 0xF0, 0x7F, 0xCF, 0xFE, 0x1F, 0xF9, 0xEF, 0x83,
  0xEF, 0x7D, 0xF0, 0x7D, 0xEF, 0x3E, 0x0F, 0xBF, 0xEF, 0xC1, 0xF7, 0xF9,
  0xF8, 0x7E, 0xFF, 0x3E, 0x0F, 0x9F, 0xE7, 0xC1, 0xF3, 0xF8, 0xF8, 0x3E,
  0x7F, 0x3F, 0x07, 0xCF, 0xC7, 0xC1, 0xF9, 0xF8, 0xF8, 0x00, 0x07, 0xF0,
  0x3E, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x87,
  0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x3F, 0x0F, 0xFC, 0x7C, 0x1F, 0xFC, 0xF8,
  0x3E, 0xF9, 0xF0, 0x7D, 0xF3, 0xE1, 0xFB, 0xEF, 0x83, 0xE7, 0xFF, 0x07,
  0xC7, 0xFE, 0x0F, 0x8F, 0xFC, 0x1F, 0x1F, 0xF8, 0x7E, 0x3F, 0xE0, 0xF8,
  0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x1F, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1,
  0xFE, 0xFE, 0x7F, 0x0F, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFE, 0xFE, 0x7F, 0x0F, 0xCF,
  0xC0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0x7E,
  0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xDF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F, 0x87, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C,
  0x3F, 0x3F, 0x07, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFD, 0xE0, 0xFC, 0x10, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x40, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F,
  0x87, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C,
  0x1F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0,
  0x7C, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC3,
  0xF0, 0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x0F, 0xEF, 0x81, 0xF9, 0xF0, 0x7E, 0x3E,
  0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x07,
  0xFF, 0x07, 0xC1, 0xFB, 0xE0, 0xF8, 0x3E, 0x7C, 0x3F, 0x07, 0xCF, 0x87,
  0xE1, 0xF9, 0xF1, 0xFC, 0x3E, 0x3E, 0x3F, 0x8F, 0xC7, 0xCF, 0xF1, 0xF0,
  0xF9, 0xFE, 0x3E, 0x1F, 0x3F, 0xCF, 0xC3, 0xEF, 0xF9, 0xF0, 0x7D, 0xEF,
  0x7E, 0x0F, 0xFD, 0xEF, 0x81, 0xEF, 0x3D, 0xF0, 0x3D, 0xE7, 0xFC, 0x07,
  0xFC, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF,
  0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x1F, 0x9F, 0x8F,
  0xC7, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xBC, 0x0F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3E,
  0x3C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0xCF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x7F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E,
  0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFD, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3E, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xE3, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0xDF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xE3, 0xEF, 0xE1, 0xF3, 0xE0, 0x07, 0xF8, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFE, 0x7F, 0x11, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x04, 0xFC, 0x63, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF1, 0xFD, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF7, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFB, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF9, 0xFF, 0xF7, 0xE3, 0xEF, 0xC7, 0xDF, 0x3F, 0xFF, 0xFE, 0xFF, 0xF9,
  0xFF, 0xE3, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x07, 0xE7, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFB, 0xF1,
  0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x8F,
  0x8F, 0xCF, 0xC7, 0xEF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x18, 0x3F, 0x0F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0x7C,
  0x7C, 0x7E, 0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7,
  0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0x03, 0xC1, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3,
  0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x3F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x0F, 0xBF,
  0x03, 0xF7, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xC7, 0xE0, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0x0F, 0x3E, 0x3F, 0x0F, 0xBF, 0xBF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xF9, 0xFD, 0xF8, 0xF8, 0xFC, 0x7C, 0xFC, 0x7E, 0x3E,
  0x7E, 0x3E, 0x3F, 0x3E, 0x3F, 0x1F, 0x9F, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7,
  0xCF, 0xC7, 0xC3, 0xE7, 0xE3, 0xE3, 0xF3, 0xE3, 0xF1, 0xF9, 0xF1, 0xF8,
  0xF9, 0xF8, 0xFC, 0x7C, 0xFC, 0x7C, 0x7E, 0x00, 0x0F, 0x7E, 0x0F, 0xBF,
  0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x00, 0x07, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xE7, 0xEF, 0xC7, 0xDF, 0x0F, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xEF, 0xCF, 0xDF, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFD, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3, 0xF1, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7E, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xCF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E,
  0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0xFC, 0xFD, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x3C, 0x7D, 0xF1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3F, 0x10, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C, 0xC3,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x03, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x8F, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0x80, 0x3F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7,
  0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E,
  0x3F, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0xDF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFE, 0xF0, 0x3E, 0x78, 0x00, 0xF8, 0x7F, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8,
  0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFB,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xF8, 0xFE, 0x3F, 0xF8, 0xFC, 0x7E, 0xF8, 0xFC, 0x7C,
  0xF9, 0xFC, 0x7C, 0xF9, 0xFC, 0xFC, 0xFB, 0xFC, 0xF8, 0xFB, 0xFD, 0xF8,
  0xFB, 0xFD, 0xF0, 0xFF, 0xBD, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x7E, 0x7E, 0x07,
  0xEF, 0xC0, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xBE, 0x01, 0xFB, 0xE0, 0x3F, 0x3F, 0x07, 0xF3, 0xF0, 0xFE, 0x3F,
  0x80, 0x1F, 0x87, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00,
  0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0xC1,
  0xFE, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x3E, 0x02, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 22, 9, 0, -22 },
  { 29, 13, 8, 14, 3, -22 },
  { 42, 19, 22, 19, 0, -22 },
  { 95, 16, 26, 17, 1, -24 },
  { 147, 25, 22, 27, 2, -22 },
  { 216, 21, 22, 21, 0, -22 },
  { 274, 6, 8, 7, 3, -22 },
  { 280, 12, 28, 11, 1, -23 },
  { 322, 12, 28, 11, -2, -23 },
  { 364, 14, 15, 16, 2, -24 },
  { 391, 15, 16, 17, 1, -19 },
  { 421, 8, 8, 9, -2, -4 },
  { 429, 9, 5, 10, 0, -11 },
  { 435, 6, 5, 9, 0, -5 },
  { 439, 18, 22, 14, -2, -22 },
  { 489, 15, 22, 17, 1, -22 },
  { 531, 14, 22, 17, 2, -22 },
  { 570, 17, 22, 17, -1, -22 },
  { 617, 16, 22, 17, 0, -22 },
  { 661, 17, 22, 17, 0, -22 },
  { 708, 17, 22, 17, 0, -22 },
  { 755, 16, 22, 17, 1, -22 },
  { 799, 17, 22, 17, 1, -22 },
  { 846, 16, 22, 17, 1, -22 },
  { 890, 15, 22, 17, 1, -22 },
  { 932, 9, 17, 9, 0, -17 },
  { 952, 11, 21, 9, -2, -17 },
  { 981, 15, 16, 17, 1, -19 },
  { 1011, 15, 11, 17, 1, -16 },
  { 1032, 15, 16, 17, 1, -19 },
  { 1062, 13, 22, 14, 2, -22 },
  { 1098, 24, 25, 26, 1, -22 },
  { 1173, 19, 22, 19, -2, -22 },
  { 1226, 18, 22, 18, 0, -22 },
  { 1276, 18, 22, 18, 1, -22 },
  { 1326, 19, 22, 20, 0, -22 },
  { 1379, 17, 22, 16, 0, -22 },
  { 1426, 17, 22, 16, 0, -22 },
  { 1473, 19, 22, 20, 1, -22 },
  { 1526, 21, 22, 20, 0, -22 },
  { 1584, 16, 22, 13, -1, -22 },
  { 1628, 16, 29, 10, -5, -22 },
  { 1686, 22, 22, 19, 0, -22 },
  { 1747, 13, 22, 15, 0, -22 },
  { 1783, 27, 22, 26, 0, -22 },
  { 1858, 23, 22, 22, 0, -22 },
  { 1922, 19, 22, 21, 1, -22 },
  { 1975, 18, 22, 18, 0, -22 },
  { 2025, 19, 27, 21, 1, -22 },
  { 2090, 18, 22, 19, 0, -22 },
  { 2140, 17, 22, 16, 0, -22 },
  { 2187, 16, 22, 16, 2, -22 },
  { 2231, 19, 22, 20, 2, -22 },
  { 2284, 19, 22, 18, 2, -22 },
  { 2337, 27, 22, 27, 3, -22 },
  { 2412, 23, 22, 19, -2, -22 },
  { 2476, 17, 22, 17, 3, -22 },
  { 2523, 18, 22, 16, -1, -22 },
  { 2573, 14, 28, 10, -1, -23 },
  { 2622, 8, 22, 14, 3, -22 },
  { 2644, 13, 28, 10, -2, -23 },
  { 2690, 16, 14, 16, 0, -22 },
  { 2718, 14, 4, 13, -3, 2 },
  { 2725, 8, 5, 11, 4, -24 },
  { 2730, 16, 17, 17, 1, -17 },
  { 2764, 17, 24, 17, 0, -24 },
  { 2815, 14, 17, 14, 1, -17 },
  { 2845, 18, 24, 17, 1, -24 },
  { 2899, 15, 17, 17, 1, -17 },
  { 2931, 18, 31, 12, -3, -24 },
  { 3001, 17, 24, 17, 0, -17 },
  { 3052, 17, 24, 18, 0, -24 },
  { 3103, 10, 24, 9, 0, -24 },
  { 3133, 14, 31, 9, -4, -24 },
  { 3188, 19, 24, 18, 0, -24 },
  { 3245, 11, 24, 9, 0, -24 },
  { 3278, 25, 17, 26, 0, -17 },
  { 3332, 17, 17, 18, 0, -17 },
  { 3369, 15, 17, 17, 1, -17 },
  { 3401, 17, 24, 17, -1, -17 },
  { 3452, 16, 24, 17, 1, -17 },
  { 3500, 14, 17, 13, 0, -17 },
  { 3530, 14, 17, 14, 0, -17 },
  { 3560, 12, 21, 13, 1, -21 },
  { 3592, 17, 17, 18, 1, -17 },
  { 3629, 16, 17, 16, 2, -17 },
  { 3663, 24, 17, 24, 2, -17 },
  { 3714, 20, 17, 16, -2, -17 },
  { 3757, 20, 24, 16, -2, -17 },
  { 3817, 16, 17, 14, -1, -17 },
  { 3851, 13, 27, 11, 0, -22 },
  { 3895, 4, 31, 16, 6, -24 },
  { 3911, 13, 27, 11, -2, -22 },
  { 3955, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC31PT7B_H_
