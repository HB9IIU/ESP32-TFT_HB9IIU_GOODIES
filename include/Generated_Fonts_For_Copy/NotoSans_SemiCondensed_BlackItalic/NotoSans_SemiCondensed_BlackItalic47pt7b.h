#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x08, 0x00, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFD, 0xC7, 0x03, 0xFC,
  0xE0, 0x81, 0xFE, 0xF0, 0x00, 0xFF, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x77, 0xF8, 0x00, 0x39, 0xFC, 0x20, 0x1C, 0xFE, 0x3C, 0x1E, 0xFF,
  0x1F, 0xCE, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0xFC, 0x0F, 0xE0, 0x0F, 0xC7,
  0xE0, 0x7E, 0x00, 0xFE, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xF3,
  0xF8, 0x00, 0x7E, 0x3F, 0x1F, 0x83, 0x03, 0xF3, 0xF9, 0xF8, 0xFF, 0x9F,
  0xFF, 0x9F, 0xCF, 0xFE, 0xFF, 0xFC, 0xFC, 0xFF, 0xF7, 0xFF, 0xCF, 0xCF,
  0xFF, 0xDF, 0xFC, 0xFE, 0x7F, 0xFE, 0x7F, 0xC7, 0xE7, 0xF3, 0xF1, 0xFC,
  0x7E, 0x3F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC7,
  0xE0, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE1, 0xF8, 0x01, 0xF8,
  0x3F, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0xFC, 0x01, 0xFC, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC0, 0x7E, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF3, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xF3, 0xF9,
  0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x30, 0x7F,
  0x00, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0xFF, 0x83, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xDF, 0x81, 0xFF, 0x7E,
  0x01, 0xF9, 0xFC, 0x03, 0xC7, 0xF8, 0x07, 0x0F, 0xC0, 0x08, 0x3C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9,
  0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE,
  0xFF, 0x83, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xF8, 0xFF, 0x8F, 0xF8,
  0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xF7, 0xFC, 0x7E, 0x7F, 0x83, 0xC7, 0xF8, 0x10,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xF9, 0xFF, 0x01, 0xF0, 0x7F, 0x80, 0x60, 0x3F, 0xC0, 0x20, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xC3,
  0xFF, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x40, 0x03, 0xFE, 0x38, 0x03, 0xFF,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xE7,
  0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF3, 0xFE, 0x07, 0xF1, 0xFE, 0x07, 0xF0,
  0xFF, 0x03, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x81, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x40, 0x07, 0xFC, 0x30, 0x07, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0,
  0x7F, 0xBF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0x87, 0xFC,
  0xFF, 0x87, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFE, 0x0F, 0xFB,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF,
  0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x87, 0xFD, 0xFF, 0x0F, 0xFB,
  0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE1, 0xFF, 0xBF,
  0xE7, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF,
  0xDF, 0xE3, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0x3F, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x81, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xE1, 0xFF, 0x18, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x0F,
  0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xF3, 0xF3, 0xF8, 0x7F, 0xFE, 0x3F, 0x3F,
  0x0F, 0xFF, 0xE3, 0xF7, 0xE1, 0xFF, 0xFE, 0x3F, 0x7E, 0x1F, 0x87, 0xE3,
  0xF7, 0xC3, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xC7, 0xE0,
  0xFC, 0x3F, 0xFC, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xE1, 0xF8, 0x3E, 0xF8,
  0xFE, 0x1F, 0x87, 0xEF, 0x8F, 0xC1, 0xF8, 0x7C, 0xF8, 0xFC, 0x3F, 0x8F,
  0xCF, 0x8F, 0xE3, 0xF9, 0xF8, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0x87, 0xFF,
  0xFF, 0xF0, 0xFC, 0x7F, 0xEF, 0xFE, 0x0F, 0xC3, 0xFC, 0x7F, 0xC0, 0xFC,
  0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0xFF, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F,
  0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFC, 0x1F, 0xFC, 0x03, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x01, 0x01, 0xFF, 0x81, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFC, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x0F, 0xFE, 0x0F, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x0F, 0xFC, 0x00, 0x81,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0xE7, 0xFC, 0x3F, 0xFC,
  0x7F, 0xC7, 0xFF, 0xCF, 0xF8, 0x7F, 0xFC, 0xFF, 0x87, 0xFF, 0xCF, 0xF8,
  0x7F, 0xFC, 0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x0F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0x0F,
  0xFF, 0xE0, 0x3F, 0xDF, 0x87, 0xEF, 0xF0, 0x1F, 0xEF, 0xC7, 0xF7, 0xF0,
  0x0F, 0xF7, 0xE3, 0xF7, 0xF8, 0x07, 0xFB, 0xF3, 0xFB, 0xFC, 0x03, 0xF9,
  0xF9, 0xF9, 0xFE, 0x03, 0xFC, 0xFD, 0xFC, 0xFF, 0x01, 0xFE, 0x7E, 0xFE,
  0x7F, 0x00, 0xFF, 0x3F, 0x7E, 0x7F, 0x80, 0x7F, 0x9F, 0xFF, 0x3F, 0xC0,
  0x3F, 0x8F, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0xC3,
  0xFC, 0x03, 0xF8, 0x7F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFE, 0x01,
  0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0xE0, 0x1F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0x80, 0x7F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0x80, 0x7F, 0x7F, 0x0F, 0xF0, 0x0F, 0xEF, 0xF1, 0xFE, 0x03, 0xFD,
  0xFE, 0x3F, 0xC0, 0x7F, 0xBF, 0xC7, 0xF8, 0x0F, 0xF3, 0xF8, 0xFE, 0x01,
  0xFE, 0x7F, 0xBF, 0xC0, 0x3F, 0x8F, 0xF7, 0xF8, 0x0F, 0xF1, 0xFE, 0xFF,
  0x01, 0xFE, 0x1F, 0xDF, 0xE0, 0x3F, 0xC3, 0xFF, 0xF8, 0x07, 0xF8, 0x7F,
  0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFC, 0x07, 0xF8,
  0x1F, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x07, 0xFE,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x3F,
  0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xCF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x07, 0xFE, 0x1F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xF3,
  0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC,
  0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x0C, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x40, 0x0F, 0xF8, 0x30,
  0x07, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF,
  0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xEF, 0xF0, 0x1F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF8, 0x1F, 0xF3,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0xFF, 0x07,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3,
  0xFE, 0x1F, 0xE1, 0xFF, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0x07,
  0xF8, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0xFC, 0x7F, 0x81, 0xFE, 0x7F,
  0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xBF, 0x9F,
  0xE0, 0x3F, 0x9F, 0xDF, 0xDF, 0xE0, 0x1F, 0xCF, 0xEF, 0xEF, 0xF0, 0x0F,
  0xEF, 0xE7, 0xF7, 0xF0, 0x07, 0xF7, 0xF3, 0xFF, 0xF8, 0x03, 0xFF, 0xF1,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3,
  0xFE, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x01, 0xF9, 0xF8, 0x03, 0xF9, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF1, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF0, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF,
  0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xFE, 0x0F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE1, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x83,
  0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0x9F, 0xF8, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xEF,
  0x0F, 0xFC, 0x08, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x04, 0x3F, 0xE0, 0x41, 0xFF, 0xBE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x03, 0xF9, 0xFE, 0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0xF7, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF,
  0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC,
  0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xDF,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC,
  0x7F, 0x9F, 0xF0, 0x7F, 0x3F, 0xE1, 0xFE, 0x7F, 0x87, 0xFD, 0xFF, 0x7F,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x43,
  0xFE, 0x07, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xE7, 0xF0,
  0x3F, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xDF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xF7, 0xF8, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x30, 0x07, 0xFC, 0x0F, 0xC7, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87,
  0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x83,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0x83, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xF1, 0xFE, 0x0F, 0xF0, 0x1F, 0xCF, 0xFC, 0x7F, 0xE0, 0x7F, 0x7F,
  0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x7F, 0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8,
  0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC1,
  0xFF, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xF1, 0xFE, 0x03, 0xF9, 0xFF, 0x81, 0xFD,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC7,
  0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFC, 0x1F,
  0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xE1,
  0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x83, 0xFE,
  0xFF, 0x07, 0xFD, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xE7, 0xFC, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xF0,
  0x07, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0,
  0x7F, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC, 0x7F, 0xE3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7,
  0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xFB, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xE7, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xC3, 0x83, 0xFE, 0x04,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x30, 0x0F, 0xF9, 0xE0, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF,
  0xE0, 0x7F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFB, 0xFC,
  0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xC1, 0xFE, 0xFF, 0x0F, 0xFC, 0x3F, 0xEF, 0xF0, 0xFF, 0xC3, 0xFC,
  0xFF, 0x1F, 0xFC, 0x3F, 0xCF, 0xE1, 0xFF, 0xC7, 0xF8, 0xFE, 0x1F, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFF, 0xCF, 0xF0, 0xFE, 0x3F, 0xFC, 0xFF, 0x0F, 0xE7,
  0xEF, 0xCF, 0xF0, 0xFE, 0x7E, 0xF9, 0xFE, 0x0F, 0xE7, 0xEF, 0x9F, 0xE0,
  0xFE, 0xFD, 0xFB, 0xFC, 0x0F, 0xEF, 0xDF, 0xBF, 0xC0, 0xFE, 0xFD, 0xFB,
  0xF8, 0x0F, 0xFF, 0x9F, 0xBF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF,
  0x1F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x07,
  0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 35, 14, 0, -34 },
  { 71, 20, 13, 21, 4, -34 },
  { 104, 29, 34, 28, 0, -34 },
  { 228, 25, 39, 25, 1, -36 },
  { 350, 37, 34, 41, 3, -34 },
  { 508, 32, 34, 32, 0, -34 },
  { 644, 10, 13, 11, 4, -34 },
  { 661, 18, 42, 16, 1, -35 },
  { 756, 18, 42, 16, -3, -35 },
  { 851, 22, 23, 24, 3, -36 },
  { 915, 22, 23, 26, 2, -28 },
  { 979, 13, 12, 14, -3, -6 },
  { 999, 14, 7, 15, 0, -16 },
  { 1012, 9, 9, 14, 0, -8 },
  { 1023, 26, 34, 21, -2, -34 },
  { 1134, 24, 34, 25, 1, -34 },
  { 1236, 20, 34, 25, 4, -34 },
  { 1321, 25, 34, 25, -1, -34 },
  { 1428, 25, 34, 25, 0, -34 },
  { 1535, 25, 34, 25, 0, -34 },
  { 1642, 25, 34, 25, 1, -34 },
  { 1749, 24, 34, 25, 2, -34 },
  { 1851, 27, 34, 25, 1, -34 },
  { 1966, 24, 34, 25, 1, -34 },
  { 2068, 23, 34, 25, 2, -34 },
  { 2166, 14, 27, 14, 0, -26 },
  { 2214, 17, 32, 14, -3, -26 },
  { 2282, 22, 24, 26, 2, -29 },
  { 2348, 22, 17, 26, 2, -25 },
  { 2395, 22, 24, 26, 2, -29 },
  { 2461, 20, 35, 21, 3, -34 },
  { 2549, 36, 38, 39, 2, -34 },
  { 2720, 29, 34, 29, -3, -34 },
  { 2844, 28, 34, 28, 0, -34 },
  { 2963, 27, 34, 27, 2, -34 },
  { 3078, 29, 34, 30, 0, -34 },
  { 3202, 26, 34, 24, 0, -34 },
  { 3313, 26, 34, 24, 0, -34 },
  { 3424, 28, 34, 30, 2, -34 },
  { 3543, 32, 34, 31, 0, -34 },
  { 3679, 24, 34, 19, -2, -34 },
  { 3781, 24, 45, 16, -7, -34 },
  { 3916, 33, 34, 29, 0, -34 },
  { 4057, 20, 34, 23, 0, -34 },
  { 4142, 41, 34, 40, 0, -34 },
  { 4317, 35, 34, 34, 0, -34 },
  { 4466, 29, 34, 32, 2, -34 },
  { 4590, 27, 34, 27, 0, -34 },
  { 4705, 29, 42, 32, 2, -34 },
  { 4858, 27, 34, 28, 0, -34 },
  { 4973, 25, 34, 24, 0, -34 },
  { 5080, 23, 34, 24, 4, -34 },
  { 5178, 29, 34, 30, 2, -34 },
  { 5302, 27, 34, 27, 4, -34 },
  { 5417, 41, 34, 41, 4, -34 },
  { 5592, 35, 34, 28, -3, -34 },
  { 5741, 26, 34, 26, 4, -34 },
  { 5852, 28, 34, 24, -2, -34 },
  { 5971, 21, 43, 16, -2, -35 },
  { 6084, 12, 34, 21, 5, -34 },
  { 6135, 20, 43, 16, -3, -35 },
  { 6243, 24, 23, 24, 0, -34 },
  { 6312, 21, 6, 20, -4, 3 },
  { 6328, 11, 8, 16, 7, -36 },
  { 6339, 25, 26, 26, 1, -26 },
  { 6421, 25, 36, 26, 0, -36 },
  { 6534, 21, 26, 22, 2, -26 },
  { 6603, 27, 36, 26, 1, -36 },
  { 6725, 23, 26, 25, 1, -26 },
  { 6800, 28, 47, 18, -5, -36 },
  { 6965, 26, 37, 26, 0, -26 },
  { 7086, 25, 36, 27, 0, -36 },
  { 7199, 16, 37, 14, 0, -37 },
  { 7273, 22, 48, 14, -6, -37 },
  { 7405, 29, 36, 27, 0, -36 },
  { 7536, 16, 36, 14, 0, -36 },
  { 7608, 38, 26, 40, 0, -26 },
  { 7732, 25, 26, 27, 0, -26 },
  { 7814, 23, 26, 26, 2, -26 },
  { 7889, 27, 37, 26, -2, -26 },
  { 8014, 25, 37, 26, 1, -26 },
  { 8130, 21, 26, 19, 0, -26 },
  { 8199, 21, 26, 22, 0, -26 },
  { 8268, 18, 31, 20, 2, -31 },
  { 8338, 25, 26, 27, 2, -26 },
  { 8420, 25, 26, 24, 2, -26 },
  { 8502, 36, 26, 36, 3, -26 },
  { 8619, 31, 26, 25, -3, -26 },
  { 8720, 30, 37, 24, -3, -26 },
  { 8859, 23, 26, 21, -1, -26 },
  { 8934, 20, 41, 17, 0, -34 },
  { 9037, 6, 47, 24, 9, -36 },
  { 9073, 20, 41, 17, -3, -34 },
  { 9176, 22, 9, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC47PT7B_H_
