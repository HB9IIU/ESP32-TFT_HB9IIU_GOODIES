#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x40, 0x00, 0x7F, 0xC7,
  0xFB, 0xFE, 0x7F, 0xDF, 0xF3, 0xFE, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x3F,
  0xC7, 0xF9, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC, 0xFF, 0x1F, 0xE7, 0xF0, 0xFF,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x43, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xE7, 0xC0, 0xFF,
  0x3C, 0x18, 0x1F, 0xE7, 0x80, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7B,
  0xFC, 0x00, 0x0F, 0x7F, 0x84, 0x01, 0xCF, 0xF0, 0xE0, 0x39, 0xFE, 0x1F,
  0x8F, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xF0, 0x03, 0xFD, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x3F, 0x80,
  0x0F, 0xF1, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x83, 0xE0, 0xFE, 0x7F, 0x9F, 0xC7,
  0xFE, 0x3F, 0x9F, 0xCF, 0xF3, 0xFF, 0xCF, 0xFF, 0xF3, 0xF9, 0xFF, 0xF1,
  0xFF, 0xF9, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0x3F, 0xFF, 0x8F, 0xFE,
  0x3F, 0x9F, 0xEF, 0xE1, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x0E, 0x0F, 0xF3,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x87,
  0xE0, 0x00, 0xFE, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x87, 0xFC,
  0x3F, 0xFF, 0xF9, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xBF, 0xFF,
  0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x8F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x30,
  0x3F, 0x80, 0x3C, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xDF, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F,
  0x8F, 0xF0, 0x07, 0x0F, 0xF0, 0x02, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0x1F, 0x8F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0F, 0xFC, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF7,
  0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0,
  0x7F, 0xEF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x3F,
  0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x3F, 0xE3, 0xFF, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0x9F, 0xF0, 0xFC, 0xFF, 0xC1,
  0xE3, 0xFE, 0x06, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xF0, 0x0F,
  0x83, 0xFF, 0x00, 0xF0, 0x3F, 0xF0, 0x06, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x18,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC8, 0x00, 0x1F, 0xF9, 0xC0, 0x07, 0xFF, 0x3F, 0x07, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xCF, 0xF8,
  0x03, 0xFD, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF1, 0xFF, 0x00, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE3, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x70, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x40, 0x01, 0xFF,
  0x8C, 0x00, 0x7F, 0xE1, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x41, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x0F, 0xFB,
  0xFE, 0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F,
  0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F,
  0xF1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0x9F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x3F, 0xF9, 0xFF, 0x9F, 0xF8,
  0x7F, 0xCF, 0xF8, 0x3F, 0xEF, 0xFC, 0x1F, 0xF7, 0xFE, 0x0F, 0xFB, 0xFF,
  0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF,
  0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xFE, 0x0F, 0xFB, 0xFE,
  0x00, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC2, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x03,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0x0F, 0xFC, 0x70,
  0x1F, 0xF1, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x7F, 0x1F, 0xC1,
  0xFF, 0xFE, 0x7F, 0x1F, 0x83, 0xFF, 0xFC, 0x3F, 0x3F, 0x87, 0xFF, 0xFC,
  0x3F, 0x3F, 0x0F, 0xFF, 0xFC, 0x3F, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x7E,
  0x1F, 0xC1, 0xF8, 0x3F, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0xFE, 0x3F, 0x83,
  0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0xF8, 0x7E, 0xFC, 0x3F, 0x83, 0xF0, 0x7E,
  0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0xFC, 0x7F,
  0x07, 0xF0, 0xFC, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0xFC, 0x7F, 0x9F, 0xE3,
  0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xF9, 0xFF, 0x80, 0xFE, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xC7, 0xE0, 0x3F, 0xFC, 0x03, 0x80, 0xFF, 0xE0,
  0x02, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x02, 0x01, 0xFF, 0xC0, 0x38,
  0x07, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x03,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF1, 0xF8, 0x0F,
  0xFF, 0x80, 0x30, 0x0F, 0xFE, 0x00, 0x10, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFC, 0x7F,
  0xE1, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F,
  0xC3, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0x1F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF,
  0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x0F, 0xEF, 0xF8, 0x07, 0xFB, 0xF8,
  0x7F, 0x7F, 0x80, 0x3F, 0xDF, 0xC7, 0xF3, 0xFC, 0x03, 0xFE, 0xFE, 0x3F,
  0xBF, 0xE0, 0x1F, 0xF7, 0xF3, 0xFD, 0xFF, 0x00, 0xFF, 0x3F, 0x9F, 0xCF,
  0xF8, 0x07, 0xF9, 0xFD, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xEF, 0xE7, 0xFC,
  0x03, 0xFE, 0x7F, 0x7F, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0xF1, 0xFF, 0x00,
  0xFF, 0x1F, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0xF8, 0x7F, 0x80, 0x7F,
  0xC7, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F,
  0xF0, 0x7F, 0x80, 0x7F, 0xC3, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0x00, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xEF,
  0xF8, 0x7F, 0xC0, 0x7F, 0xBF, 0xE1, 0xFE, 0x01, 0xFE, 0xFF, 0x87, 0xF8,
  0x07, 0xF9, 0xFE, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xCF, 0xF0, 0x0F, 0xF0, 0xFF, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFE, 0xFF, 0x01, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F,
  0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xFE, 0x01,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x1F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xCF,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0x80, 0x7F, 0xE0,
  0x38, 0x07, 0xFC, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x04, 0x00, 0x3F, 0xE0, 0x60, 0x07, 0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xEF, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xFE, 0x3F,
  0xF0, 0x3F, 0xE3, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xFF, 0xE3, 0xFE,
  0x03, 0xFE, 0x7F, 0xFF, 0x9F, 0xF0, 0x0F, 0xF9, 0xFF, 0xFE, 0x7F, 0xC0,
  0x3F, 0xE7, 0xF7, 0xF9, 0xFE, 0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF8, 0x03,
  0xFE, 0xFE, 0x7F, 0xBF, 0xE0, 0x0F, 0xFF, 0xF9, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xE7, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x00, 0xFF, 0xE7,
  0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE3,
  0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F,
  0x9F, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x3F, 0xE3, 0xFC, 0x0F, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x9F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xEF, 0xF0, 0x1F, 0xF9, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xF0, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x3F, 0xF3, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFE,
  0x7C, 0x3F, 0xF0, 0x10, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x04, 0x1F, 0xF8, 0x78, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xFE, 0x00, 0xFF,
  0xCF, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F,
  0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xEF, 0xF8, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x87, 0xFE, 0x01, 0xC3, 0xFF, 0xCF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xDC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xFF, 0x3F, 0xC0, 0x3F, 0xF9, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xDF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8,
  0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFF, 0x1F, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x80, 0x07, 0xFC, 0x07, 0x80,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFE,
  0xFF, 0xC0, 0x3F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x08, 0x7F, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFE, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0x9F, 0xFE, 0x7F, 0xF8, 0x0F, 0xEF,
  0xFF, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF,
  0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xFC, 0x03, 0xFD,
  0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x87,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x3F, 0xF0,
  0xFF, 0x9F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xF0, 0x7F, 0xEF,
  0xF8, 0x7F, 0xE7, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFB, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xF7, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x1F, 0xC0, 0x03,
  0xFE, 0x04, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x1F, 0xE0, 0x3F, 0xF3, 0xFC, 0x0F, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF,
  0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFE, 0x3F, 0xF0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0x80,
  0x04, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03,
  0xF9, 0xFE, 0x03, 0xFB, 0xFE, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x04, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFD, 0xFC, 0x1F, 0xF8, 0x38, 0x1F, 0xF8, 0x08, 0x1F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x80, 0x1F, 0xF8, 0xF0,
  0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x86, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFC, 0x03,
  0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xEF, 0xF8,
  0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFE, 0xFF, 0x83,
  0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFF, 0x87,
  0xFC, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0xFF, 0x8F, 0xFF, 0x0F, 0xF8, 0xFF,
  0x8F, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F, 0xFF,
  0x1F, 0xF0, 0xFF, 0x9F, 0xBF, 0x1F, 0xE0, 0xFF, 0xBF, 0xBF, 0x3F, 0xE0,
  0xFF, 0x3F, 0xBF, 0x3F, 0xC0, 0xFF, 0x3F, 0x7F, 0x7F, 0xC0, 0xFF, 0x7F,
  0x7F, 0x7F, 0xC0, 0xFF, 0x7F, 0x7F, 0x7F, 0x80, 0xFF, 0x7E, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE,
  0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x43, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xC0, 0x07, 0xFE,
  0x40, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 38, 15, 0, -37 },
  { 82, 21, 13, 24, 5, -37 },
  { 117, 33, 37, 31, 0, -37 },
  { 270, 27, 43, 28, 1, -40 },
  { 416, 42, 38, 46, 3, -38 },
  { 616, 35, 39, 36, 0, -38 },
  { 787, 10, 13, 12, 5, -37 },
  { 804, 21, 46, 18, 1, -38 },
  { 925, 20, 46, 18, -4, -38 },
  { 1040, 24, 25, 26, 4, -40 },
  { 1115, 25, 25, 29, 2, -31 },
  { 1194, 14, 14, 15, -3, -7 },
  { 1219, 15, 8, 17, 1, -18 },
  { 1234, 10, 10, 15, 0, -9 },
  { 1247, 30, 39, 23, -3, -38 },
  { 1394, 26, 39, 28, 2, -38 },
  { 1521, 22, 37, 28, 4, -37 },
  { 1623, 28, 38, 28, -1, -38 },
  { 1756, 27, 39, 28, 0, -38 },
  { 1888, 28, 37, 28, 0, -37 },
  { 2018, 27, 38, 28, 1, -37 },
  { 2147, 27, 39, 28, 2, -38 },
  { 2279, 30, 37, 28, 1, -37 },
  { 2418, 27, 39, 28, 1, -38 },
  { 2550, 25, 39, 28, 2, -38 },
  { 2672, 15, 30, 15, 0, -29 },
  { 2729, 18, 36, 15, -3, -29 },
  { 2810, 25, 28, 29, 2, -33 },
  { 2898, 25, 19, 29, 2, -28 },
  { 2958, 25, 28, 29, 2, -33 },
  { 3046, 22, 39, 23, 3, -38 },
  { 3154, 40, 42, 43, 2, -38 },
  { 3364, 32, 37, 32, -3, -37 },
  { 3512, 31, 37, 31, 0, -37 },
  { 3656, 30, 39, 30, 2, -38 },
  { 3803, 32, 37, 33, 0, -37 },
  { 3951, 28, 37, 27, 0, -37 },
  { 4081, 28, 37, 27, 0, -37 },
  { 4211, 32, 39, 33, 2, -38 },
  { 4367, 35, 37, 34, 0, -37 },
  { 4529, 26, 37, 21, -2, -37 },
  { 4650, 26, 49, 18, -8, -37 },
  { 4810, 36, 37, 32, 0, -37 },
  { 4977, 22, 37, 25, 0, -37 },
  { 5079, 45, 37, 44, 0, -37 },
  { 5288, 38, 37, 38, 0, -37 },
  { 5464, 32, 39, 35, 2, -38 },
  { 5620, 30, 37, 30, 0, -37 },
  { 5759, 32, 47, 35, 2, -38 },
  { 5947, 30, 37, 31, 0, -37 },
  { 6086, 28, 39, 26, 0, -38 },
  { 6223, 26, 37, 26, 4, -37 },
  { 6344, 32, 38, 33, 3, -37 },
  { 6496, 30, 37, 30, 4, -37 },
  { 6635, 46, 37, 45, 4, -37 },
  { 6848, 38, 37, 31, -3, -37 },
  { 7024, 30, 37, 29, 4, -37 },
  { 7163, 31, 37, 26, -2, -37 },
  { 7307, 23, 47, 17, -2, -38 },
  { 7443, 14, 39, 23, 5, -38 },
  { 7512, 23, 47, 17, -4, -38 },
  { 7648, 26, 24, 26, 0, -37 },
  { 7726, 24, 7, 22, -5, 3 },
  { 7747, 13, 8, 18, 7, -40 },
  { 7760, 27, 30, 29, 2, -29 },
  { 7862, 28, 41, 29, 0, -40 },
  { 8006, 23, 30, 24, 2, -29 },
  { 8093, 29, 41, 29, 2, -40 },
  { 8242, 25, 30, 28, 2, -29 },
  { 8336, 30, 52, 19, -5, -40 },
  { 8531, 29, 41, 29, 0, -29 },
  { 8680, 28, 40, 30, 0, -40 },
  { 8820, 17, 40, 16, 0, -40 },
  { 8905, 25, 52, 16, -7, -40 },
  { 9068, 32, 40, 30, 0, -40 },
  { 9228, 18, 40, 16, 0, -40 },
  { 9318, 42, 29, 44, 0, -29 },
  { 9471, 28, 29, 30, 0, -29 },
  { 9573, 25, 30, 29, 2, -29 },
  { 9667, 31, 41, 29, -3, -29 },
  { 9826, 27, 41, 29, 2, -29 },
  { 9965, 24, 29, 21, 0, -29 },
  { 10052, 24, 30, 24, 0, -29 },
  { 10142, 21, 36, 22, 2, -35 },
  { 10237, 28, 30, 30, 2, -29 },
  { 10342, 27, 29, 27, 3, -29 },
  { 10440, 40, 29, 40, 3, -29 },
  { 10585, 33, 29, 27, -3, -29 },
  { 10705, 33, 41, 27, -3, -29 },
  { 10875, 26, 29, 23, -1, -29 },
  { 10970, 22, 45, 18, 0, -37 },
  { 11094, 7, 52, 26, 10, -40 },
  { 11140, 22, 45, 18, -3, -37 },
  { 11264, 25, 10, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC52PT7B_H_
