#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x7B, 0xEF, 0x79, 0xEF, 0x39,
  0xE7, 0x39, 0xE7, 0x3C, 0xE0, 0x03, 0xDE, 0x03, 0x9C, 0x03, 0x9C, 0x07,
  0xBC, 0x07, 0x38, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x0E, 0x70, 0x0E,
  0x70, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x3D, 0xE0, 0x39, 0xC0, 0x39,
  0xC0, 0x39, 0xC0, 0x73, 0x80, 0x01, 0x80, 0x0C, 0x03, 0xFE, 0x3F, 0xE3,
  0xFF, 0x3F, 0x91, 0xEC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x42, 0xF3, 0xBF, 0x9F, 0xF8, 0xFF, 0xC3, 0xF8, 0x02, 0x00,
  0x30, 0x00, 0x1F, 0x01, 0xC3, 0xF8, 0x38, 0x3F, 0x87, 0x87, 0xB8, 0xF0,
  0x73, 0x8E, 0x07, 0x39, 0xE0, 0xF7, 0xBC, 0x0F, 0x7B, 0x9E, 0x7F, 0x73,
  0xF7, 0xEF, 0x7F, 0x3C, 0xEF, 0x70, 0x1C, 0xE7, 0x03, 0xCE, 0x70, 0x38,
  0xE7, 0x07, 0x0E, 0xF0, 0xF0, 0xFE, 0x0E, 0x0F, 0xE1, 0xC0, 0x7C, 0x03,
  0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xEF, 0x81, 0xF3, 0xC0, 0xFB, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xCF, 0x9F, 0xE7, 0x9F, 0xFF, 0xDF, 0x7F,
  0xEF, 0x9F, 0xE7, 0xC7, 0xE3, 0xF7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xDF, 0x80, 0x7B, 0xDE, 0xE7, 0x7B, 0xC0, 0x07, 0x87, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x07, 0x00, 0xE1, 0x1C, 0x7B, 0x8F, 0xFF, 0xFF, 0xC7, 0xF9, 0xF8, 0xFF,
  0x0E, 0xF0, 0xCF, 0x01, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3D,
  0xF7, 0x9E, 0xF3, 0xC0, 0x7F, 0x7E, 0x7E, 0xFE, 0x7F, 0xFF, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3,
  0xFF, 0x7C, 0xF7, 0xCF, 0x78, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF1, 0xFF,
  0x1E, 0xF1, 0xEF, 0x3E, 0xFF, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x3F, 0x1F, 0xE7, 0xFD, 0xFF, 0x9D, 0xE3, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0x03,
  0xF0, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0x0E, 0x7C, 0x11, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC0, 0x07, 0xE1, 0xFF, 0x87, 0xFE,
  0x3F, 0xF0, 0x87, 0x80, 0x7C, 0x03, 0xC1, 0xFC, 0x0F, 0x80, 0x7F, 0x07,
  0xFC, 0x03, 0xE0, 0x1F, 0x40, 0xFB, 0xDF, 0xDF, 0xFC, 0xFF, 0xC7, 0xFC,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0xC3, 0xDE, 0x1D, 0xF1, 0xEF, 0x1E, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xC0, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF2, 0x07, 0xCF, 0x7E, 0x3F, 0xF8, 0xFF,
  0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xE0, 0x3E,
  0x01, 0xEF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0xBE, 0x7D, 0xF3, 0xEF, 0x1E,
  0x78, 0xF3, 0xFF, 0x8F, 0xF8, 0x7F, 0xC1, 0xF8, 0x00, 0x3F, 0xFC, 0xFF,
  0xE3, 0xFF, 0x9F, 0xFE, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x3E, 0xF1,
  0xE7, 0x8F, 0x3C, 0x7F, 0xE3, 0xFE, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFB,
  0xE7, 0x8F, 0x7C, 0x7B, 0xE7, 0xCF, 0xFC, 0x7F, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xFE, 0x3F, 0xE7, 0xFF, 0x7C, 0xF7, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0x7F, 0xE3, 0xDE, 0x03, 0xE0, 0x3C, 0x9F, 0x8F, 0xF8, 0xFF,
  0x0F, 0xC0, 0x1E, 0x3C, 0xF9, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE7,
  0xCF, 0x9E, 0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xE0, 0x00, 0x10, 0x03, 0x01,
  0xF0, 0x7F, 0x1F, 0xE7, 0xF0, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x0F, 0xE7, 0xF8, 0xFE, 0x0F,
  0x80, 0xE0, 0x08, 0x00, 0x1F, 0x8F, 0xF9, 0xFF, 0x9F, 0xF2, 0x1E, 0x07,
  0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0xF8, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x71, 0xFD, 0xDC, 0xFF, 0x3B, 0x9E, 0xE7,
  0xE7, 0x9C, 0xFC, 0xE3, 0x9F, 0x9C, 0xE3, 0xF7, 0x9C, 0xEE, 0x77, 0xBD,
  0xCF, 0xFF, 0x39, 0xF7, 0xC7, 0x80, 0x00, 0x78, 0x04, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E, 0x78,
  0x7C, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xBC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7C, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xF3,
  0xE3, 0xC7, 0x87, 0x9F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1,
  0xE3, 0xC7, 0xC7, 0x8F, 0x9F, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x80, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x09, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE3, 0xC7, 0xC7, 0x87, 0x9F, 0x0F,
  0x3E, 0x1E, 0x7C, 0x7C, 0xF0, 0xF9, 0xE1, 0xF7, 0xC7, 0xCF, 0x9F, 0x9F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x83, 0xFE, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x01,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xF0, 0x4F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xF9, 0xFD, 0xF3, 0xFB, 0xE7, 0xF7, 0xC3, 0xCF, 0x87, 0x9F,
  0x0F, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0x8F, 0x87,
  0x87, 0xC7, 0xC3, 0xC3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x87, 0xC7, 0xC3,
  0xC3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x00,
  0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE1, 0x3F, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x0E, 0x00, 0x0F, 0x8F, 0x87,
  0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0xF7, 0xC0, 0x7B, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xDF,
  0x03, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x3E, 0x00,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0xFB, 0xFF, 0x7F, 0xDF,
  0xF8, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F, 0x73, 0xFC, 0x3D,
  0xCE, 0xF0, 0xF7, 0x7F, 0xC3, 0xDD, 0xDE, 0x0F, 0x7F, 0x78, 0x7D, 0xF9,
  0xE1, 0xE7, 0xE7, 0x87, 0x9F, 0x3E, 0x1E, 0x7C, 0xF0, 0x79, 0xF3, 0xC3,
  0xC7, 0x8F, 0x00, 0x0F, 0x83, 0xE1, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1,
  0xE1, 0xFC, 0x7C, 0x3F, 0xCF, 0x07, 0x79, 0xE1, 0xEF, 0x3C, 0x3D, 0xE7,
  0x87, 0xBF, 0xF0, 0xF3, 0xFC, 0x1E, 0x7F, 0x87, 0xCF, 0xF0, 0xF1, 0xFE,
  0x1E, 0x1F, 0x83, 0xC3, 0xF0, 0x78, 0x7E, 0x1E, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xBC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xDF, 0x0F,
  0x9F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3,
  0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x87, 0xDF, 0x1F, 0x9F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x9F,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFE, 0x0F, 0x78, 0x7D, 0xF1, 0xF7, 0xC7, 0xCF,
  0x1E, 0x3E, 0x78, 0xFB, 0xE1, 0xF0, 0x07, 0xF0, 0x7F, 0xC7, 0xFE, 0x3F,
  0xE3, 0xE1, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1E, 0x61, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC3, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78,
  0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xE0, 0x1F, 0x80, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xF7, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF0, 0x78, 0x7F, 0xC3, 0xE1, 0xEF, 0x0F, 0x8F, 0xBC, 0x3E, 0x3C,
  0xF1, 0xF8, 0xF3, 0xC7, 0xE7, 0xCF, 0x3F, 0x9E, 0x3C, 0xFE, 0xF8, 0xF7,
  0xFB, 0xC3, 0xDF, 0xEF, 0x0F, 0x77, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F,
  0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xE1, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xE7,
  0xC0, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x1F, 0x87, 0xE0, 0xF8, 0x7F,
  0xE3, 0xE7, 0x8F, 0x9E, 0x7C, 0x79, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0x0F, 0xE1, 0xF8, 0x00, 0xE3,
  0xCF, 0x3C, 0xF3, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0xCF, 0x3C,
  0xF0, 0x07, 0xE0, 0xFC, 0x3F, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x0F, 0x80, 0x7E, 0x07, 0x70, 0x7B, 0x83, 0x9E, 0x3C, 0xF3, 0xC3,
  0x9C, 0x1D, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF7, 0xDE, 0x70,
  0x0F, 0x79, 0xFB, 0xCF, 0xFE, 0xFF, 0xE7, 0xCF, 0x7C, 0x7B, 0xE7, 0xDE,
  0x3C, 0xF1, 0xE7, 0x8F, 0x3E, 0xF9, 0xFF, 0xCF, 0xDC, 0x3C, 0xE0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x78, 0x7F, 0xE7, 0xFF,
  0x3F, 0xF9, 0xF3, 0xCF, 0x1E, 0x78, 0xF7, 0xCF, 0xBE, 0x7D, 0xF3, 0xCF,
  0xBE, 0x7F, 0xE7, 0xFF, 0x3D, 0xF0, 0x0F, 0xC3, 0xFC, 0xFF, 0x3F, 0xE7,
  0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x13, 0xEE, 0x7F, 0xC7, 0xF8,
  0x7E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x39,
  0xE3, 0xFF, 0x8F, 0xFE, 0x7F, 0xF1, 0xF3, 0xCF, 0x8F, 0x3E, 0x7C, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x07, 0xDC, 0x00,
  0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xCF, 0x78, 0xFF, 0x9F, 0xFF, 0xEF, 0xFC,
  0xFC, 0x0F, 0x00, 0xF8, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xA0, 0x1E, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x7E, 0xF1,
  0xFF, 0xCF, 0xFE, 0x3E, 0x79, 0xF1, 0xE7, 0xCF, 0x9E, 0x3E, 0x78, 0xF1,
  0xE3, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xF7, 0x80, 0x1E, 0x20, 0xF8,
  0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x78, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xF3, 0xCF,
  0x1E, 0x78, 0xF7, 0xCF, 0xBE, 0x7D, 0xF3, 0xCF, 0x1E, 0x78, 0xF7, 0xCF,
  0xBE, 0x7C, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x3F, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7D, 0xE0, 0x79, 0xF0, 0x79, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0x0F, 0x87,
  0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87,
  0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x00, 0x1E, 0xF1, 0xE1, 0xDF,
  0xBF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3E, 0x7C, 0xF3, 0xC7, 0x8F, 0x3C,
  0x78, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7,
  0x8F, 0x1E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x1E, 0xF0, 0xEF, 0xCF, 0xFE,
  0x7F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xEF, 0x9F, 0x7C, 0xFB, 0xC7, 0x9E,
  0x3C, 0xF1, 0xEF, 0x9F, 0x7C, 0xF8, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF,
  0x78, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0xFB, 0xEF, 0xFC,
  0x7F, 0x83, 0xF0, 0x0F, 0x78, 0x3B, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0x3C,
  0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xFE,
  0x7F, 0xF1, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0x0F, 0x79, 0xFB, 0xCF, 0xFE, 0xFF, 0xE7, 0xCF, 0x7C, 0x7B,
  0xE7, 0xDE, 0x3E, 0xF1, 0xE7, 0x8F, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x3D,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x1E,
  0xE3, 0xBC, 0xFF, 0x9F, 0xE3, 0xF4, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0x9E,
  0x63, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFB, 0x1F, 0x7F, 0xEF,
  0xF9, 0xFE, 0x00, 0x0E, 0x03, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x8F, 0xE3, 0xF8, 0x7E,
  0x00, 0x3C, 0x79, 0xE3, 0xDF, 0x3E, 0xF9, 0xF7, 0x8F, 0x3C, 0x79, 0xE7,
  0xDF, 0x3E, 0xF9, 0xF7, 0xCF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x3E, 0xF0,
  0xF8, 0xFF, 0xC7, 0xFE, 0x7C, 0xF3, 0xE7, 0x9E, 0x3D, 0xE1, 0xEF, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF9,
  0xF1, 0xFF, 0x9F, 0x1E, 0xF9, 0xF3, 0xEF, 0xBF, 0x3C, 0xFB, 0xF7, 0xC7,
  0xBF, 0x78, 0x7F, 0x77, 0x87, 0x77, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x1F, 0x3F,
  0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF0, 0x7D, 0xF0, 0x7C, 0xF0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F,
  0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x7F, 0xE0, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x1F, 0xC3, 0xF0, 0x7C, 0x0F, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF0, 0x7C,
  0x3E, 0x1F, 0x87, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x83, 0xE0, 0xF0,
  0x38, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 11, 7, 11, 2, -18 },
  { 29, 16, 18, 15, 0, -18 },
  { 65, 13, 20, 14, 1, -19 },
  { 98, 20, 18, 22, 1, -18 },
  { 143, 17, 18, 17, 0, -18 },
  { 182, 5, 7, 6, 2, -18 },
  { 187, 9, 22, 9, 1, -18 },
  { 212, 10, 22, 9, -2, -18 },
  { 240, 11, 12, 13, 2, -19 },
  { 257, 12, 12, 14, 1, -15 },
  { 275, 6, 6, 7, -1, -3 },
  { 280, 8, 4, 8, 0, -9 },
  { 284, 5, 4, 7, 0, -4 },
  { 287, 14, 18, 11, -1, -18 },
  { 319, 12, 18, 14, 1, -18 },
  { 346, 11, 18, 14, 2, -18 },
  { 371, 14, 18, 14, -1, -18 },
  { 403, 13, 18, 14, 0, -18 },
  { 433, 13, 18, 14, 0, -18 },
  { 463, 14, 18, 14, 0, -18 },
  { 495, 13, 18, 14, 1, -18 },
  { 525, 14, 18, 14, 1, -18 },
  { 557, 13, 18, 14, 0, -18 },
  { 587, 12, 18, 14, 1, -18 },
  { 614, 7, 14, 7, 0, -14 },
  { 627, 8, 17, 7, -1, -14 },
  { 644, 12, 14, 14, 1, -16 },
  { 665, 12, 9, 14, 1, -13 },
  { 679, 12, 14, 14, 1, -16 },
  { 700, 11, 18, 11, 1, -18 },
  { 725, 19, 20, 21, 1, -18 },
  { 773, 15, 18, 16, -1, -18 },
  { 807, 15, 18, 15, 0, -18 },
  { 841, 14, 18, 14, 1, -18 },
  { 873, 15, 18, 16, 0, -18 },
  { 907, 14, 18, 13, 0, -18 },
  { 939, 14, 18, 13, 0, -18 },
  { 971, 15, 18, 16, 1, -18 },
  { 1005, 17, 18, 16, 0, -18 },
  { 1044, 13, 18, 10, -1, -18 },
  { 1074, 13, 24, 8, -4, -18 },
  { 1113, 17, 18, 15, 0, -18 },
  { 1152, 11, 18, 12, 0, -18 },
  { 1177, 22, 18, 21, 0, -18 },
  { 1227, 19, 18, 18, 0, -18 },
  { 1270, 15, 18, 17, 1, -18 },
  { 1304, 14, 18, 14, 0, -18 },
  { 1336, 15, 22, 17, 1, -18 },
  { 1378, 14, 18, 15, 0, -18 },
  { 1410, 13, 18, 13, 0, -18 },
  { 1440, 12, 18, 13, 2, -18 },
  { 1467, 16, 18, 16, 1, -18 },
  { 1503, 15, 18, 15, 2, -18 },
  { 1537, 22, 18, 22, 2, -18 },
  { 1587, 19, 18, 15, -2, -18 },
  { 1630, 14, 18, 14, 2, -18 },
  { 1662, 15, 18, 13, -1, -18 },
  { 1696, 11, 22, 8, -1, -18 },
  { 1727, 6, 18, 11, 3, -18 },
  { 1741, 11, 22, 8, -2, -18 },
  { 1772, 13, 12, 13, 0, -18 },
  { 1792, 11, 3, 11, -2, 2 },
  { 1797, 5, 4, 9, 4, -19 },
  { 1800, 13, 14, 14, 1, -14 },
  { 1823, 13, 19, 14, 0, -19 },
  { 1854, 11, 14, 12, 1, -14 },
  { 1874, 14, 19, 14, 1, -19 },
  { 1908, 12, 14, 13, 1, -14 },
  { 1929, 15, 25, 9, -3, -19 },
  { 1976, 14, 20, 14, 0, -14 },
  { 2011, 13, 19, 14, 0, -19 },
  { 2042, 8, 19, 7, 0, -19 },
  { 2061, 11, 25, 7, -3, -19 },
  { 2096, 16, 19, 14, 0, -19 },
  { 2134, 9, 19, 7, 0, -19 },
  { 2156, 20, 14, 21, 0, -14 },
  { 2191, 13, 14, 14, 0, -14 },
  { 2214, 12, 14, 14, 1, -14 },
  { 2235, 14, 20, 14, -1, -14 },
  { 2270, 13, 20, 14, 1, -14 },
  { 2303, 11, 14, 10, 0, -14 },
  { 2323, 11, 14, 12, 0, -14 },
  { 2343, 10, 17, 10, 1, -17 },
  { 2365, 13, 14, 14, 1, -14 },
  { 2388, 13, 14, 13, 1, -14 },
  { 2411, 20, 14, 19, 1, -14 },
  { 2446, 16, 14, 13, -1, -14 },
  { 2474, 16, 20, 13, -2, -14 },
  { 2514, 13, 14, 11, -1, -14 },
  { 2537, 11, 22, 9, 0, -18 },
  { 2568, 3, 25, 13, 5, -19 },
  { 2578, 10, 22, 9, -1, -18 },
  { 2606, 12, 5, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC25PT7B_H_
