#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0xE7, 0xF9, 0xFE,
  0x3F, 0xCF, 0xF1, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF9,
  0xFE, 0x3F, 0xCF, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xB9, 0xF0, 0x3F, 0xCE, 0x0C, 0x0F, 0xF7, 0x80, 0x03, 0xFD, 0xE0,
  0x00, 0xFF, 0x70, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1D, 0xFE,
  0x00, 0x07, 0x7F, 0x88, 0x03, 0xCF, 0xE1, 0x80, 0xF3, 0xF8, 0x7C, 0x39,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x7F,
  0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x1F, 0x81,
  0xFC, 0x00, 0xFE, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x3F, 0x83, 0xF0, 0x00,
  0xFE, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x7F, 0x3F, 0x8F,
  0xF8, 0xFF, 0xFE, 0x7F, 0x1F, 0xFC, 0xFF, 0xFE, 0x7F, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFE, 0x7F, 0xFE, 0x7F, 0xF9, 0xFC, 0xFF, 0xFF, 0x3F, 0xF1, 0xFC,
  0xFE, 0x7F, 0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF8,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x03, 0xF9, 0xFE, 0x00,
  0xFE, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFF, 0x7F, 0xC7, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE,
  0x3F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x02, 0x07,
  0xF0, 0x0F, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0x83, 0x8F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xBF, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x00, 0xF1, 0xFE, 0x00,
  0xC1, 0xF8, 0x00, 0x83, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x00, 0x0F, 0x0F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x1F, 0xF9, 0xFF, 0x0F,
  0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFB,
  0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0xC1, 0xFF,
  0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F,
  0xF7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0x07,
  0xFC, 0x7F, 0x83, 0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF9,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFB,
  0xFE, 0x1F, 0x1F, 0xF0, 0x70, 0xFF, 0x03, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0xE0, 0x1C, 0x07, 0xFC,
  0x01, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xC3, 0xFF, 0x00, 0xC0, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0x00, 0x0F, 0xFC, 0xF8,
  0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xEF, 0xF8, 0x03,
  0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF,
  0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x04, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE2, 0x00,
  0x3F, 0xF8, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFE, 0x04, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE3, 0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xFD, 0xFF, 0x81, 0xFE, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF,
  0xF8, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFD, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x81, 0xFE,
  0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83,
  0xFE, 0x3F, 0xF3, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFB, 0xFF, 0x3F, 0xF1, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0xE1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFD, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFB,
  0xFC, 0x07, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x18, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xE1,
  0xFF, 0x1C, 0x0F, 0xF8, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x7C, 0x07, 0xF1, 0xFC, 0x0F, 0xFF, 0x8F, 0xC7, 0xF0,
  0x7F, 0xFE, 0x3F, 0x3F, 0x87, 0xFF, 0xF8, 0xFC, 0xFC, 0x1F, 0xFF, 0xE3,
  0xF7, 0xF0, 0xFF, 0x3F, 0x8F, 0xDF, 0x87, 0xF0, 0xFC, 0x3F, 0x7E, 0x1F,
  0x83, 0xF0, 0xFD, 0xF8, 0xFE, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x7F, 0x0F,
  0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0xFC, 0x7F, 0x07, 0xE0, 0xFF, 0xF1, 0xFC,
  0x1F, 0x87, 0xEF, 0xC7, 0xE0, 0xFE, 0x1F, 0xBF, 0x1F, 0x83, 0xF0, 0xFC,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xC7, 0xFF,
  0xFF, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xF3, 0xFF, 0x83,
  0xF8, 0x7F, 0x8F, 0xF8, 0x0F, 0xE0, 0x38, 0x0F, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF,
  0x87, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE,
  0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xC0, 0xFF, 0xE0, 0x04, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x18, 0x07, 0xFF, 0x07, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x1F,
  0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x60,
  0x3F, 0xF8, 0x00, 0x81, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x7F, 0xFE, 0x7F, 0xE3, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xC7, 0xFC, 0x3F,
  0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0x9F, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F,
  0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF7, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x87, 0xF7, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFE, 0xFE, 0x3F,
  0xBF, 0xE0, 0x3F, 0xDF, 0xC7, 0xF7, 0xF8, 0x07, 0xFB, 0xF9, 0xFC, 0xFF,
  0x00, 0xFF, 0x7F, 0x3F, 0x9F, 0xE0, 0x3F, 0xEF, 0xEF, 0xE7, 0xFC, 0x07,
  0xFD, 0xFD, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0x1F, 0xE0, 0x1F, 0xE7,
  0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE3, 0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC3, 0xFE, 0x03,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0xFF,
  0x00, 0xFF, 0x7F, 0x87, 0xF8, 0x07, 0xFB, 0xFE, 0x7F, 0xC0, 0x7F, 0x9F,
  0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0xFF, 0x00,
  0xFF, 0x1F, 0xF7, 0xF8, 0x0F, 0xF8, 0xFF, 0xBF, 0xC0, 0x7F, 0xC3, 0xFF,
  0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0x00, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFC,
  0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF,
  0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE,
  0x07, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF3,
  0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0x00, 0xFF, 0x80, 0x20, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0x00,
  0x1F, 0xF0, 0x3C, 0x03, 0xFE, 0x07, 0xF1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0,
  0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0x8F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0x0F, 0xFF, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xDF, 0xCF, 0xF8, 0x0F, 0xF1, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0xCF, 0xF0, 0x0F, 0xF3, 0xFB, 0xF9, 0xFF,
  0x00, 0xFF, 0x7F, 0xBF, 0x9F, 0xE0, 0x0F, 0xF7, 0xF3, 0xFB, 0xFE, 0x00,
  0xFF, 0x7F, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF3, 0xFB, 0xFC, 0x00, 0xFF,
  0xFE, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0xC0, 0x7F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F,
  0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFF,
  0xCF, 0xF0, 0x7F, 0xFB, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFE, 0x3F, 0xE1, 0xFF,
  0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0xC1,
  0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFD, 0xFE, 0x03, 0xFF, 0x7F, 0x80, 0x7F,
  0x1F, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xCF, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFC,
  0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x83,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xBF, 0xFC, 0x0F, 0xF3, 0xFF, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFE, 0x3C, 0x3F, 0xE0, 0x11, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x10, 0xFF, 0xC1, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x07, 0xFF, 0x7F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x1F, 0xF9, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x30, 0xFF, 0xC1,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x27, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0xEF, 0xF0, 0x3F,
  0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xCF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0x83, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x08, 0x00, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xF8, 0x01, 0xFE, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x04, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0xFF, 0xC3, 0xFF, 0x00, 0xFE, 0xFF, 0xF3, 0xFF, 0xC0,
  0xFF, 0x7F, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xF3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x7F, 0x3F, 0xF0, 0x0F, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0xE1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF, 0xDF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x3F, 0xBF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x87, 0xFE, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xF0, 0x0F, 0xFB, 0xFF, 0x00,
  0x7F, 0xC7, 0xF0, 0x03, 0xFE, 0x08, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x7F, 0xCF, 0xF0, 0x7F, 0xFB, 0xFC, 0x3F, 0xFE, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF,
  0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF,
  0x07, 0xFC, 0xFF, 0xC1, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFE, 0xFF, 0x80, 0x7F, 0x3F, 0xC0, 0x02, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x7E,
  0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFE, 0x7E, 0x0F, 0xF8, 0x18, 0x1F, 0xF0, 0x10, 0x3F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC4, 0x00, 0xFF, 0x8E, 0x01, 0xFF, 0x1F, 0xDF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x20, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0x00, 0xFF,
  0xCF, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xDF, 0xE0, 0x3F, 0xF7, 0xF8, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0x81,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0x83, 0xFE, 0xFF,
  0x0F, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xF8, 0x7F, 0xCF, 0xF0, 0xFF, 0xE1,
  0xFF, 0x3F, 0xC7, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xFE, 0x3F, 0xE3, 0xFC,
  0x7F, 0xF8, 0xFF, 0x0F, 0xF3, 0xF7, 0xE7, 0xFC, 0x3F, 0xCF, 0xDF, 0x9F,
  0xE0, 0xFF, 0x7F, 0x7E, 0x7F, 0x83, 0xFD, 0xF9, 0xFB, 0xFC, 0x0F, 0xF7,
  0xE7, 0xEF, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xFE,
  0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFE,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x10, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x80,
  0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 37, 14, 0, -36 },
  { 80, 21, 13, 23, 4, -36 },
  { 115, 31, 36, 30, 0, -36 },
  { 255, 26, 41, 27, 1, -38 },
  { 389, 40, 36, 44, 3, -36 },
  { 569, 34, 37, 34, 0, -36 },
  { 727, 11, 13, 12, 4, -36 },
  { 745, 20, 45, 17, 1, -37 },
  { 858, 20, 45, 17, -4, -37 },
  { 971, 23, 24, 25, 4, -38 },
  { 1040, 24, 24, 28, 2, -30 },
  { 1112, 13, 13, 14, -3, -6 },
  { 1134, 15, 7, 16, 0, -17 },
  { 1148, 10, 10, 14, 0, -9 },
  { 1161, 28, 37, 22, -2, -36 },
  { 1291, 25, 37, 27, 2, -36 },
  { 1407, 21, 36, 27, 4, -36 },
  { 1502, 27, 36, 27, -1, -36 },
  { 1624, 26, 37, 27, 0, -36 },
  { 1745, 27, 36, 27, 0, -36 },
  { 1867, 26, 37, 27, 1, -36 },
  { 1988, 26, 37, 27, 2, -36 },
  { 2109, 28, 36, 27, 1, -36 },
  { 2235, 26, 37, 27, 1, -36 },
  { 2356, 24, 37, 27, 2, -36 },
  { 2467, 14, 29, 15, 0, -28 },
  { 2518, 17, 35, 15, -3, -28 },
  { 2593, 24, 26, 28, 2, -31 },
  { 2671, 24, 17, 28, 2, -26 },
  { 2722, 24, 26, 28, 2, -31 },
  { 2800, 21, 37, 22, 3, -36 },
  { 2898, 38, 40, 41, 2, -36 },
  { 3088, 31, 36, 31, -3, -36 },
  { 3228, 29, 36, 30, 0, -36 },
  { 3359, 29, 37, 29, 2, -36 },
  { 3494, 31, 36, 32, 0, -36 },
  { 3634, 27, 36, 26, 0, -36 },
  { 3756, 27, 36, 26, 0, -36 },
  { 3878, 30, 37, 32, 2, -36 },
  { 4017, 34, 36, 33, 0, -36 },
  { 4170, 25, 36, 20, -2, -36 },
  { 4283, 26, 47, 17, -8, -36 },
  { 4436, 35, 36, 31, 0, -36 },
  { 4594, 22, 36, 24, 0, -36 },
  { 4693, 43, 36, 42, 0, -36 },
  { 4887, 37, 36, 36, 0, -36 },
  { 5054, 31, 37, 34, 2, -36 },
  { 5198, 29, 36, 29, 0, -36 },
  { 5329, 31, 45, 34, 2, -36 },
  { 5504, 29, 36, 30, 0, -36 },
  { 5635, 27, 37, 25, 0, -36 },
  { 5760, 25, 36, 25, 4, -36 },
  { 5873, 30, 37, 32, 3, -36 },
  { 6012, 29, 36, 29, 4, -36 },
  { 6143, 44, 36, 43, 4, -36 },
  { 6341, 37, 36, 30, -3, -36 },
  { 6508, 28, 36, 28, 4, -36 },
  { 6634, 30, 36, 25, -2, -36 },
  { 6769, 22, 45, 17, -2, -37 },
  { 6893, 13, 37, 22, 5, -36 },
  { 6954, 22, 45, 17, -4, -37 },
  { 7078, 25, 24, 25, 0, -36 },
  { 7153, 23, 6, 21, -5, 3 },
  { 7171, 12, 8, 17, 7, -38 },
  { 7183, 26, 29, 28, 2, -28 },
  { 7278, 27, 39, 28, 0, -38 },
  { 7410, 22, 29, 23, 2, -28 },
  { 7490, 28, 39, 28, 2, -38 },
  { 7627, 24, 29, 27, 2, -28 },
  { 7714, 29, 50, 19, -5, -38 },
  { 7896, 28, 40, 28, 0, -28 },
  { 8036, 27, 38, 29, 0, -38 },
  { 8165, 17, 39, 15, 0, -39 },
  { 8248, 23, 51, 15, -6, -39 },
  { 8395, 31, 38, 28, 0, -38 },
  { 8543, 17, 38, 15, 0, -38 },
  { 8624, 41, 28, 43, 0, -28 },
  { 8768, 27, 28, 29, 0, -28 },
  { 8863, 24, 29, 28, 2, -28 },
  { 8950, 29, 40, 28, -2, -28 },
  { 9095, 26, 40, 28, 2, -28 },
  { 9225, 23, 28, 20, 0, -28 },
  { 9306, 23, 29, 23, 0, -28 },
  { 9390, 20, 34, 21, 2, -33 },
  { 9475, 27, 29, 29, 2, -28 },
  { 9573, 26, 28, 26, 2, -28 },
  { 9664, 38, 28, 39, 3, -28 },
  { 9797, 32, 28, 26, -3, -28 },
  { 9909, 31, 40, 26, -3, -28 },
  { 10064, 25, 28, 23, -1, -28 },
  { 10152, 21, 44, 18, 0, -36 },
  { 10268, 7, 49, 25, 9, -38 },
  { 10311, 21, 44, 18, -3, -36 },
  { 10427, 24, 9, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC50PT7B_H_
