#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x60, 0xCC, 0xDE, 0xBC, 0x14, 0x69, 0xFB, 0xF2, 0x9F,
  0x96, 0x68, 0x19, 0xF7, 0x1C, 0x3A, 0xAF, 0x9C, 0x20, 0x62, 0xE4, 0xAC,
  0xAB, 0xD7, 0x35, 0x25, 0x47, 0x38, 0x3C, 0x6C, 0x39, 0x7E, 0xDE, 0xFC,
  0x7E, 0xFC, 0x39, 0x18, 0xC4, 0x63, 0x18, 0xC2, 0x00, 0x31, 0x11, 0x13,
  0x32, 0x6C, 0xB7, 0xDF, 0xE7, 0x00, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x78,
  0xFC, 0xF0, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x18, 0x70, 0x39, 0xF6, 0xDB,
  0xCF, 0x6F, 0x9C, 0x3B, 0xBD, 0x63, 0x31, 0x8C, 0x39, 0xF4, 0xC6, 0x31,
  0x8F, 0xBE, 0x39, 0xF0, 0xCE, 0x78, 0x6F, 0xBC, 0x0C, 0x73, 0x9E, 0x5B,
  0xF1, 0x8C, 0x3C, 0xF6, 0x1E, 0x58, 0x6F, 0xBC, 0x1C, 0xF6, 0x1E, 0xFF,
  0x37, 0x9C, 0x7D, 0xF0, 0xC6, 0x30, 0xC6, 0x38, 0x39, 0xF6, 0xCE, 0x7B,
  0x6D, 0x9E, 0x39, 0xF6, 0xDB, 0x7C, 0x6F, 0xBC, 0x6C, 0x0D, 0x80, 0x33,
  0x00, 0x06, 0xC0, 0x04, 0x77, 0x3C, 0x1C, 0x10, 0xFF, 0xF0, 0x3F, 0x83,
  0x83, 0x87, 0xF2, 0x00, 0xFF, 0x37, 0xC0, 0xCC, 0x1E, 0x18, 0x9B, 0xEA,
  0xDD, 0x5F, 0xAB, 0x78, 0xC8, 0x3C, 0x00, 0x0E, 0x3C, 0x78, 0xB3, 0x67,
  0xDF, 0xF3, 0x3D, 0xF6, 0xDF, 0x7D, 0xBF, 0xFE, 0x1E, 0x79, 0x83, 0x06,
  0x1C, 0x1E, 0x3C, 0x38, 0xF9, 0x9B, 0x36, 0xED, 0xBF, 0x7C, 0x3D, 0xF6,
  0x1E, 0x79, 0x8F, 0xBC, 0x3D, 0xF6, 0x1E, 0x79, 0x8C, 0x30, 0x1E, 0x7D,
  0x83, 0x77, 0xDD, 0x9F, 0x3E, 0x36, 0xCD, 0x9B, 0xF7, 0xED, 0xB3, 0x66,
  0x7B, 0x8C, 0xC6, 0x31, 0x9E, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x33,
  0xC0, 0x37, 0x6E, 0x6C, 0x78, 0x78, 0x78, 0xDC, 0xCC, 0x33, 0x18, 0xC6,
  0x33, 0xFF, 0x31, 0xDC, 0xE7, 0x39, 0xDE, 0x75, 0x97, 0x4D, 0xB3, 0x6C,
  0x33, 0x73, 0x7B, 0x7A, 0x7E, 0x4E, 0xCE, 0xCE, 0x1C, 0x7D, 0x9B, 0x36,
  0x7C, 0xDF, 0x3C, 0x39, 0xF6, 0xDB, 0x79, 0x8C, 0x30, 0x1C, 0x7D, 0x9B,
  0x36, 0x7C, 0xDF, 0x3C, 0x18, 0x18, 0x39, 0xF6, 0xDB, 0x79, 0xED, 0xB3,
  0x3D, 0xE6, 0x1C, 0x38, 0x6F, 0xBC, 0xFF, 0xD8, 0xC6, 0x33, 0x18, 0x6F,
  0x3C, 0xF3, 0xDB, 0x6F, 0xBC, 0xCF, 0x3D, 0xB6, 0xF3, 0xCE, 0x38, 0xCD,
  0xEE, 0xF7, 0x7F, 0xEF, 0xB7, 0x73, 0xB9, 0x98, 0x33, 0x1F, 0x1E, 0x1C,
  0x1C, 0x3C, 0x7E, 0xE6, 0xCF, 0x6D, 0x9C, 0x61, 0x86, 0x30, 0x7D, 0xF1,
  0x8C, 0x71, 0x8F, 0xBE, 0x36, 0x66, 0x44, 0xCC, 0xEC, 0xD9, 0x24, 0xDB,
  0x38, 0xC4, 0x23, 0x18, 0xC4, 0x67, 0x00, 0x10, 0xE3, 0x9A, 0xCC, 0xF8,
  0xC0, 0x3D, 0xB6, 0xF2, 0xF9, 0xE0, 0x31, 0x87, 0xDB, 0x6D, 0x3F, 0xBE,
  0x3B, 0x59, 0x8F, 0x38, 0x06, 0x18, 0xF3, 0x66, 0xD9, 0x3E, 0x3C, 0x39,
  0xB7, 0xBC, 0xE9, 0xE0, 0x1C, 0x63, 0xDC, 0x30, 0xC3, 0x18, 0x63, 0x8C,
  0x00, 0x3D, 0xB6, 0xF2, 0xF9, 0xE1, 0xBC, 0x60, 0x31, 0x87, 0xDB, 0x6D,
  0xBD, 0xB6, 0x23, 0x06, 0x66, 0x6C, 0xC0, 0x10, 0xC0, 0x63, 0x18, 0xCC,
  0x63, 0x39, 0x00, 0x30, 0xC1, 0xBB, 0xC7, 0x8F, 0x36, 0x6E, 0x36, 0x66,
  0x66, 0xCC, 0x7F, 0xB6, 0xDB, 0x6D, 0xBD, 0xB6, 0xD8, 0x7D, 0xB6, 0xDB,
  0xDB, 0x60, 0x39, 0xB6, 0xF3, 0xF9, 0xC0, 0x3E, 0x6C, 0xD9, 0x37, 0xCF,
  0x98, 0x30, 0xC0, 0x3D, 0xB6, 0xF2, 0xF9, 0xE1, 0x86, 0x30, 0x7B, 0xD8,
  0xCC, 0x60, 0x7B, 0x5C, 0x6B, 0x78, 0x33, 0xF8, 0xC6, 0x39, 0xC0, 0x6D,
  0xB6, 0xD3, 0xF9, 0xE0, 0xDF, 0xBD, 0xCE, 0x60, 0x9B, 0xBE, 0xBE, 0xFC,
  0xDC, 0xDC, 0x36, 0x78, 0x61, 0xC3, 0xDD, 0x80, 0x36, 0x78, 0xF1, 0xC3,
  0x86, 0x0C, 0x70, 0xC0, 0x78, 0xCC, 0xCF, 0x78, 0x19, 0x88, 0xCE, 0x61,
  0x88, 0x63, 0x00, 0xFF, 0xFF, 0xFC, 0x31, 0x8C, 0x63, 0x9C, 0x8C, 0xE6,
  0x00, 0x67, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 8, 3, 0, -8 },
  { 5, 5, 3, 5, 1, -8 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 6, 9, 6, 0, -8 },
  { 21, 8, 8, 10, 1, -8 },
  { 29, 8, 8, 8, 0, -8 },
  { 37, 2, 3, 3, 1, -8 },
  { 38, 5, 10, 4, 0, -8 },
  { 45, 4, 10, 4, -1, -8 },
  { 50, 5, 5, 6, 1, -8 },
  { 54, 6, 6, 6, 0, -7 },
  { 59, 3, 2, 3, -1, -1 },
  { 60, 3, 2, 4, 0, -4 },
  { 61, 2, 2, 3, 0, -2 },
  { 62, 7, 8, 5, -1, -8 },
  { 69, 6, 8, 6, 0, -8 },
  { 75, 5, 8, 6, 1, -8 },
  { 80, 6, 8, 6, 0, -8 },
  { 86, 6, 8, 6, 0, -8 },
  { 92, 6, 8, 6, 0, -8 },
  { 98, 6, 8, 6, 0, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 6, 8, 6, 0, -8 },
  { 116, 6, 8, 6, 0, -8 },
  { 122, 6, 8, 6, 0, -8 },
  { 128, 3, 6, 3, 0, -6 },
  { 131, 4, 7, 3, -1, -6 },
  { 135, 6, 6, 6, 0, -7 },
  { 140, 6, 4, 6, 0, -6 },
  { 143, 6, 6, 6, 0, -7 },
  { 148, 4, 8, 5, 1, -8 },
  { 152, 9, 9, 9, 0, -8 },
  { 163, 7, 8, 7, -1, -8 },
  { 170, 6, 8, 7, 0, -8 },
  { 176, 7, 8, 6, 0, -8 },
  { 183, 7, 8, 7, 0, -8 },
  { 190, 6, 8, 6, 0, -8 },
  { 196, 6, 8, 6, 0, -8 },
  { 202, 7, 8, 7, 0, -8 },
  { 209, 7, 8, 7, 0, -8 },
  { 216, 5, 8, 4, 0, -8 },
  { 221, 6, 10, 4, -2, -8 },
  { 229, 8, 8, 7, 0, -8 },
  { 237, 5, 8, 5, 0, -8 },
  { 242, 10, 8, 9, 0, -8 },
  { 252, 8, 8, 8, 0, -8 },
  { 260, 7, 8, 7, 0, -8 },
  { 267, 6, 8, 6, 0, -8 },
  { 273, 7, 10, 7, 0, -8 },
  { 282, 6, 8, 7, 0, -8 },
  { 288, 6, 8, 6, 0, -8 },
  { 294, 5, 8, 6, 1, -8 },
  { 299, 6, 8, 7, 1, -8 },
  { 305, 6, 8, 6, 1, -8 },
  { 311, 9, 8, 10, 1, -8 },
  { 320, 8, 8, 7, -1, -8 },
  { 328, 6, 8, 6, 1, -8 },
  { 334, 6, 8, 6, 0, -8 },
  { 340, 4, 10, 4, 0, -8 },
  { 345, 3, 8, 5, 1, -8 },
  { 348, 5, 10, 4, -1, -8 },
  { 355, 6, 5, 6, 0, -8 },
  { 359, 5, 1, 5, -1, 1 },
  { 360, 2, 1, 4, 2, -8 },
  { 361, 6, 6, 6, 0, -6 },
  { 366, 6, 8, 6, 0, -8 },
  { 372, 5, 6, 5, 0, -6 },
  { 376, 7, 8, 6, 0, -8 },
  { 383, 6, 6, 6, 0, -6 },
  { 388, 6, 11, 4, -1, -8 },
  { 397, 6, 9, 6, 0, -6 },
  { 404, 6, 8, 6, 0, -8 },
  { 410, 4, 9, 3, 0, -9 },
  { 415, 5, 12, 3, -1, -9 },
  { 423, 7, 8, 6, 0, -8 },
  { 430, 4, 8, 3, 0, -8 },
  { 434, 9, 6, 9, 0, -6 },
  { 441, 6, 6, 6, 0, -6 },
  { 446, 6, 6, 6, 0, -6 },
  { 451, 7, 9, 6, -1, -6 },
  { 459, 6, 9, 6, 0, -6 },
  { 466, 5, 6, 4, 0, -6 },
  { 470, 5, 6, 5, 0, -6 },
  { 474, 5, 7, 5, 0, -7 },
  { 479, 6, 6, 6, 0, -6 },
  { 484, 5, 6, 6, 1, -6 },
  { 488, 8, 6, 8, 1, -6 },
  { 494, 7, 6, 6, -1, -6 },
  { 500, 7, 9, 6, -1, -6 },
  { 508, 5, 6, 5, 0, -6 },
  { 512, 5, 10, 4, 0, -8 },
  { 519, 2, 11, 6, 2, -8 },
  { 522, 5, 10, 4, -1, -8 },
  { 529, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC11PT7B_H_
