#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0x3F, 0xBF, 0x9F, 0x9F, 0x9F, 0xCF, 0xCF,
  0xEF, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7,
  0xC0, 0x03, 0xE3, 0xF0, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x03, 0xE3,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xC0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFD,
  0xF0, 0xFE, 0xE1, 0x07, 0xE7, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x06, 0xFE, 0x40, 0x73, 0xF3, 0x83,
  0xBF, 0x9F, 0x1F, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFC,
  0x03, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x7E,
  0x01, 0xFB, 0xF0, 0x3E, 0x01, 0xF9, 0xF8, 0x3E, 0x00, 0xFC, 0xFC, 0x3F,
  0x00, 0x7C, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x1F,
  0x80, 0x1F, 0x9F, 0x9F, 0x80, 0x0F, 0xCF, 0xCF, 0x87, 0xC7, 0xEF, 0xCF,
  0xCF, 0xF1, 0xFF, 0xEF, 0xCF, 0xFC, 0xFF, 0xE7, 0xCF, 0xFF, 0x7F, 0xE7,
  0xEF, 0xFF, 0x9F, 0xE7, 0xE7, 0xE7, 0xC1, 0xC3, 0xE3, 0xE3, 0xE0, 0x03,
  0xF3, 0xF1, 0xF0, 0x03, 0xF1, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0xFC, 0x01,
  0xF8, 0x7C, 0x7E, 0x01, 0xF8, 0x3E, 0x3E, 0x00, 0xF8, 0x1F, 0x3F, 0x00,
  0xFC, 0x0F, 0xDF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x8F,
  0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x9F, 0xE3, 0xFF, 0xFD, 0xFC, 0x7F,
  0xBF, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0x8F, 0xF0, 0xFF,
  0xF0, 0xFF, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xC7, 0xF8, 0x7F, 0x7F, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC,
  0xFC, 0xF8, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x10, 0x7C,
  0x07, 0x8F, 0x80, 0xFD, 0xF0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x1E, 0x3F, 0x01, 0x87, 0xC0, 0x10, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x00,
  0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xF0, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xF0,
  0xFE, 0x7F, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x1F,
  0xCF, 0xF0, 0xFE, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x1F, 0xE7, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xDF, 0xC3, 0xCF, 0xF0, 0xE3, 0xF8, 0x10, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xF8, 0xFF, 0x01, 0x81, 0xFC, 0x04, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xBF, 0xE0, 0x60, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFA, 0x00, 0x3F, 0xDC, 0x03, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0x7F, 0x00, 0xFD, 0xFC,
  0x07, 0xEF, 0xE0, 0x3F, 0x3F, 0x80, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x08, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x40, 0x1F, 0xE3, 0x01, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xE1, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x40, 0x0F, 0xEF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7F, 0xDF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0x0F, 0xF3, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0xDF, 0xE7, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFE, 0xFE, 0x3F, 0xFF, 0xC1, 0xF9, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x03, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x00,
  0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xF7, 0xFC, 0x60, 0x7F, 0x10, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x3E, 0x0F, 0xC1, 0xFC, 0x3F, 0x1F, 0x87, 0xFF, 0x9F, 0x1F,
  0x0F, 0xFF, 0x1F, 0x3E, 0x1F, 0xFF, 0x1F, 0x3E, 0x3F, 0x9F, 0x1F, 0x7E,
  0x3E, 0x1F, 0x1F, 0x7C, 0x7E, 0x3F, 0x1F, 0x7C, 0x7C, 0x3E, 0x1F, 0x7C,
  0xFC, 0x3E, 0x1F, 0x7C, 0xFC, 0x3E, 0x3E, 0xF8, 0xF8, 0x7E, 0x3E, 0xF8,
  0xF8, 0x7C, 0x3E, 0xF8, 0xF8, 0xFC, 0x7C, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7C, 0x7F, 0xFF, 0xF0, 0x7C, 0x3F, 0x9F, 0xC0, 0x7E,
  0x0E, 0x07, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x3F,
  0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0x80,
  0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x87, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1C, 0x3F, 0xE0, 0x08, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x10, 0x7F,
  0xC0, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0xE1, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x04, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xF0, 0x18, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0xF3, 0xFC, 0x7F, 0xF9, 0xFE, 0x3F, 0xF8, 0xFF, 0x1F, 0xFC,
  0x7F, 0x8F, 0xFE, 0x3F, 0xCF, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x10, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x80,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFE,
  0x7F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xDF, 0x0F, 0xBF, 0x80,
  0xFD, 0xF1, 0xFB, 0xF8, 0x1F, 0xDF, 0x1F, 0x7F, 0x01, 0xFD, 0xF3, 0xF7,
  0xF0, 0x1F, 0xDF, 0x3E, 0x7F, 0x01, 0xFD, 0xF7, 0xE7, 0xF0, 0x1F, 0x9F,
  0xFE, 0x7E, 0x03, 0xF9, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F, 0xFC, 0xFE, 0x03,
  0xF9, 0xFF, 0x8F, 0xE0, 0x3F, 0x9F, 0xF8, 0xFE, 0x07, 0xF1, 0xFF, 0x0F,
  0xC0, 0x7F, 0x1F, 0xF1, 0xFC, 0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0xE1, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x00,
  0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0,
  0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0x01, 0xF8, 0x1F, 0xFE, 0x0F, 0xE0, 0x7F,
  0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0x83, 0xF0, 0x3F, 0xFF,
  0x1F, 0xC0, 0xFF, 0xFC, 0x7F, 0x03, 0xF7, 0xF1, 0xFC, 0x0F, 0xCF, 0xC7,
  0xF0, 0x3F, 0x3F, 0x9F, 0x81, 0xFC, 0xFE, 0xFE, 0x07, 0xF3, 0xFB, 0xF8,
  0x1F, 0xC7, 0xEF, 0xE0, 0x7F, 0x1F, 0xFF, 0x81, 0xF8, 0x7F, 0xFC, 0x0F,
  0xE1, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x03, 0xF0,
  0x3F, 0xFC, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0x81, 0xFC, 0x07,
  0xFE, 0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x7F, 0xC0, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x0F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xE3, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xE1, 0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFC,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x3F, 0xCF, 0xE0, 0x3F, 0xCF,
  0xE0, 0x3F, 0x8F, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x1C, 0x0F,
  0xE0, 0x10, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC2, 0x00,
  0x7F, 0x06, 0x01, 0xFC, 0x1E, 0x0F, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3,
  0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8,
  0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFC,
  0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFE,
  0xFE, 0x03, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x81, 0xFE, 0xFE, 0x07, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0x87, 0xF0,
  0xFE, 0x3F, 0xF8, 0xFF, 0x0F, 0xE3, 0xFF, 0x8F, 0xE0, 0xFE, 0x3E, 0xF8,
  0xFE, 0x0F, 0xE7, 0xFF, 0x9F, 0xC0, 0xFE, 0x7F, 0xF9, 0xFC, 0x0F, 0xEF,
  0xDF, 0x9F, 0xC0, 0xFE, 0xFD, 0xFB, 0xF8, 0x0F, 0xEF, 0xDF, 0xBF, 0x80,
  0xFF, 0xF9, 0xFB, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x7F, 0x03, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x9F, 0xE0, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0xC7, 0xE0,
  0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7E, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x3F, 0x8F,
  0xC7, 0xF1, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x0F, 0xF7, 0xF0, 0x7F, 0xDF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1,
  0xFC, 0xFF, 0x07, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0x7F, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F,
  0xC7, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFB, 0xFE, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xF8, 0x61, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x06, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF1, 0xFC, 0x03, 0xFD, 0xFC, 0x07,
  0xFD, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xC7, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F,
  0x9F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFE, 0x7F, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x7F, 0x87,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x87, 0xF8, 0x38, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xEC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x9F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x03, 0xFC, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0x00, 0x7F, 0x83, 0x81, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF3, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x4F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF9,
  0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x9F,
  0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x7E, 0x01, 0xFB, 0xFE, 0x3F,
  0xC0, 0xFF, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xE3, 0xF8, 0x7F, 0x87,
  0xF8, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x0F,
  0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xC0, 0x07, 0xE3, 0xE0, 0x1F, 0xBF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3,
  0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0x1F, 0xE7, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F,
  0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x87, 0xFB, 0xFC,
  0x3F, 0xDF, 0xE1, 0xFC, 0xFF, 0x1F, 0xE3, 0xFD, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xF9, 0xF0, 0x01, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xE3, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xBF, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0xFC, 0x0F, 0xF3, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE3, 0xE0,
  0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xEF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xC4, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xCF, 0x07, 0xF0, 0x40, 0xFE, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x80, 0x7F, 0x1F, 0x1F, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x87, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xC3, 0xF9,
  0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3,
  0xF9, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F,
  0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F,
  0x1F, 0xC7, 0xF8, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xC0, 0xFE, 0x7E, 0x00, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x3F,
  0x0F, 0xF1, 0xF8, 0x7F, 0x0F, 0xC7, 0xF8, 0x7E, 0x3F, 0x83, 0xF9, 0xFC,
  0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFE, 0x1F, 0xF0, 0xFE, 0xFE, 0x1F, 0xF0, 0xFE, 0xFE,
  0x1F, 0xF1, 0xFC, 0xFE, 0x3F, 0xF1, 0xFC, 0xFE, 0x3F, 0xF3, 0xFC, 0xFE,
  0x3F, 0xF3, 0xF8, 0xFE, 0x7F, 0xE3, 0xF8, 0xFE, 0x7F, 0xE7, 0xF0, 0x7E,
  0x7F, 0xE7, 0xF0, 0x7E, 0xFB, 0xEF, 0xE0, 0x7E, 0xFB, 0xEF, 0xE0, 0x7F,
  0xFB, 0xEF, 0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xFD, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x1F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF8,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x04, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 29, 12, 0, -29 },
  { 52, 17, 10, 19, 4, -29 },
  { 74, 26, 29, 25, 0, -29 },
  { 169, 21, 33, 22, 1, -31 },
  { 256, 33, 30, 36, 2, -30 },
  { 380, 28, 30, 28, 0, -30 },
  { 485, 8, 10, 10, 4, -29 },
  { 495, 16, 36, 14, 1, -30 },
  { 567, 16, 36, 14, -3, -30 },
  { 639, 19, 19, 21, 3, -31 },
  { 685, 19, 19, 23, 2, -24 },
  { 731, 10, 10, 12, -2, -5 },
  { 744, 13, 6, 13, 0, -14 },
  { 754, 8, 7, 12, 0, -7 },
  { 761, 23, 30, 18, -2, -30 },
  { 848, 21, 30, 22, 1, -30 },
  { 927, 18, 29, 22, 3, -29 },
  { 993, 22, 30, 22, -1, -30 },
  { 1076, 21, 30, 22, 0, -30 },
  { 1155, 22, 29, 22, 0, -29 },
  { 1235, 21, 29, 22, 1, -29 },
  { 1312, 22, 30, 22, 1, -30 },
  { 1395, 23, 29, 22, 1, -29 },
  { 1479, 21, 30, 22, 1, -30 },
  { 1558, 20, 30, 22, 2, -30 },
  { 1633, 12, 23, 12, 0, -23 },
  { 1668, 14, 28, 12, -2, -23 },
  { 1717, 19, 22, 23, 2, -26 },
  { 1770, 19, 15, 23, 2, -22 },
  { 1806, 19, 22, 23, 2, -26 },
  { 1859, 18, 30, 18, 2, -30 },
  { 1927, 32, 33, 34, 1, -30 },
  { 2059, 25, 29, 26, -2, -29 },
  { 2150, 24, 29, 24, 0, -29 },
  { 2237, 23, 30, 23, 2, -30 },
  { 2324, 25, 29, 26, 0, -29 },
  { 2415, 22, 29, 21, 0, -29 },
  { 2495, 22, 29, 21, 0, -29 },
  { 2575, 25, 30, 26, 2, -30 },
  { 2669, 28, 29, 27, 0, -29 },
  { 2771, 20, 29, 17, -1, -29 },
  { 2844, 22, 38, 14, -7, -29 },
  { 2949, 29, 29, 25, 0, -29 },
  { 3055, 18, 29, 20, 0, -29 },
  { 3121, 36, 29, 35, 0, -29 },
  { 3252, 30, 29, 30, 0, -29 },
  { 3361, 25, 30, 28, 2, -30 },
  { 3455, 24, 29, 23, 0, -29 },
  { 3542, 25, 37, 28, 2, -30 },
  { 3658, 24, 29, 24, 0, -29 },
  { 3745, 22, 30, 21, 0, -30 },
  { 3828, 21, 29, 21, 3, -29 },
  { 3905, 25, 29, 26, 2, -29 },
  { 3996, 24, 29, 24, 3, -29 },
  { 4083, 36, 29, 35, 3, -29 },
  { 4214, 30, 29, 25, -2, -29 },
  { 4323, 24, 29, 23, 3, -29 },
  { 4410, 25, 29, 21, -2, -29 },
  { 4501, 18, 37, 14, -1, -30 },
  { 4585, 11, 30, 18, 4, -30 },
  { 4627, 18, 37, 14, -3, -30 },
  { 4711, 21, 19, 21, 0, -29 },
  { 4761, 19, 5, 17, -4, 3 },
  { 4773, 9, 6, 14, 6, -31 },
  { 4780, 22, 23, 23, 1, -23 },
  { 4844, 22, 31, 23, 0, -31 },
  { 4930, 19, 23, 19, 1, -23 },
  { 4985, 24, 31, 23, 1, -31 },
  { 5078, 20, 23, 22, 1, -23 },
  { 5136, 24, 41, 15, -4, -31 },
  { 5259, 23, 33, 23, 0, -23 },
  { 5354, 22, 31, 24, 0, -31 },
  { 5440, 14, 32, 12, 0, -32 },
  { 5496, 19, 42, 12, -5, -32 },
  { 5596, 26, 31, 23, 0, -31 },
  { 5697, 14, 31, 12, 0, -31 },
  { 5752, 34, 23, 35, 0, -23 },
  { 5850, 22, 23, 24, 0, -23 },
  { 5914, 21, 23, 23, 1, -23 },
  { 5975, 24, 33, 23, -2, -23 },
  { 6074, 22, 33, 23, 1, -23 },
  { 6165, 19, 23, 17, 0, -23 },
  { 6220, 19, 23, 19, 0, -23 },
  { 6275, 17, 27, 17, 1, -27 },
  { 6333, 21, 23, 24, 2, -23 },
  { 6394, 21, 23, 21, 2, -23 },
  { 6455, 32, 23, 32, 2, -23 },
  { 6547, 26, 23, 22, -2, -23 },
  { 6622, 26, 33, 21, -3, -23 },
  { 6730, 20, 23, 18, -1, -23 },
  { 6788, 18, 35, 15, 0, -29 },
  { 6867, 6, 40, 21, 7, -31 },
  { 6897, 17, 35, 15, -2, -29 },
  { 6972, 19, 7, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC41PT7B_H_
