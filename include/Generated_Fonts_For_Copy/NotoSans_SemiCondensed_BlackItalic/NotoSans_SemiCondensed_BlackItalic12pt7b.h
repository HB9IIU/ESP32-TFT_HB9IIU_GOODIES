#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x37, 0x66, 0x66, 0x0C, 0xC0, 0x7E, 0xF5, 0xA0, 0x1E, 0x16, 0x35,
  0x7E, 0x2C, 0xFE, 0xFE, 0x78, 0x58, 0x08, 0x7D, 0xD3, 0x83, 0x83, 0xA7,
  0x7C, 0x70, 0x40, 0x61, 0x79, 0x2D, 0x97, 0x8E, 0xBA, 0xF4, 0xDA, 0x4F,
  0x67, 0x00, 0x18, 0x3C, 0x36, 0x3C, 0x3B, 0xFF, 0xDE, 0xFC, 0x7E, 0x7B,
  0x60, 0x19, 0x88, 0xC6, 0x63, 0x18, 0xC2, 0x18, 0x30, 0xC6, 0x31, 0x8C,
  0x46, 0x33, 0x30, 0x37, 0xBE, 0xED, 0x88, 0x21, 0x3F, 0xF2, 0x10, 0x6D,
  0xE0, 0xFE, 0xF0, 0x06, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0xE0, 0x18,
  0xF6, 0xDB, 0x6F, 0xBE, 0xFE, 0x70, 0x19, 0xFF, 0xE3, 0x18, 0xCE, 0x60,
  0x19, 0xF2, 0xC3, 0x18, 0xE6, 0x3F, 0xF8, 0x39, 0xF4, 0xC3, 0x30, 0x70,
  0xFF, 0xF8, 0x0C, 0x31, 0xCF, 0x6F, 0x6F, 0xC6, 0x18, 0x3E, 0x78, 0xC3,
  0x87, 0xC3, 0x83, 0x7C, 0xF8, 0x0E, 0x79, 0xC3, 0xC7, 0xDD, 0xBB, 0x3E,
  0x78, 0x7E, 0xFC, 0x30, 0x61, 0x87, 0x0C, 0x38, 0xE0, 0x18, 0xF6, 0xDF,
  0x39, 0xFC, 0xFF, 0x78, 0x19, 0xF6, 0xDB, 0x7D, 0xF1, 0xFE, 0xF0, 0x2C,
  0x81, 0xB0, 0x13, 0x10, 0x06, 0x66, 0xC0, 0x08, 0xDF, 0x8F, 0x1C, 0x20,
  0xF8, 0x3F, 0xF0, 0x86, 0x3C, 0x77, 0xF2, 0x00, 0x77, 0xE6, 0x66, 0x60,
  0x18, 0xC0, 0x0E, 0x0F, 0xE2, 0x09, 0xBF, 0x5A, 0xF5, 0xAD, 0xF9, 0x6C,
  0x62, 0x0F, 0x80, 0x0E, 0x0E, 0x1E, 0x1E, 0x3E, 0x37, 0x7F, 0x63, 0xE3,
  0x38, 0x7D, 0xDB, 0x77, 0x8D, 0x9B, 0x7E, 0xF8, 0x19, 0xFE, 0x70, 0xC3,
  0x0C, 0x3E, 0xF8, 0x38, 0x7D, 0xDB, 0x36, 0x6C, 0xDB, 0xFE, 0xF8, 0x3E,
  0x79, 0xC3, 0x07, 0xCC, 0x18, 0x7C, 0xF8, 0x3E, 0x79, 0xC3, 0x07, 0xCF,
  0x18, 0x70, 0xC0, 0x1C, 0xFF, 0x96, 0x0D, 0xDB, 0xB3, 0x7E, 0x78, 0x33,
  0x33, 0x73, 0x66, 0x7E, 0x66, 0x66, 0xEE, 0xCC, 0x7D, 0xE3, 0x0C, 0x31,
  0xC6, 0x3C, 0xF0, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xCF, 0x38,
  0x33, 0x37, 0x7E, 0x6C, 0x78, 0x7C, 0x6C, 0xEC, 0xCE, 0x31, 0x9C, 0xC6,
  0x31, 0x9F, 0xF8, 0x39, 0xCE, 0x77, 0xBD, 0xEF, 0x7A, 0xDF, 0xE7, 0xDB,
  0x76, 0xD9, 0x80, 0x31, 0x9C, 0xDE, 0xCF, 0x67, 0xB3, 0x79, 0xBD, 0x9C,
  0xCE, 0x00, 0x18, 0xFB, 0xBE, 0x3C, 0x79, 0xF3, 0x7E, 0x78, 0x38, 0x7D,
  0xDB, 0x37, 0xCF, 0x98, 0x70, 0xC0, 0x18, 0xFB, 0xBE, 0x3C, 0x79, 0xF3,
  0x7E, 0x78, 0x30, 0x70, 0x38, 0x7D, 0xDB, 0x37, 0xCF, 0x1F, 0x76, 0xCE,
  0x18, 0xF6, 0x5C, 0x78, 0xE9, 0xBE, 0xF0, 0xFF, 0xF3, 0x1C, 0x61, 0x86,
  0x18, 0xC0, 0x66, 0xCF, 0xBE, 0x6C, 0xD9, 0xB7, 0x7C, 0xF0, 0xC7, 0x9B,
  0x36, 0xCD, 0x9F, 0x3C, 0x78, 0xE0, 0xCC, 0xF3, 0x3D, 0xDF, 0x76, 0xDD,
  0xBF, 0xCE, 0xF3, 0xBC, 0xEE, 0x00, 0x39, 0x8D, 0x87, 0xC3, 0xC1, 0xC0,
  0xE0, 0xD8, 0xEC, 0xE7, 0x00, 0xCF, 0x9B, 0xE3, 0xC7, 0x0C, 0x18, 0x30,
  0xE0, 0x3F, 0x3F, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x7C, 0xFC, 0x39, 0xD8,
  0xC6, 0x31, 0x18, 0xC6, 0x38, 0xD9, 0x36, 0xDB, 0x60, 0x39, 0xC6, 0x31,
  0x98, 0xC6, 0x31, 0x38, 0x08, 0x63, 0x8A, 0x6F, 0x30, 0xF8, 0xCC, 0x36,
  0xF9, 0xB3, 0x6E, 0xDF, 0x9A, 0x00, 0x30, 0xC6, 0xDF, 0x6D, 0xB6, 0xFF,
  0xF8, 0x1D, 0xE6, 0x38, 0xE3, 0xE7, 0x80, 0x06, 0x0C, 0xDB, 0xE6, 0xCD,
  0xBB, 0x7E, 0x68, 0x19, 0xF6, 0xFF, 0xE3, 0xA7, 0x80, 0x0E, 0x38, 0x71,
  0xE3, 0x06, 0x0C, 0x18, 0x70, 0xC3, 0x86, 0x00, 0x36, 0xF9, 0xB3, 0x6E,
  0xDF, 0x9E, 0x0C, 0xF9, 0xE0, 0x30, 0xC6, 0xDF, 0x6D, 0xB6, 0xF3, 0xDC,
  0x33, 0x76, 0x66, 0x6C, 0xC0, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8E, 0x30,
  0xCF, 0x38, 0x30, 0x61, 0xDB, 0x67, 0xCF, 0x1E, 0x6E, 0xCC, 0x33, 0x76,
  0x66, 0x6C, 0xC0, 0x6D, 0x9F, 0xF6, 0xED, 0xB7, 0x6D, 0xB3, 0x6D, 0xD8,
  0x6D, 0xF6, 0xDB, 0x6F, 0x3D, 0xC0, 0x19, 0xF6, 0xDB, 0xEF, 0xF7, 0x80,
  0x36, 0x7C, 0xD9, 0xB3, 0x6F, 0xDF, 0x30, 0x61, 0xC0, 0x36, 0xF9, 0xB3,
  0x6E, 0xDF, 0x9E, 0x0C, 0x18, 0x30, 0x6B, 0xDE, 0xC6, 0x63, 0x00, 0x3B,
  0xD8, 0xE3, 0xFF, 0xC0, 0x31, 0xFE, 0xC6, 0x31, 0xCE, 0x76, 0xDD, 0xB3,
  0x66, 0xDF, 0x9B, 0x00, 0xDF, 0x6D, 0xBC, 0xF3, 0x8E, 0x00, 0xD9, 0xED,
  0xBE, 0xDD, 0x4E, 0xE7, 0x73, 0x30, 0x37, 0x36, 0x1C, 0x1C, 0x3C, 0x7C,
  0xEE, 0x37, 0x36, 0x36, 0x3C, 0x3C, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0x7D,
  0xE3, 0x8C, 0x63, 0xEF, 0x00, 0x09, 0xCC, 0x66, 0x63, 0x8C, 0x63, 0x18,
  0xFF, 0xFF, 0xFF, 0x21, 0xC6, 0x63, 0x0C, 0xE6, 0x67, 0x30, 0xFE, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 4, 5, 1, -9 },
  { 9, 8, 9, 7, 0, -9 },
  { 18, 7, 10, 6, 0, -9 },
  { 27, 9, 9, 11, 1, -9 },
  { 38, 8, 9, 8, 0, -9 },
  { 47, 3, 4, 3, 1, -9 },
  { 49, 5, 11, 4, 0, -9 },
  { 56, 5, 11, 4, -1, -9 },
  { 63, 5, 6, 6, 1, -9 },
  { 67, 5, 6, 7, 1, -7 },
  { 71, 3, 4, 3, -1, -2 },
  { 73, 4, 2, 4, 0, -4 },
  { 74, 2, 2, 3, 0, -2 },
  { 75, 7, 9, 5, -1, -9 },
  { 83, 6, 9, 6, 0, -9 },
  { 90, 5, 9, 6, 1, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 7, 9, 6, 0, -9 },
  { 125, 7, 9, 6, 0, -9 },
  { 133, 7, 9, 6, 0, -9 },
  { 141, 6, 9, 6, 0, -9 },
  { 148, 6, 9, 6, 0, -9 },
  { 155, 3, 7, 4, 0, -7 },
  { 158, 4, 9, 4, -1, -7 },
  { 163, 5, 7, 7, 1, -8 },
  { 168, 5, 4, 7, 1, -6 },
  { 171, 5, 7, 7, 1, -8 },
  { 176, 5, 9, 5, 1, -9 },
  { 182, 10, 10, 10, 0, -9 },
  { 195, 8, 9, 7, -1, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 6, 9, 7, 1, -9 },
  { 219, 7, 9, 8, 0, -9 },
  { 227, 7, 9, 6, 0, -9 },
  { 235, 7, 9, 6, 0, -9 },
  { 243, 7, 9, 8, 1, -9 },
  { 251, 8, 9, 8, 0, -9 },
  { 260, 6, 9, 5, 0, -9 },
  { 267, 6, 12, 4, -2, -9 },
  { 276, 8, 9, 7, 0, -9 },
  { 285, 5, 9, 6, 0, -9 },
  { 291, 10, 9, 10, 0, -9 },
  { 303, 9, 9, 9, 0, -9 },
  { 314, 7, 9, 8, 1, -9 },
  { 322, 7, 9, 7, 0, -9 },
  { 330, 7, 11, 8, 1, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 6, 9, 6, 0, -9 },
  { 355, 6, 9, 6, 1, -9 },
  { 362, 7, 9, 8, 1, -9 },
  { 370, 7, 9, 7, 1, -9 },
  { 378, 10, 9, 10, 1, -9 },
  { 390, 9, 9, 7, -1, -9 },
  { 401, 7, 9, 7, 1, -9 },
  { 409, 8, 9, 6, -1, -9 },
  { 418, 5, 11, 4, 0, -9 },
  { 425, 3, 9, 5, 1, -9 },
  { 429, 5, 11, 4, -1, -9 },
  { 436, 6, 6, 6, 0, -9 },
  { 441, 5, 1, 5, -1, 1 },
  { 442, 3, 2, 4, 2, -9 },
  { 443, 7, 7, 7, 0, -7 },
  { 450, 6, 9, 7, 0, -9 },
  { 457, 6, 7, 6, 0, -7 },
  { 463, 7, 9, 7, 0, -9 },
  { 471, 6, 7, 6, 0, -7 },
  { 477, 7, 12, 4, -1, -9 },
  { 488, 7, 10, 7, 0, -7 },
  { 497, 6, 9, 7, 0, -9 },
  { 504, 4, 9, 4, 0, -9 },
  { 509, 6, 12, 4, -2, -9 },
  { 518, 7, 9, 7, 0, -9 },
  { 526, 4, 9, 4, 0, -9 },
  { 531, 10, 7, 10, 0, -7 },
  { 540, 6, 7, 7, 0, -7 },
  { 546, 6, 7, 7, 0, -7 },
  { 552, 7, 10, 7, -1, -7 },
  { 561, 7, 10, 7, 0, -7 },
  { 570, 5, 7, 5, 0, -7 },
  { 575, 5, 7, 6, 0, -7 },
  { 580, 5, 8, 5, 0, -8 },
  { 585, 7, 7, 7, 0, -7 },
  { 592, 6, 7, 6, 1, -7 },
  { 598, 9, 7, 9, 1, -7 },
  { 606, 8, 7, 6, -1, -7 },
  { 613, 8, 10, 6, -1, -7 },
  { 623, 6, 7, 5, 0, -7 },
  { 629, 5, 11, 4, 0, -9 },
  { 636, 2, 12, 6, 2, -9 },
  { 639, 5, 11, 4, -1, -9 },
  { 646, 6, 2, 7, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC12PT7B_H_
