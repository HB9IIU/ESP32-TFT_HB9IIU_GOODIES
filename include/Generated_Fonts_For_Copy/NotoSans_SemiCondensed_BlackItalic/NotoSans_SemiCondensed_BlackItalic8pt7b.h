#ifndef _NOTOSANS_SEMICONDENSED_BLACKITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACKITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-BlackItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_BlackItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x61, 0x80, 0xBC, 0x29, 0xBE, 0xBE, 0x70, 0x27, 0x63, 0xBE,
  0x64, 0xD3, 0xB2, 0xD2, 0xAD, 0x80, 0x32, 0x9D, 0xDF, 0xFC, 0xC0, 0x29,
  0x69, 0x30, 0x22, 0x32, 0x22, 0xC0, 0x5F, 0x70, 0x22, 0xF2, 0xE0, 0xC0,
  0xC0, 0x12, 0x24, 0xC8, 0x35, 0xDD, 0xF6, 0x3F, 0xA5, 0x80, 0x75, 0x32,
  0x4F, 0x75, 0x37, 0xBE, 0x13, 0x7F, 0xF2, 0x77, 0x67, 0xBE, 0x36, 0x7D,
  0xF6, 0x7B, 0x8C, 0x46, 0x60, 0x35, 0x77, 0xDE, 0x75, 0xD7, 0x3E, 0x43,
  0x43, 0x80, 0x16, 0xE1, 0xF0, 0xF0, 0x86, 0x3C, 0x67, 0x24, 0x0C, 0x39,
  0x17, 0xEB, 0xBD, 0x23, 0x00, 0x33, 0x75, 0xF9, 0x72, 0xDC, 0xED, 0x78,
  0x3B, 0x51, 0x8C, 0x38, 0x73, 0xD6, 0xBD, 0x70, 0x77, 0x77, 0xCE, 0x77,
  0x47, 0xCC, 0x3B, 0x51, 0xFD, 0x38, 0x6A, 0x5E, 0xFD, 0xE8, 0x76, 0x64,
  0x4E, 0x33, 0x22, 0x66, 0xCC, 0x6D, 0x67, 0x1C, 0xF3, 0x40, 0x69, 0x2D,
  0xC0, 0x66, 0xDD, 0xB3, 0x6F, 0x57, 0x80, 0x65, 0xB7, 0x9E, 0xDA, 0x60,
  0x33, 0xD3, 0x9D, 0xB8, 0x73, 0xD6, 0xEC, 0x60, 0x33, 0xD3, 0x9D, 0xB8,
  0xC0, 0x72, 0xD6, 0xEF, 0x68, 0x35, 0x66, 0xBE, 0xFE, 0x4C, 0xC8, 0x6A,
  0x56, 0xBD, 0x38, 0x9B, 0xAE, 0xCC, 0xB7, 0x6A, 0xF6, 0xCD, 0x9A, 0x00,
  0x4B, 0xDC, 0xE7, 0x48, 0xBA, 0xEC, 0xCC, 0x7B, 0x88, 0xCC, 0x78, 0x69,
  0x2D, 0x30, 0xAB, 0xD0, 0x33, 0x22, 0x22, 0xE0, 0x22, 0x59, 0xF0, 0xC0,
  0x27, 0xDF, 0xF0, 0x65, 0x75, 0xFE, 0x27, 0xCC, 0x60, 0x19, 0xDD, 0xAF,
  0x78, 0x27, 0xFC, 0x60, 0x19, 0x9C, 0x42, 0x31, 0x98, 0x27, 0xDF, 0xFA,
  0xE0, 0x65, 0x75, 0xDF, 0x61, 0x2D, 0x80, 0x30, 0x22, 0x66, 0x4C, 0x62,
  0x54, 0xCF, 0x78, 0x69, 0x2D, 0x80, 0x14, 0xFD, 0x56, 0xAF, 0xC0, 0x17,
  0x5D, 0xF0, 0x27, 0xDF, 0x60, 0x17, 0x5D, 0xE8, 0x80, 0x27, 0xDF, 0xF2,
  0x20, 0x16, 0x4C, 0xC0, 0x3E, 0x62, 0xE0, 0x7D, 0x6E, 0x5A, 0xBD, 0xE0,
  0xDB, 0x98, 0xC0, 0xF7, 0xF9, 0xE2, 0xC0, 0x7B, 0x19, 0x60, 0x6C, 0xE3,
  0x0C, 0x23, 0x00, 0x76, 0xCE, 0x2D, 0x65, 0xB0, 0xFF, 0xFF, 0x49, 0x35,
  0xA0, 0x5F,
};

const GFXglyph NotoSans_SemiCondensed_BlackItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 6, 4, 0, -6 },
  { 12, 7, 6, 7, 0, -6 },
  { 18, 5, 6, 5, 0, -6 },
  { 22, 1, 2, 2, 1, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 4, 7, 3, -1, -6 },
  { 30, 3, 4, 4, 1, -6 },
  { 32, 4, 4, 4, 0, -5 },
  { 34, 2, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -3 },
  { 36, 2, 1, 2, 0, -1 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 3, 6, 4, 1, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 5, 6, 4, 0, -6 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 4, 6, 4, 0, -6 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 2, 5, 2, 0, -4 },
  { 74, 4, 4, 4, 0, -5 },
  { 76, 4, 3, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 4, 6, 4, 0, -6 },
  { 83, 6, 7, 7, 0, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 5, 6, 5, 0, -6 },
  { 100, 5, 6, 5, 0, -6 },
  { 104, 4, 6, 4, 0, -6 },
  { 107, 4, 6, 4, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 4, 6, 3, 0, -6 },
  { 121, 4, 8, 3, -1, -6 },
  { 125, 6, 6, 5, 0, -6 },
  { 130, 3, 6, 4, 0, -6 },
  { 133, 7, 6, 7, 0, -6 },
  { 139, 6, 6, 6, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 7, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 4, 6, 4, 0, -6 },
  { 164, 4, 6, 4, 1, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 4, 6, 5, 1, -6 },
  { 174, 7, 6, 7, 1, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 4, 6, 5, 1, -6 },
  { 187, 5, 6, 4, 0, -6 },
  { 191, 3, 7, 3, 0, -6 },
  { 194, 2, 6, 4, 1, -6 },
  { 196, 4, 7, 3, -1, -6 },
  { 200, 4, 4, 4, 0, -6 },
  { 202, 4, 1, 3, -1, 0 },
  { 203, 2, 1, 3, 1, -6 },
  { 204, 4, 5, 5, 0, -5 },
  { 207, 4, 6, 5, 0, -6 },
  { 210, 4, 5, 4, 0, -5 },
  { 213, 5, 6, 4, 0, -6 },
  { 217, 4, 5, 4, 0, -5 },
  { 220, 5, 8, 3, -1, -6 },
  { 225, 4, 7, 5, 0, -5 },
  { 229, 4, 6, 5, 0, -6 },
  { 232, 3, 6, 2, 0, -6 },
  { 235, 4, 8, 2, -1, -6 },
  { 239, 5, 6, 5, 0, -6 },
  { 243, 3, 6, 2, 0, -6 },
  { 246, 7, 5, 7, 0, -5 },
  { 251, 4, 5, 5, 0, -5 },
  { 254, 4, 5, 4, 0, -5 },
  { 257, 4, 7, 5, 0, -5 },
  { 261, 4, 7, 5, 0, -5 },
  { 265, 4, 5, 3, 0, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 3, 5, 3, 0, -5 },
  { 273, 5, 4, 5, 0, -4 },
  { 276, 5, 4, 4, 0, -4 },
  { 279, 7, 4, 6, 0, -4 },
  { 283, 5, 4, 4, 0, -4 },
  { 286, 6, 6, 4, -1, -4 },
  { 291, 4, 4, 4, 0, -4 },
  { 293, 3, 7, 3, 0, -6 },
  { 296, 2, 8, 4, 1, -6 },
  { 298, 3, 7, 3, 0, -6 },
  { 301, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_BlackItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_BlackItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_BlackItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_BLACKITALIC8PT7B_H_
