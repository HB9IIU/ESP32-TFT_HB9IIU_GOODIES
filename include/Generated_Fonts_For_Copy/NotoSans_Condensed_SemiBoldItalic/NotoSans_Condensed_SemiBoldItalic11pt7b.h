#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0xA6, 0xFA, 0xA0, 0x14, 0xA7, 0xCA, 0x53, 0xE5, 0x28,
  0x13, 0xD4, 0xC3, 0x1B, 0xC8, 0x40, 0x65, 0x52, 0xC6, 0xAE, 0xA6, 0x95,
  0x66, 0x38, 0xA3, 0x8C, 0x76, 0x69, 0xBA, 0xE8, 0x32, 0x44, 0x4C, 0x88,
  0xC4, 0x21, 0x11, 0x12, 0x22, 0x48, 0xAF, 0x6B, 0x21, 0x09, 0xF2, 0x10,
  0x78, 0xFC, 0xB0, 0x04, 0x21, 0x84, 0x30, 0x84, 0x30, 0x3B, 0x52, 0x9D,
  0xEB, 0x4C, 0x36, 0xA2, 0x64, 0x44, 0x3A, 0x42, 0x23, 0x33, 0x1E, 0x3A,
  0x42, 0x67, 0x08, 0x5C, 0x18, 0xCE, 0xA5, 0x7C, 0xC4, 0x3B, 0x10, 0xE1,
  0x0A, 0x5C, 0x19, 0x10, 0xED, 0xEF, 0x4E, 0x7C, 0x21, 0x84, 0x30, 0x86,
  0x30, 0x3A, 0x52, 0x67, 0x4A, 0x5E, 0x32, 0x52, 0xB7, 0x88, 0xDC, 0x68,
  0x09, 0x80, 0x32, 0x00, 0x06, 0xC0, 0x08, 0xD9, 0xC1, 0x84, 0xF8, 0x3E,
  0x87, 0x06, 0x36, 0x40, 0x75, 0x12, 0x44, 0x4C, 0x1C, 0x22, 0x4D, 0x55,
  0xAA, 0xAA, 0xB4, 0x40, 0x38, 0x08, 0x61, 0xCF, 0x2D, 0xF4, 0xF3, 0x39,
  0xB6, 0x9E, 0x59, 0x2D, 0xBC, 0x1C, 0x96, 0x10, 0x43, 0x04, 0x1C, 0x39,
  0xB6, 0xD3, 0x4D, 0x2D, 0xBC, 0x3B, 0x18, 0xE4, 0x23, 0x1E, 0x3B, 0x18,
  0x87, 0x23, 0x10, 0x1C, 0x96, 0x10, 0x5F, 0x24, 0x9E, 0x25, 0x96, 0x5F,
  0x4D, 0x2C, 0xA2, 0x72, 0x26, 0x44, 0x4E, 0x08, 0x46, 0x21, 0x08, 0xC6,
  0x27, 0x00, 0x25, 0xA7, 0x9C, 0x71, 0x4D, 0x26, 0x26, 0x64, 0x44, 0xCF,
  0x23, 0x73, 0x57, 0x57, 0x5E, 0x5A, 0xDA, 0x96, 0x22, 0xCD, 0x52, 0xA5,
  0x4A, 0xB7, 0x44, 0x1C, 0x94, 0x51, 0x47, 0x34, 0x9C, 0x39, 0xB6, 0xD2,
  0x79, 0x0C, 0x20, 0x1C, 0x94, 0x51, 0x47, 0x34, 0x9C, 0x10, 0x60, 0x3B,
  0x5A, 0x97, 0x2B, 0x53, 0x3B, 0x50, 0xC3, 0x0A, 0x5C, 0xF6, 0x44, 0x44,
  0xC8, 0x25, 0x94, 0x53, 0x49, 0x2C, 0x9C, 0x8C, 0xE5, 0x6A, 0x53, 0x18,
  0x99, 0x9B, 0x9A, 0xAA, 0xAC, 0xCC, 0xDC, 0xD8, 0x36, 0x68, 0x60, 0xC1,
  0x85, 0x1A, 0x64, 0x9C, 0xB8, 0xC4, 0x23, 0x10, 0x78, 0xC4, 0x66, 0x23,
  0x1E, 0x36, 0x44, 0x44, 0xC8, 0x8C, 0xAD, 0x55, 0x38, 0x84, 0x23, 0x10,
  0x84, 0x27, 0x00, 0x11, 0x9C, 0x98, 0x80, 0xF0, 0xC0, 0x3A, 0x53, 0xBD,
  0x38, 0x23, 0x16, 0xD4, 0xA7, 0x5E, 0x3A, 0x11, 0x8C, 0x38, 0x0C, 0x23,
  0x92, 0x4B, 0x6D, 0x1C, 0x32, 0x5D, 0x8C, 0x38, 0x18, 0x8E, 0xC2, 0x11,
  0x8C, 0x46, 0x20, 0x3A, 0x53, 0xBD, 0x38, 0x56, 0xC0, 0x23, 0x16, 0xD4,
  0xAF, 0x52, 0x21, 0xA4, 0xB4, 0x10, 0x32, 0x22, 0x64, 0x4C, 0x80, 0x23,
  0x12, 0xA6, 0x3B, 0x52, 0x2D, 0x24, 0xB4, 0x7E, 0x4B, 0x5A, 0x5A, 0xD2,
  0x96, 0x5B, 0x52, 0xBD, 0x48, 0x32, 0x53, 0xBD, 0x38, 0x3C, 0x92, 0x49,
  0x69, 0x64, 0x10, 0xC0, 0x3A, 0x53, 0xBD, 0x38, 0x42, 0x30, 0x56, 0x44,
  0xC8, 0x74, 0x62, 0x3E, 0x27, 0x44, 0x4C, 0x60, 0x4A, 0x52, 0xBD, 0x38,
  0x9A, 0xAC, 0xCC, 0xB7, 0x6B, 0x76, 0xCD, 0x92, 0x00, 0x2C, 0xA3, 0x0C,
  0x33, 0x60, 0x24, 0xA2, 0x8C, 0x30, 0xC2, 0x38, 0xC0, 0x73, 0x24, 0xCE,
  0x12, 0x22, 0xC4, 0x44, 0x46, 0xFF, 0xE0, 0x30, 0x84, 0x61, 0x98, 0x84,
  0x66, 0x00, 0x6D, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 4, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 8, 1, -8 },
  { 25, 6, 8, 6, 0, -8 },
  { 31, 2, 3, 3, 1, -8 },
  { 32, 4, 10, 3, 0, -8 },
  { 37, 4, 10, 3, -1, -8 },
  { 42, 4, 4, 5, 1, -8 },
  { 44, 5, 6, 5, 0, -7 },
  { 48, 3, 2, 3, -1, -1 },
  { 49, 3, 2, 3, 0, -4 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 6, 8, 4, -1, -8 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 4, 8, 5, 1, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 5, 8, 5, 0, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 5, 8, 5, 0, -8 },
  { 91, 6, 8, 5, 0, -8 },
  { 97, 5, 8, 5, 0, -8 },
  { 102, 5, 8, 5, 0, -8 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 4, 7, 3, -1, -6 },
  { 114, 5, 6, 5, 0, -7 },
  { 118, 5, 3, 5, 0, -5 },
  { 120, 5, 6, 5, 0, -7 },
  { 124, 4, 8, 4, 0, -8 },
  { 128, 8, 9, 8, 0, -8 },
  { 137, 6, 8, 5, -1, -8 },
  { 143, 6, 8, 6, 0, -8 },
  { 149, 6, 8, 5, 0, -8 },
  { 155, 6, 8, 6, 0, -8 },
  { 161, 5, 8, 5, 0, -8 },
  { 166, 5, 8, 5, 0, -8 },
  { 171, 6, 8, 6, 0, -8 },
  { 177, 6, 8, 6, 0, -8 },
  { 183, 4, 8, 3, 0, -8 },
  { 187, 5, 10, 3, -2, -8 },
  { 194, 6, 8, 5, 0, -8 },
  { 200, 4, 8, 4, 0, -8 },
  { 204, 8, 8, 8, 0, -8 },
  { 212, 7, 8, 7, 0, -8 },
  { 219, 6, 8, 6, 0, -8 },
  { 225, 6, 8, 5, 0, -8 },
  { 231, 6, 10, 6, 0, -8 },
  { 239, 5, 8, 5, 0, -8 },
  { 244, 5, 8, 5, 0, -8 },
  { 249, 4, 8, 5, 1, -8 },
  { 253, 6, 8, 6, 0, -8 },
  { 259, 5, 8, 5, 1, -8 },
  { 264, 8, 8, 8, 1, -8 },
  { 272, 7, 8, 5, -1, -8 },
  { 279, 5, 8, 5, 1, -8 },
  { 284, 5, 8, 5, 0, -8 },
  { 289, 4, 10, 3, 0, -8 },
  { 294, 2, 8, 4, 1, -8 },
  { 296, 5, 10, 3, -1, -8 },
  { 303, 5, 5, 5, 0, -8 },
  { 307, 4, 1, 4, -1, 1 },
  { 308, 2, 1, 3, 2, -8 },
  { 309, 5, 6, 5, 0, -6 },
  { 313, 5, 8, 5, 0, -8 },
  { 318, 5, 6, 4, 0, -6 },
  { 322, 6, 8, 5, 0, -8 },
  { 328, 5, 6, 5, 0, -6 },
  { 332, 5, 11, 3, -1, -8 },
  { 339, 5, 9, 5, 0, -6 },
  { 345, 5, 8, 5, 0, -8 },
  { 350, 3, 8, 3, 0, -8 },
  { 353, 4, 11, 3, -1, -8 },
  { 359, 5, 8, 5, 0, -8 },
  { 364, 3, 8, 3, 0, -8 },
  { 367, 8, 6, 8, 0, -6 },
  { 373, 5, 6, 5, 0, -6 },
  { 377, 5, 6, 5, 0, -6 },
  { 381, 6, 9, 5, -1, -6 },
  { 388, 5, 9, 5, 0, -6 },
  { 394, 4, 6, 4, 0, -6 },
  { 397, 4, 6, 4, 0, -6 },
  { 400, 4, 7, 3, 0, -7 },
  { 404, 5, 6, 5, 0, -6 },
  { 408, 4, 6, 5, 1, -6 },
  { 411, 7, 6, 7, 1, -6 },
  { 417, 6, 6, 5, -1, -6 },
  { 422, 6, 9, 5, -1, -6 },
  { 429, 4, 6, 4, 0, -6 },
  { 432, 4, 10, 4, 0, -8 },
  { 437, 1, 11, 5, 2, -8 },
  { 439, 5, 10, 4, -1, -8 },
  { 446, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC11PT7B_H_
