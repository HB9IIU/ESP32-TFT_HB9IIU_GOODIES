#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x00, 0x00, 0x04, 0x07,
  0x87, 0xC3, 0xE1, 0xE0, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE3,
  0x9C, 0xE7, 0x1C, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0C, 0x70,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x7F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x71, 0xC0, 0x1C, 0x60, 0x06, 0x38, 0x03, 0x8E,
  0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0x1C, 0x01, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x91,
  0x0F, 0x60, 0x1E, 0xC0, 0x3D, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xBC, 0x01, 0x78, 0x06, 0x72, 0x0C, 0xE2, 0x1B,
  0xCF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0xE0, 0xFC, 0x0E, 0x0F, 0xE0, 0xE0, 0xE7, 0x07,
  0x07, 0x38, 0x70, 0x39, 0xC3, 0x83, 0x8E, 0x38, 0x1C, 0x71, 0x80, 0xE3,
  0x9C, 0x07, 0x1D, 0xC0, 0x39, 0xCE, 0xFD, 0xCE, 0xE7, 0xEF, 0xE7, 0x77,
  0xFE, 0x77, 0x1C, 0xE7, 0x38, 0xE0, 0x39, 0xC7, 0x03, 0x9C, 0x70, 0x1C,
  0xE3, 0x81, 0xC7, 0x1C, 0x1C, 0x38, 0xE0, 0xE1, 0xCE, 0x0E, 0x0F, 0xF0,
  0x70, 0x3F, 0x07, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x07,
  0x78, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xC7, 0xF8,
  0xE3, 0xDE, 0x79, 0xE3, 0xDC, 0x70, 0xFF, 0x3C, 0x1F, 0x8F, 0x07, 0xE3,
  0xC1, 0xF0, 0xF8, 0xFC, 0x1F, 0xFF, 0x87, 0xFD, 0xE0, 0xFE, 0x7C, 0x3B,
  0xDE, 0xF7, 0x39, 0xDE, 0xE0, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x11, 0xC0, 0xCE, 0x0F, 0xF1, 0x7F, 0xF8, 0x7F, 0xC1, 0xEF, 0x1F,
  0x83, 0xDC, 0x1E, 0xF0, 0x63, 0xC1, 0x18, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x3C,
  0x71, 0xE3, 0x87, 0x1C, 0x78, 0x7F, 0xBF, 0xDF, 0xDF, 0xE0, 0x23, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF,
  0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83,
  0xDC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x78, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x01,
  0xE0, 0x7C, 0x1F, 0x07, 0xE3, 0xFC, 0xFF, 0xBE, 0xE3, 0x9C, 0x27, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFF, 0x06, 0x0F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF8, 0x79, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xCC, 0x1F, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x7F, 0x01, 0xDE, 0x03, 0xB8, 0x0E, 0x70,
  0x39, 0xE0, 0xE3, 0xC1, 0xC7, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3B, 0x80, 0x7F, 0xC1, 0xFF,
  0xC1, 0xDF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xCC, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x3E, 0x20, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF7, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0xC7, 0x9F,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87,
  0x8F, 0x9E, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xF8,
  0x1F, 0xF8, 0x78, 0xF0, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x8F, 0x0F, 0x0F,
  0x3C, 0x1E, 0xF8, 0x1F, 0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0x1E,
  0x3C, 0x3C, 0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCF, 0x87, 0x8F,
  0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7D,
  0xE1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0xF9, 0xE3, 0xE3, 0xFF, 0xC3, 0xFF, 0x87, 0xEF, 0x01, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF8, 0xF0, 0x03, 0x81, 0xF0, 0x7C,
  0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x00,
  0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x78, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x07, 0xC3, 0xFE,
  0x3F, 0xF3, 0xDF, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xC0, 0x01, 0x87, 0x0F, 0xE7, 0x38, 0xFF, 0x1C, 0xC3, 0x9C,
  0x77, 0x1C, 0x71, 0x9C, 0xE1, 0xC6, 0x63, 0x8E, 0x3B, 0x8E, 0x38, 0xEE,
  0x30, 0xE3, 0xB9, 0xC3, 0x8C, 0xE7, 0x1C, 0x73, 0x9C, 0xF3, 0x8E, 0x3F,
  0xFC, 0x38, 0xF9, 0xE0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x01, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0xEF, 0x01, 0xEF, 0x01, 0xEF, 0x01, 0xCF, 0x03, 0xCF, 0x03, 0x8F,
  0x07, 0x8F, 0x07, 0x8F, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F,
  0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0xF8, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x8F, 0xC3, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF8, 0x20, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC3, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC7, 0x83,
  0xE1, 0xE1, 0xF0, 0x79, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0x80, 0x87,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE1, 0xFE, 0x78, 0x7F, 0x1E, 0x1F, 0xCF, 0x80, 0xF3, 0xE0, 0x3C,
  0xF8, 0x0E, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x7C, 0x1E, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07,
  0x87, 0x80, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03,
  0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0E,
  0x78, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x1C, 0x0F, 0x07, 0x81,
  0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xDF, 0xFF, 0xFF, 0x07, 0xC0,
  0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xFE,
  0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1D, 0xC1, 0xFC, 0x0E,
  0xE0, 0xEE, 0x0F, 0x70, 0xFF, 0x07, 0xB8, 0x77, 0x83, 0x9C, 0x7B, 0xC1,
  0xCE, 0x39, 0xC0, 0xE7, 0x3D, 0xE0, 0xF3, 0x9C, 0xF0, 0x79, 0xDE, 0x78,
  0x38, 0xEE, 0x3C, 0x1C, 0x77, 0x1C, 0x1E, 0x3F, 0x1E, 0x0F, 0x1F, 0x8F,
  0x07, 0x8F, 0x87, 0x83, 0x87, 0xC3, 0x81, 0xC3, 0xC1, 0xC1, 0xE1, 0xE1,
  0xE0, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0x81, 0xF0, 0x1C, 0x0F, 0x81, 0xE0,
  0xFC, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83, 0x81, 0xDC, 0x3C, 0x0E, 0xE1,
  0xE0, 0xF7, 0x8F, 0x07, 0xBC, 0x70, 0x38, 0xE3, 0x81, 0xC7, 0x3C, 0x1E,
  0x39, 0xE0, 0xF1, 0xEF, 0x07, 0x8F, 0x70, 0x38, 0x3B, 0x81, 0xC1, 0xDC,
  0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x81, 0xF0, 0x38, 0x0F, 0x81, 0xC0,
  0x7C, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFE, 0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x7B, 0xE0, 0x3E, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0x81, 0xE1, 0xE0,
  0xF8, 0x7C, 0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC7, 0xC1,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0x07,
  0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xE0,
  0x3E, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0x3C, 0xF0, 0x3C, 0x00, 0xF8, 0x07,
  0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xF0, 0x43, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC4, 0x07, 0x8E, 0x1F,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x70, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x38, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C,
  0x07, 0x8F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xF1, 0xC0, 0xF3, 0xC0, 0xF3, 0x80, 0xF7, 0x80, 0x77,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0E,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C,
  0xF0, 0xFC, 0x38, 0xE1, 0xDC, 0x78, 0xE1, 0xDC, 0x78, 0xE3, 0xDC, 0xF0,
  0xE3, 0x9C, 0xF0, 0xE7, 0x9C, 0xE0, 0xE7, 0x1D, 0xE0, 0xE7, 0x1D, 0xE0,
  0xEE, 0x1D, 0xC0, 0xEE, 0x1F, 0xC0, 0xEE, 0x3B, 0x80, 0xFC, 0x3F, 0x80,
  0xFC, 0x3F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0x80, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0xB8, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xC7, 0x0F,
  0x0E, 0x1E, 0x1E, 0x78, 0x3C, 0xE0, 0x7B, 0xC0, 0xF7, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70,
  0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x8F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x78, 0x70, 0x71, 0xC0, 0xE7, 0x81,
  0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFE, 0xF1, 0xC7, 0x8E, 0x1C, 0x07, 0xCE,
  0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E,
  0x3C, 0x7C, 0x7F, 0xF8, 0x7E, 0xF0, 0x79, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x3C, 0x0E,
  0xFC, 0x3F, 0xFC, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x38, 0x1E, 0x70, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F,
  0x8F, 0x1F, 0xFC, 0x7F, 0xF0, 0xE7, 0xC0, 0x07, 0xF8, 0x7F, 0x87, 0xFC,
  0x7C, 0x43, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE3, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x0F, 0xBC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x9F,
  0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xE1, 0xE0, 0x70, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3E, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE,
  0x78, 0x73, 0xC3, 0xBC, 0x3D, 0xE1, 0xEE, 0x7E, 0xFF, 0xE7, 0xFC, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x8F, 0xFC, 0x7F, 0xE1, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x04, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE7, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x3E, 0x1E, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x3E, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x81, 0xE0, 0xC3, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0x7E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x3E, 0x0E, 0xFC, 0x3F, 0xFC, 0x7C,
  0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x1E, 0x0E, 0x3C, 0x3C,
  0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x78,
  0x3C, 0xF0, 0x70, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x20, 0x00, 0x00, 0x1E,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x5F, 0x03, 0xF0, 0x1F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0x78, 0xE0, 0x70, 0xF0, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x00, 0x0E, 0x78, 0x78,
  0x1D, 0xFB, 0xF8, 0x7F, 0xFF, 0xF8, 0xF8, 0xF8, 0xF1, 0xE1, 0xE1, 0xE3,
  0xC3, 0xC3, 0xC7, 0x07, 0x07, 0x1E, 0x1E, 0x0E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0xE0, 0xF0, 0xF3, 0xC1, 0xC1, 0xC7, 0x87, 0x83, 0x8F, 0x0F,
  0x0F, 0x1E, 0x1E, 0x1E, 0x38, 0x38, 0x3C, 0xF0, 0x70, 0x71, 0xE1, 0xE1,
  0xE0, 0x0E, 0x7C, 0x1D, 0xF8, 0x7F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xE0, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF,
  0x1F, 0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0x9E, 0x01, 0xDF, 0x81,
  0xFF, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F,
  0x0F, 0x07, 0x87, 0x83, 0xC3, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x7C, 0x78, 0x3F, 0xF8, 0x3D, 0xF8, 0x1E, 0xF8, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xCE, 0x1F, 0xFC, 0x7F, 0xF9, 0xF3, 0xE3, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF8, 0x7E, 0xF0, 0xF9,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x78, 0x77, 0x87, 0xFC, 0x3F, 0xE1, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0xFF, 0xC7, 0xFC, 0x78, 0x43, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF2, 0x0F, 0x1F, 0xF8,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1F, 0xDF, 0xF7,
  0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xF8, 0x7E, 0x1F, 0x80, 0x1C, 0x1E, 0x38, 0x3C,
  0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x78,
  0x78, 0xE0, 0xF1, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C,
  0x7F, 0xF8, 0x7E, 0xE0, 0xF9, 0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1,
  0xEF, 0x0E, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0xF3, 0x87, 0xBC, 0x3D, 0xC1,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00,
  0xF0, 0xF0, 0x7F, 0x87, 0x87, 0xBC, 0x7C, 0x3D, 0xE3, 0xE1, 0xCF, 0x1F,
  0x1E, 0x71, 0xF8, 0xE3, 0x8F, 0xC7, 0x1C, 0xEE, 0x78, 0xE7, 0x73, 0x87,
  0x73, 0xBC, 0x3B, 0x9D, 0xC1, 0xDC, 0xEE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x3B, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x79, 0xE0, 0x78, 0xF0, 0x78, 0x78,
  0x7C, 0x1E, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00,
  0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x09, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x84, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x08,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x3F, 0x01, 0xE0, 0x0F, 0x80,
  0xBC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x05, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0x70,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 11, 9, 13, 3, -24 },
  { 41, 18, 24, 17, 0, -24 },
  { 95, 15, 27, 15, 0, -25 },
  { 146, 21, 24, 24, 2, -24 },
  { 209, 18, 24, 18, 0, -24 },
  { 263, 5, 9, 8, 3, -24 },
  { 269, 11, 29, 9, 1, -24 },
  { 309, 10, 29, 9, -2, -24 },
  { 346, 13, 13, 14, 3, -25 },
  { 368, 13, 16, 16, 2, -20 },
  { 394, 7, 8, 8, -2, -4 },
  { 401, 9, 4, 10, 0, -11 },
  { 406, 5, 5, 8, 0, -5 },
  { 410, 17, 24, 12, -2, -24 },
  { 461, 14, 24, 15, 1, -24 },
  { 503, 11, 24, 15, 3, -24 },
  { 536, 16, 24, 15, -1, -24 },
  { 584, 15, 24, 15, 0, -24 },
  { 629, 15, 24, 15, 0, -24 },
  { 674, 15, 24, 15, 0, -24 },
  { 719, 15, 24, 15, 1, -24 },
  { 764, 16, 24, 15, 1, -24 },
  { 812, 15, 24, 15, 0, -24 },
  { 857, 15, 24, 15, 0, -24 },
  { 902, 8, 18, 8, 0, -18 },
  { 920, 10, 22, 8, -2, -18 },
  { 948, 14, 16, 16, 1, -20 },
  { 976, 13, 9, 16, 2, -16 },
  { 991, 13, 16, 16, 2, -20 },
  { 1017, 12, 24, 12, 1, -24 },
  { 1053, 22, 27, 23, 1, -24 },
  { 1128, 16, 24, 16, -2, -24 },
  { 1176, 17, 24, 17, 0, -24 },
  { 1227, 17, 24, 16, 1, -24 },
  { 1278, 18, 24, 18, 0, -24 },
  { 1332, 16, 24, 14, 0, -24 },
  { 1380, 16, 24, 14, 0, -24 },
  { 1428, 18, 24, 19, 1, -24 },
  { 1482, 19, 24, 19, 0, -24 },
  { 1539, 14, 24, 10, -1, -24 },
  { 1581, 14, 31, 8, -5, -24 },
  { 1636, 19, 24, 16, 0, -24 },
  { 1693, 11, 24, 13, 0, -24 },
  { 1726, 25, 24, 24, 0, -24 },
  { 1801, 21, 24, 20, 0, -24 },
  { 1864, 18, 24, 19, 1, -24 },
  { 1918, 17, 24, 16, 0, -24 },
  { 1969, 18, 30, 19, 1, -24 },
  { 2037, 16, 24, 16, 0, -24 },
  { 2085, 15, 24, 14, 0, -24 },
  { 2130, 13, 24, 14, 3, -24 },
  { 2169, 18, 24, 18, 1, -24 },
  { 2223, 16, 24, 16, 3, -24 },
  { 2271, 24, 24, 24, 3, -24 },
  { 2343, 20, 24, 15, -2, -24 },
  { 2403, 15, 24, 15, 3, -24 },
  { 2448, 17, 24, 14, -1, -24 },
  { 2499, 13, 29, 10, -1, -24 },
  { 2547, 7, 24, 12, 3, -24 },
  { 2568, 13, 29, 10, -2, -24 },
  { 2616, 15, 14, 15, 0, -24 },
  { 2643, 12, 2, 11, -3, 3 },
  { 2646, 6, 5, 10, 5, -25 },
  { 2650, 15, 18, 16, 1, -18 },
  { 2684, 15, 25, 16, 0, -25 },
  { 2731, 13, 18, 13, 1, -18 },
  { 2761, 17, 25, 16, 1, -25 },
  { 2815, 13, 18, 15, 1, -18 },
  { 2845, 17, 33, 10, -4, -25 },
  { 2916, 16, 26, 16, 0, -18 },
  { 2968, 15, 25, 16, 0, -25 },
  { 3015, 9, 25, 8, 0, -25 },
  { 3044, 13, 33, 8, -4, -25 },
  { 3098, 16, 25, 15, 0, -25 },
  { 3148, 9, 25, 8, 0, -25 },
  { 3177, 23, 18, 24, 0, -18 },
  { 3229, 15, 18, 16, 0, -18 },
  { 3263, 14, 18, 16, 1, -18 },
  { 3295, 17, 26, 16, -2, -18 },
  { 3351, 15, 26, 16, 1, -18 },
  { 3400, 13, 18, 11, 0, -18 },
  { 3430, 13, 18, 12, 0, -18 },
  { 3460, 10, 22, 10, 1, -22 },
  { 3488, 15, 18, 16, 1, -18 },
  { 3522, 13, 18, 14, 2, -18 },
  { 3552, 21, 18, 21, 2, -18 },
  { 3600, 17, 18, 14, -2, -18 },
  { 3639, 18, 26, 14, -3, -18 },
  { 3698, 14, 18, 12, -1, -18 },
  { 3730, 13, 29, 11, 0, -24 },
  { 3778, 4, 33, 14, 5, -25 },
  { 3795, 13, 29, 11, -2, -24 },
  { 3843, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC33PT7B_H_
