#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0x80, 0xF0, 0x5F, 0x6E, 0xC0, 0x69, 0xBC, 0x55, 0x3E, 0xB5,
  0x00, 0x66, 0x5A, 0xE0, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xF4, 0x5D,
  0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xDC, 0x7A, 0x80, 0x64, 0xAE,
  0x65, 0x1C, 0x2E, 0xF4, 0x6B, 0x9C, 0x6B, 0xDC, 0x72, 0x44, 0x80, 0x6D,
  0x5E, 0x77, 0x9C, 0x42, 0x42, 0x80, 0x38, 0x80, 0xFC, 0xC7, 0x00, 0x65,
  0x08, 0x33, 0xF7, 0xF8, 0x30, 0x2D, 0xFA, 0x65, 0x6A, 0xE0, 0x74, 0x88,
  0x60, 0x65, 0x9A, 0xE0, 0x69, 0xCC, 0x69, 0xC8, 0x74, 0xB9, 0x60, 0x55,
  0x7A, 0xA0, 0x69, 0x4C, 0x24, 0xA5, 0x80, 0x56, 0x4A, 0xA0, 0x5A, 0xC0,
  0x4A, 0xF7, 0x5B, 0x00, 0x55, 0xBB, 0xA0, 0x75, 0x99, 0x60, 0x65, 0x68,
  0x80, 0x75, 0x99, 0x62, 0x6D, 0xDA, 0x69, 0x1C, 0xEA, 0x80, 0x55, 0x9A,
  0xE0, 0xBB, 0x48, 0xAF, 0xBD, 0x4A, 0x00, 0x56, 0x4A, 0xA0, 0xFA, 0x48,
  0x65, 0x4C, 0x6A, 0x49, 0x00, 0xF8, 0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80,
  0x76, 0xF0, 0x4E, 0xDE, 0x72, 0x60, 0x16, 0xAA, 0xE0, 0x77, 0x60, 0x36,
  0x24, 0x44, 0x80, 0x76, 0xF3, 0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24,
  0xA0, 0x4F, 0x6A, 0x5A, 0x80, 0x7D, 0x6B, 0x60, 0x76, 0xD0, 0x76, 0xF0,
  0x76, 0xF9, 0x00, 0x76, 0xF2, 0x80, 0x72, 0x40, 0x71, 0x60, 0x7A, 0xC0,
  0x76, 0xF0, 0xB5, 0x20, 0xAD, 0xBD, 0x40, 0xA9, 0x60, 0x55, 0x22, 0x4C,
  0x6A, 0x60, 0x69, 0x49, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 6, 2, -1, -5 },
  { 22, 2, 3, 3, 1, -5 },
  { 23, 3, 3, 3, 0, -4 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 2, 5, 3, 1, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 4, 5, 3, 0, -5 },
  { 47, 3, 5, 3, 0, -5 },
  { 49, 3, 5, 3, 0, -5 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 2, 5, 2, 0, -4 },
  { 54, 3, 3, 3, 0, -4 },
  { 56, 3, 2, 3, 0, -3 },
  { 57, 3, 3, 3, 0, -4 },
  { 59, 3, 5, 2, 0, -5 },
  { 61, 5, 6, 5, 0, -5 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 3, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 3, 5, 2, 0, -5 },
  { 88, 3, 6, 2, -1, -5 },
  { 91, 4, 5, 3, 0, -5 },
  { 94, 2, 5, 3, 0, -5 },
  { 96, 5, 5, 5, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 3, 0, -5 },
  { 109, 4, 6, 4, 0, -5 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 2, 5, 3, 1, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 3, 5, 3, 1, -5 },
  { 123, 5, 5, 5, 1, -5 },
  { 127, 4, 5, 3, 0, -5 },
  { 130, 3, 5, 3, 1, -5 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 3, 6, 2, 0, -5 },
  { 137, 1, 5, 3, 1, -5 },
  { 138, 2, 6, 2, 0, -5 },
  { 140, 3, 3, 3, 0, -5 },
  { 142, 3, 1, 2, -1, 0 },
  { 143, 1, 1, 2, 1, -5 },
  { 144, 3, 4, 3, 0, -4 },
  { 146, 3, 5, 3, 0, -5 },
  { 148, 3, 4, 3, 0, -4 },
  { 150, 4, 5, 3, 0, -5 },
  { 153, 3, 4, 3, 0, -4 },
  { 155, 4, 7, 2, -1, -5 },
  { 159, 3, 6, 3, 0, -4 },
  { 162, 3, 5, 3, 0, -5 },
  { 164, 2, 5, 2, 0, -5 },
  { 166, 3, 7, 2, -1, -5 },
  { 169, 3, 5, 3, 0, -5 },
  { 171, 2, 5, 2, 0, -5 },
  { 173, 5, 4, 5, 0, -4 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 3, 6, 3, 0, -4 },
  { 183, 3, 6, 3, 0, -4 },
  { 186, 3, 4, 2, 0, -4 },
  { 188, 3, 4, 3, 0, -4 },
  { 190, 2, 5, 2, 0, -5 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 5, 4, 4, 0, -4 },
  { 199, 3, 4, 3, 0, -4 },
  { 201, 4, 6, 3, -1, -4 },
  { 204, 3, 4, 3, 0, -4 },
  { 206, 3, 6, 2, 0, -5 },
  { 209, 1, 7, 3, 1, -5 },
  { 210, 2, 6, 2, 0, -5 },
  { 212, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC7PT7B_H_
