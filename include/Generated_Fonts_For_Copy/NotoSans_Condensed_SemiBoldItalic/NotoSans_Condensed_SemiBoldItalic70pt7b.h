#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xE1, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xB9, 0xF8, 0x03, 0xFE, 0x38, 0x38, 0x03, 0xFC, 0x78, 0x10, 0x03, 0xF8,
  0x78, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x03, 0xF8,
  0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x03, 0xFC, 0xE0, 0x00, 0x03, 0xFE,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xBF, 0xE0, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0x07, 0x1F, 0xE0, 0x00, 0x07,
  0x0F, 0xE0, 0x00, 0x07, 0x0F, 0xE0, 0x00, 0x0F, 0x1F, 0xE0, 0x80, 0x0E,
  0x1F, 0xE0, 0xC0, 0x0E, 0x1F, 0xE0, 0xF0, 0x0E, 0x3F, 0xC0, 0xFE, 0x1E,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0x00,
  0xFC, 0x0F, 0xC3, 0xF0, 0x1E, 0x0F, 0xC0, 0xFC, 0x7F, 0x0F, 0xF8, 0xFC,
  0x1F, 0xC7, 0xE1, 0xFF, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0xFE, 0xFC, 0x3F,
  0x8F, 0xC7, 0xFF, 0xEF, 0xE7, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x8F, 0xC7, 0xF7, 0xFF, 0xE3, 0xF1, 0xFC, 0x3F, 0x7F, 0xFC, 0x7E, 0x1F,
  0x83, 0xF3, 0xFF, 0x87, 0xE3, 0xF0, 0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x03,
  0xF0, 0x70, 0x1F, 0xC3, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x87, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x00,
  0x7E, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x10,
  0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0xF7, 0xF8, 0x3F, 0xC0, 0xFF, 0x9F, 0xF0, 0xFF, 0x07,
  0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF, 0x9F, 0xE0, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0x80, 0x3F, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF,
  0x80, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x08, 0x03, 0xF0, 0x01, 0xC0,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xF1, 0xF0, 0x01, 0xFF, 0xBE, 0x07,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xC7,
  0xE0, 0x0F, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01,
  0xF0, 0x3F, 0xC0, 0x1C, 0x07, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0x03, 0xF8, 0xFF, 0x3F,
  0xE7, 0xFE, 0xFF, 0xBF, 0xF3, 0xFE, 0x7F, 0x8F, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xF7, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFB, 0xFC, 0xFF, 0xCF, 0xF1, 0xFE,
  0x3F, 0x83, 0xE1, 0xFE, 0x0F, 0x07, 0xF8, 0x18, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xF0,
  0x01, 0xC0, 0x07, 0xFC, 0x00, 0x20, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0x8F, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x30, 0x01, 0xFF, 0x00, 0x20,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0x7F, 0xC0, 0xE0, 0x01,
  0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x07, 0xE7, 0xF8, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x01, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x80, 0x00, 0x7F, 0xE0, 0xC0, 0x00, 0xFF,
  0xC0, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF4, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x0C, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xE7, 0xFF,
  0x00, 0x1F, 0xEF, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xE7, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFF,
  0x0F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0x80,
  0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0xC7, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7E, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x83,
  0xFF, 0x0F, 0x00, 0xFF, 0x82, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0xFE, 0x0F, 0xC1, 0xF8, 0x03,
  0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0xFC, 0x3F, 0x00, 0xFF,
  0xFF, 0x83, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x07, 0xE0,
  0x3E, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x9F, 0x83, 0xF0, 0x0F, 0xC0, 0x7C,
  0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF1, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC7,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0xFC,
  0x0F, 0x80, 0xFE, 0x07, 0xE3, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0x87, 0xE0, 0xFC, 0x0F,
  0xC3, 0xFE, 0x3F, 0x83, 0xF0, 0x3F, 0xFE, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF,
  0xFB, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0xC0, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0,
  0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xE0,
  0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xF8, 0x03,
  0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x40, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFD, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07,
  0xF9, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0x1F, 0xE0,
  0x07, 0xF1, 0xFC, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFC, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xC1,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xC3, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFC, 0x7F, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xC7, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F,
  0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xF0,
  0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xF0, 0x03,
  0xFB, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xEF,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x9F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0xFF,
  0x00, 0x3F, 0x8F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x00,
  0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x03, 0xFC,
  0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F,
  0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x3E, 0x00, 0x3F, 0xF0, 0x01, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x0F, 0xF8, 0x07, 0x00, 0x07,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xDF,
  0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0x9F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xF9, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0x9F, 0x81, 0xFE, 0x00, 0xFF, 0x07, 0xF1, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x00, 0xFF, 0x0F, 0xE1, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x1F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xC1, 0xF8, 0x7F,
  0x80, 0x0F, 0xF1, 0xFC, 0x1F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xC1, 0xF8,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0x81,
  0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x1F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F,
  0x01, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0xC0, 0x00, 0xFE,
  0xFE, 0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x00,
  0xFE, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0xF8, 0x7F, 0x00, 0x7F, 0xFC,
  0xFF, 0x00, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x1F, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F,
  0xF0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0x3F, 0x80, 0x3F, 0xFE, 0x3F,
  0x80, 0x1F, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x03,
  0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0xFE, 0x7F,
  0xFC, 0x00, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0x00, 0x7E, 0x3F, 0xFF,
  0x00, 0x7E, 0x3F, 0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF8, 0x78, 0x07, 0xFC, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x02, 0x07, 0xFE, 0x01,
  0x80, 0x7F, 0xE0, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0x9F, 0xC0, 0x03,
  0xFF, 0xFB, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x0F,
  0xFF, 0x1F, 0x80, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xBF, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x40, 0x7F, 0xC0, 0x1C, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x8C, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x08, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F,
  0xC1, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0x80, 0x07, 0xFF, 0xCF, 0xF0, 0x01,
  0xFF, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF7, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x01, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x80, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xFC, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0xFE,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x87, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x9F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFC, 0xFF, 0xFC, 0xFF, 0xFF, 0x01, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFC, 0x1F, 0xF0, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0xFC,
  0x7F, 0xFC, 0x00, 0xFC, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9,
  0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFE,
  0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x7E, 0x1F, 0xFC,
  0x00, 0x0F, 0xC7, 0xFF, 0xC0, 0x01, 0xF9, 0xFF, 0xFC, 0x00, 0x7F, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x7F, 0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0xFF, 0xFE, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x7F, 0x80, 0x3F, 0xFE, 0x7F, 0x00, 0x1F, 0xFC, 0x7F, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x7E,
  0x3F, 0xE0, 0x0F, 0xCF, 0xFC, 0x03, 0xFB, 0xFF, 0x00, 0x7F, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x7C, 0x0F, 0xF8, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x20, 0x00, 0xFF, 0x06, 0x00, 0x3F, 0xE0,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x8F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x40, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0x3F, 0x00, 0x3F, 0xFE, 0x3F,
  0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0xFF,
  0x01, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0x0F, 0xF0, 0x7E, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xEF, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFE, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xCF, 0xC1, 0xFC,
  0x0F, 0xF0, 0xFC, 0xFC, 0x3F, 0xC0, 0xFF, 0x1F, 0x8F, 0xC3, 0xF8, 0x0F,
  0xF1, 0xF8, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x0F, 0xCF, 0xF0, 0x0F, 0xE7, 0xE0,
  0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x0F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0xFD,
  0xFC, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x04, 0x7F, 0xF0, 0x00, 0x37, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xF2, 0x00, 0x03, 0xFF, 0x88,
  0x00, 0x00, 0x60, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 20, 51, 18, 0, -50 },
  { 129, 23, 18, 27, 7, -50 },
  { 181, 36, 50, 36, 1, -50 },
  { 406, 32, 57, 32, 1, -53 },
  { 634, 44, 52, 50, 4, -51 },
  { 920, 38, 52, 38, 0, -51 },
  { 1167, 11, 18, 16, 7, -50 },
  { 1192, 23, 61, 20, 2, -50 },
  { 1368, 23, 62, 20, -5, -51 },
  { 1547, 27, 29, 31, 6, -54 },
  { 1645, 29, 34, 34, 3, -42 },
  { 1769, 14, 18, 17, -3, -9 },
  { 1801, 18, 8, 20, 1, -23 },
  { 1819, 11, 11, 17, 0, -10 },
  { 1835, 36, 50, 26, -4, -50 },
  { 2060, 30, 52, 32, 2, -51 },
  { 2255, 22, 50, 32, 7, -50 },
  { 2393, 34, 51, 32, -2, -51 },
  { 2610, 32, 52, 32, 0, -51 },
  { 2818, 33, 50, 32, -1, -50 },
  { 3025, 32, 51, 32, 0, -50 },
  { 3229, 32, 52, 32, 2, -51 },
  { 3437, 33, 50, 32, 2, -50 },
  { 3644, 33, 52, 32, 0, -51 },
  { 3859, 31, 52, 32, 1, -51 },
  { 4061, 16, 40, 17, 0, -39 },
  { 4141, 20, 48, 17, -4, -39 },
  { 4261, 30, 34, 34, 3, -42 },
  { 4389, 30, 21, 34, 3, -35 },
  { 4468, 30, 34, 34, 3, -42 },
  { 4596, 25, 52, 25, 3, -51 },
  { 4759, 46, 56, 49, 2, -50 },
  { 5081, 34, 50, 35, -4, -50 },
  { 5294, 35, 50, 35, 1, -50 },
  { 5513, 34, 52, 33, 3, -51 },
  { 5734, 36, 50, 38, 1, -50 },
  { 5959, 32, 50, 30, 1, -50 },
  { 6159, 32, 50, 29, 1, -50 },
  { 6359, 38, 52, 40, 3, -51 },
  { 6606, 40, 50, 40, 1, -50 },
  { 6856, 30, 50, 22, -3, -50 },
  { 7044, 31, 64, 18, -11, -50 },
  { 7292, 39, 50, 34, 1, -50 },
  { 7536, 23, 50, 29, 1, -50 },
  { 7680, 52, 50, 51, 1, -50 },
  { 8005, 43, 50, 42, 1, -50 },
  { 8274, 37, 52, 41, 3, -51 },
  { 8515, 35, 50, 34, 1, -50 },
  { 8734, 37, 63, 41, 3, -51 },
  { 9026, 34, 50, 35, 1, -50 },
  { 9239, 34, 52, 30, -1, -51 },
  { 9460, 29, 50, 29, 6, -50 },
  { 9642, 38, 51, 39, 3, -50 },
  { 9885, 34, 50, 34, 6, -50 },
  { 10098, 52, 50, 52, 6, -50 },
  { 10423, 42, 50, 32, -4, -50 },
  { 10686, 31, 50, 31, 6, -50 },
  { 10880, 35, 50, 29, -2, -50 },
  { 11099, 27, 61, 21, -2, -50 },
  { 11305, 14, 50, 26, 7, -50 },
  { 11393, 28, 61, 21, -5, -50 },
  { 11607, 31, 30, 32, 1, -50 },
  { 11724, 24, 5, 24, -6, 6 },
  { 11739, 12, 12, 20, 10, -54 },
  { 11757, 32, 40, 34, 2, -39 },
  { 11917, 32, 54, 34, 0, -53 },
  { 12133, 27, 40, 27, 2, -39 },
  { 12268, 35, 54, 34, 2, -53 },
  { 12505, 28, 40, 31, 2, -39 },
  { 12645, 36, 71, 20, -8, -54 },
  { 12965, 35, 56, 34, -1, -39 },
  { 13210, 32, 53, 34, 0, -53 },
  { 13422, 19, 53, 16, 0, -53 },
  { 13548, 28, 70, 17, -9, -53 },
  { 13793, 34, 53, 31, 0, -53 },
  { 14019, 20, 53, 16, 0, -53 },
  { 14152, 48, 39, 51, 0, -39 },
  { 14386, 32, 39, 34, 0, -39 },
  { 14542, 29, 40, 33, 2, -39 },
  { 14687, 35, 56, 34, -3, -39 },
  { 14932, 32, 56, 34, 2, -39 },
  { 15156, 27, 39, 24, 0, -39 },
  { 15288, 27, 40, 26, 0, -39 },
  { 15423, 20, 47, 21, 3, -46 },
  { 15541, 32, 39, 34, 2, -38 },
  { 15697, 28, 38, 29, 4, -38 },
  { 15830, 44, 38, 45, 4, -38 },
  { 16039, 35, 38, 30, -3, -38 },
  { 16206, 39, 55, 29, -6, -38 },
  { 16475, 29, 38, 25, -2, -38 },
  { 16613, 27, 61, 24, 1, -50 },
  { 16819, 7, 69, 30, 11, -53 },
  { 16880, 27, 61, 24, -4, -50 },
  { 17086, 30, 11, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC70PT7B_H_
