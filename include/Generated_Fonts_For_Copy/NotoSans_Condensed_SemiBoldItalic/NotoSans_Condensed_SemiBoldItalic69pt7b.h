#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC69PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x7F, 0x87, 0xF8,
  0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F,
  0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE7, 0x8F, 0x80, 0x7F, 0x8F, 0x06, 0x00, 0xFE, 0x1C,
  0x00, 0x01, 0xFC, 0x38, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x0F, 0xF1, 0xE0,
  0x00, 0x1F, 0xE3, 0x80, 0x00, 0x1F, 0xC7, 0x00, 0x00, 0x3F, 0xCE, 0x00,
  0x00, 0x7F, 0xDC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x3F, 0xE0, 0x00,
  0x0E, 0x7F, 0xC0, 0x00, 0x1C, 0x7F, 0x80, 0x00, 0x38, 0xFF, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x01, 0xC3, 0xFC, 0x20, 0x03, 0x87, 0xF8, 0x60, 0x07,
  0x0F, 0xE0, 0xF0, 0x0E, 0x3F, 0xC1, 0xF8, 0x3D, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x83, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x7E, 0x0F, 0xF1, 0xF8, 0x3F, 0x0F,
  0xC3, 0xFF, 0x3F, 0x07, 0xE3, 0xF0, 0xFF, 0xF7, 0xE1, 0xF8, 0xFE, 0x3F,
  0xFE, 0xFC, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7E, 0x1F, 0xBF, 0xFE, 0x3F, 0x1F, 0xC3, 0xF3, 0xFF,
  0x8F, 0xE3, 0xF0, 0x7E, 0x7F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF0, 0x7F, 0xC7,
  0xFC, 0x7F, 0x83, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC0, 0xFF, 0xBF, 0xC1,
  0xFE, 0x03, 0xFD, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x7F,
  0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x03, 0x01, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xE7,
  0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x81,
  0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xF7,
  0xE0, 0x0F, 0xF9, 0xFC, 0x07, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F,
  0x83, 0xFC, 0x01, 0xC0, 0x7F, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF0, 0x03, 0x07, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xFF, 0xFD, 0xFF,
  0x7F, 0x9F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x00, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFE, 0xFE,
  0x3F, 0xF3, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x83, 0xE1, 0xFE, 0x06,
  0x07, 0xF0, 0x10, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x0F,
  0x00, 0x3F, 0xC0, 0x06, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0x78, 0x03, 0xFF,
  0x00, 0x20, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x80, 0x00, 0x7F, 0xC0,
  0xE0, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07,
  0xE3, 0xFC, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01,
  0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0xC0, 0x00, 0xFF, 0xC0, 0xF0, 0x01, 0xFF, 0x80, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0xFF, 0x1F, 0xF0,
  0x01, 0xFC, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0xC7,
  0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE1, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF3,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0x3F, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x38, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0x0E, 0x00, 0xFF, 0x08, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xFE, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xFC, 0x3F, 0x07, 0xE0, 0x1F, 0xFF,
  0xC0, 0xF8, 0x7E, 0x01, 0xFF, 0xFE, 0x07, 0xC3, 0xF0, 0x1F, 0xE7, 0xF0,
  0x3E, 0x1F, 0x01, 0xFC, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0xC0, 0xF8, 0x0F,
  0x8F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x3F, 0x07, 0xE0, 0x1F, 0x01, 0xF9, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0x9F, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0xFC, 0x1F,
  0x80, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x3E, 0x07, 0xE0,
  0x3F, 0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x9F, 0x81, 0xF0, 0x0F,
  0xC0, 0xFC, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xC7, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x3F, 0x07, 0xE0, 0x7F, 0x03, 0xE1, 0xF8, 0x3F, 0x03, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0xC3, 0xF0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x1F, 0x80, 0xFF, 0xE7, 0xFF, 0x80, 0xFC,
  0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x7F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0xF8, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x80, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x40, 0x07, 0xFF, 0x00, 0x70, 0x00, 0xFF, 0xF9, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x0F,
  0xFE, 0x00, 0x02, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0x00,
  0x7F, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0x83,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x08, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFB, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0,
  0x07, 0xF7, 0xF8, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xBF,
  0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0xE0, 0x0F,
  0xF3, 0xF8, 0x07, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0xE0, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC,
  0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xE3, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x9F, 0xC1, 0xFE, 0x00, 0x7F, 0x03,
  0xF3, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7E, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xDF, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xDF, 0xC0, 0x1F, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xF8, 0x03, 0xFD,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x0F, 0xF3, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFB, 0xFC, 0x00, 0xFF,
  0xC0, 0x1E, 0x00, 0x7F, 0xC0, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x00,
  0x3F, 0xE0, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x7E,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFD,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x3F, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xEF, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x80, 0x3F,
  0x81, 0xF8, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xF0,
  0x03, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F,
  0x80, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x07, 0xF3,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0x7E, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x0F, 0xDF, 0xE0, 0x00, 0x7F, 0x7E,
  0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x01, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0xFF, 0xFC,
  0xFE, 0x01, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xBF,
  0x80, 0x7F, 0xFF, 0x7F, 0x00, 0x3F, 0xFE, 0x7F, 0x00, 0x1F, 0xFC, 0x7F,
  0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0x3F,
  0xF0, 0x00, 0xFE, 0x7F, 0xF8, 0x00, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF,
  0x00, 0x7E, 0x7F, 0xFE, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0xFE, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF8, 0x0C, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0x01, 0xFF, 0x83,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x7F,
  0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFD, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0x00, 0x07, 0xFF,
  0xE7, 0xE0, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x04, 0x07, 0xFC, 0x01, 0xC0, 0x7F, 0xFB, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x87, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x20, 0x00, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0xFE,
  0x7F, 0x00, 0x0F, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFD, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0xEF,
  0xF0, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x0C,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x7F,
  0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x7F, 0x9F, 0xFC, 0x00, 0xFE, 0x7F, 0xFC, 0x01, 0xFD, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x08, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFD, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0xF0, 0x03, 0xF1,
  0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0x81,
  0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0x9F,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0xFF,
  0xC0, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x0F, 0xCF, 0xFF, 0xC0, 0x03, 0xFB,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xF0, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xFF,
  0x80, 0x07, 0xF3, 0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0xFC, 0x01, 0xFF, 0xF3,
  0xF8, 0x07, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x07, 0xF8, 0x0F, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03,
  0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xCF, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x70, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xF0, 0x0F, 0xC7, 0xFC, 0x03, 0xF3, 0xFF,
  0x01, 0xFD, 0xFF, 0x80, 0x7F, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE1, 0xF0, 0x1F, 0xE0, 0x1C, 0x0F, 0xF0, 0x01, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x20, 0x01, 0xFF, 0x0C, 0x00, 0x7F, 0xC3, 0xE0, 0x7F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x40, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xBF, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xF9, 0xFC, 0x01,
  0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0x8F, 0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x0F,
  0xE0, 0x3E, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xEF, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7E, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC,
  0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xCF, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF1, 0xFC, 0xFE, 0x00,
  0xFE, 0x7E, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE1, 0xFD, 0xFC, 0x00, 0xFE,
  0xFC, 0x1F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x00, 0xFE, 0xFC,
  0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x81, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x1F,
  0xBF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03,
  0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x04, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x08, 0xFF, 0xC0,
  0x00, 0x4F, 0xFF, 0x80, 0x06, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF6, 0x00, 0x07, 0xFF, 0x20, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 20, 50, 18, 0, -49 },
  { 126, 23, 18, 27, 7, -49 },
  { 178, 36, 49, 35, 1, -49 },
  { 399, 31, 56, 31, 1, -52 },
  { 616, 43, 51, 50, 4, -50 },
  { 891, 37, 51, 38, 0, -50 },
  { 1127, 11, 18, 16, 7, -49 },
  { 1152, 22, 60, 19, 2, -49 },
  { 1317, 23, 61, 20, -5, -50 },
  { 1493, 26, 29, 30, 6, -53 },
  { 1588, 29, 33, 34, 3, -41 },
  { 1708, 14, 17, 16, -3, -8 },
  { 1738, 18, 7, 20, 1, -22 },
  { 1754, 10, 11, 16, 0, -10 },
  { 1768, 34, 50, 26, -3, -50 },
  { 1981, 29, 51, 31, 2, -50 },
  { 2166, 22, 49, 32, 7, -49 },
  { 2301, 33, 50, 31, -2, -50 },
  { 2508, 32, 51, 31, 0, -50 },
  { 2712, 33, 49, 32, -1, -49 },
  { 2915, 32, 50, 31, 0, -49 },
  { 3115, 31, 51, 31, 2, -50 },
  { 3313, 33, 49, 31, 2, -49 },
  { 3516, 32, 51, 31, 0, -50 },
  { 3720, 30, 51, 31, 1, -50 },
  { 3912, 16, 39, 17, 0, -38 },
  { 3990, 20, 47, 17, -4, -38 },
  { 4108, 29, 33, 34, 3, -41 },
  { 4228, 29, 20, 34, 3, -34 },
  { 4301, 29, 33, 34, 3, -41 },
  { 4421, 24, 51, 25, 3, -50 },
  { 4574, 45, 56, 48, 2, -50 },
  { 4889, 34, 49, 34, -4, -49 },
  { 5098, 34, 49, 35, 1, -49 },
  { 5307, 34, 51, 33, 3, -50 },
  { 5524, 36, 49, 38, 1, -49 },
  { 5745, 32, 49, 30, 1, -49 },
  { 5941, 32, 49, 28, 1, -49 },
  { 6137, 37, 51, 39, 3, -50 },
  { 6373, 40, 49, 39, 1, -49 },
  { 6618, 29, 49, 22, -3, -49 },
  { 6796, 30, 63, 18, -11, -49 },
  { 7033, 39, 49, 34, 1, -49 },
  { 7272, 23, 49, 28, 1, -49 },
  { 7413, 51, 49, 51, 1, -49 },
  { 7726, 42, 49, 42, 1, -49 },
  { 7984, 36, 51, 40, 3, -50 },
  { 8214, 34, 49, 34, 1, -49 },
  { 8423, 36, 62, 40, 3, -50 },
  { 8702, 33, 49, 34, 1, -49 },
  { 8905, 33, 51, 30, -1, -50 },
  { 9116, 28, 49, 29, 6, -49 },
  { 9288, 37, 50, 38, 3, -49 },
  { 9520, 33, 49, 33, 6, -49 },
  { 9723, 51, 49, 51, 6, -49 },
  { 10036, 41, 49, 32, -4, -49 },
  { 10288, 31, 49, 31, 6, -49 },
  { 10478, 35, 49, 29, -2, -49 },
  { 10693, 27, 60, 20, -2, -49 },
  { 10896, 14, 50, 26, 7, -50 },
  { 10984, 27, 60, 20, -5, -49 },
  { 11187, 30, 29, 32, 1, -49 },
  { 11296, 24, 4, 24, -6, 6 },
  { 11308, 12, 11, 20, 10, -53 },
  { 11325, 32, 39, 34, 2, -38 },
  { 11481, 32, 53, 34, 0, -52 },
  { 11693, 26, 39, 27, 2, -38 },
  { 11820, 35, 53, 34, 2, -52 },
  { 12052, 28, 39, 31, 2, -38 },
  { 12189, 36, 70, 20, -8, -53 },
  { 12504, 35, 55, 34, -1, -38 },
  { 12745, 31, 52, 34, 0, -52 },
  { 12947, 19, 52, 16, 0, -52 },
  { 13071, 28, 69, 16, -9, -52 },
  { 13313, 34, 52, 31, 0, -52 },
  { 13534, 19, 52, 16, 0, -52 },
  { 13658, 48, 38, 50, 0, -38 },
  { 13886, 31, 38, 34, 0, -38 },
  { 14034, 29, 39, 33, 2, -38 },
  { 14176, 35, 54, 34, -3, -38 },
  { 14413, 31, 55, 34, 2, -38 },
  { 14627, 26, 38, 23, 0, -38 },
  { 14751, 26, 39, 26, 0, -38 },
  { 14878, 20, 47, 21, 3, -46 },
  { 14996, 31, 38, 33, 2, -37 },
  { 15144, 28, 37, 28, 4, -37 },
  { 15274, 44, 37, 44, 4, -37 },
  { 15478, 35, 37, 29, -3, -37 },
  { 15640, 38, 54, 29, -6, -37 },
  { 15897, 28, 37, 25, -2, -37 },
  { 16027, 27, 60, 23, 1, -49 },
  { 16230, 7, 69, 29, 11, -53 },
  { 16291, 27, 60, 23, -4, -49 },
  { 16494, 29, 11, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC69PT7B_H_
