#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x3C, 0xF3, 0x8F,
  0x78, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xC0, 0x00,
  0x71, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0C,
  0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x8E, 0x23, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0x62, 0x1E, 0x60, 0x1E, 0x40, 0x1E, 0x40, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xBC, 0x01,
  0xBC, 0x01, 0x3C, 0x43, 0x3C, 0x63, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xE0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0F, 0x80, 0x70,
  0x7F, 0x03, 0x83, 0xFC, 0x1C, 0x1E, 0x70, 0x70, 0x71, 0xC3, 0x81, 0xC7,
  0x0E, 0x0F, 0x1C, 0x70, 0x38, 0x73, 0x80, 0xE3, 0xCE, 0x03, 0x8E, 0x70,
  0x0E, 0x39, 0xCF, 0xB9, 0xCE, 0x7E, 0xFF, 0x73, 0xFF, 0xF9, 0xDE, 0x77,
  0xCE, 0x71, 0xC0, 0x39, 0xC7, 0x01, 0xCE, 0x1C, 0x0F, 0x38, 0x70, 0x38,
  0xE3, 0x81, 0xC3, 0x8E, 0x07, 0x0E, 0x38, 0x38, 0x39, 0xC1, 0xE0, 0xFF,
  0x07, 0x03, 0xF8, 0x38, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFE,
  0x1E, 0x3F, 0xC7, 0x8F, 0xFC, 0xF3, 0xE7, 0x9C, 0x78, 0xFF, 0x8F, 0x0F,
  0xE3, 0xC1, 0xFC, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xF1, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0x78, 0x3F, 0x8F, 0x80, 0x3C, 0xF7, 0x9E, 0x79, 0xC7, 0x1C,
  0xF0, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x00, 0x1E, 0x00, 0xE0,
  0x87, 0x07, 0x38, 0x7F, 0x9F, 0xFF, 0xE1, 0xFF, 0x0F, 0x98, 0xFC, 0x0F,
  0x70, 0xF3, 0x83, 0x1E, 0x08, 0x60, 0x02, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF,
  0xFF, 0xFF, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x79, 0xF1, 0xE1,
  0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1F, 0x7C, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xE7, 0xFD, 0xF7, 0x3D, 0xE3,
  0x3C, 0x47, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0xF1, 0xF0, 0x60, 0xF8,
  0x10, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0x1F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x80,
  0x78, 0xC1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xDE, 0x01,
  0xDC, 0x03, 0xBC, 0x07, 0x3C, 0x07, 0x3C, 0x0E, 0x3C, 0x1C, 0x38, 0x3C,
  0x78, 0x38, 0x78, 0x70, 0x78, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x80, 0xF8, 0xE1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xC2, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3D, 0xF0, 0x7B, 0xF8, 0x7F,
  0xF8, 0x7E, 0x7C, 0x7C, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x79, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1E, 0x0F, 0xBC, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0xF8, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0x9E, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x3E, 0x3E,
  0x7E, 0x1F, 0xFE, 0x1F, 0xDE, 0x0F, 0xBC, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x83, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x03, 0xC0, 0xF0, 0x7C,
  0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x03, 0x80, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F,
  0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x87, 0xF8, 0x7F,
  0x83, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0xE1, 0xFF, 0x8F,
  0xFE, 0x31, 0xF2, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x1E, 0x01,
  0xE0, 0x78, 0x01, 0xC1, 0xC0, 0x01, 0x87, 0x80, 0x03, 0x8E, 0x1F, 0xE7,
  0x38, 0x7F, 0x8E, 0x71, 0xE7, 0x1D, 0xC3, 0x8E, 0x3B, 0x8E, 0x1C, 0x77,
  0x1C, 0x70, 0xEC, 0x70, 0xE3, 0xB8, 0xE1, 0xC7, 0x71, 0xC7, 0x8E, 0xE3,
  0x8E, 0x39, 0xC7, 0x1C, 0x73, 0x8F, 0xFD, 0xC7, 0x1F, 0xBF, 0x0E, 0x1E,
  0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x02,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03,
  0xDC, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF,
  0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x07, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1E,
  0x3F, 0x07, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x83,
  0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF1, 0xE0,
  0x78, 0x78, 0x3E, 0x1E, 0x3F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF8, 0xC1, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE3, 0x81,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8,
  0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87,
  0x81, 0xF0, 0xF0, 0x3C, 0x3E, 0x0F, 0x87, 0x87, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0x9E, 0x1F, 0x80, 0x8F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC1, 0xFE, 0xF0, 0x7F,
  0x3C, 0x1F, 0xCF, 0x0F, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x3F, 0x0F, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x1E, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x0D, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0x78, 0x7C, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81,
  0xFE, 0x0E, 0xE0, 0x77, 0x83, 0xB8, 0x3D, 0xC1, 0xEE, 0x0E, 0xF0, 0x7B,
  0x87, 0xBC, 0x1E, 0xF1, 0xCF, 0x07, 0x3C, 0xF3, 0xC1, 0xCF, 0x39, 0xE0,
  0xF3, 0xDE, 0x78, 0x3C, 0xF7, 0x1E, 0x0F, 0x3D, 0xC7, 0x83, 0x8F, 0xE1,
  0xE1, 0xE1, 0xF8, 0xF0, 0x78, 0x7E, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87,
  0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x00, 0x07, 0xC0, 0x3C,
  0x1F, 0x00, 0xF0, 0x7E, 0x03, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x3F,
  0x81, 0xE0, 0xFF, 0x07, 0x03, 0xFC, 0x3C, 0x0E, 0xF0, 0xF0, 0x39, 0xC3,
  0xC1, 0xE7, 0x0F, 0x07, 0x9E, 0x38, 0x1E, 0x79, 0xE0, 0x71, 0xE7, 0x83,
  0xC3, 0x9E, 0x0F, 0x0F, 0x78, 0x3C, 0x3D, 0xC0, 0xF0, 0xFF, 0x03, 0x81,
  0xFC, 0x1E, 0x07, 0xF0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8,
  0x1C, 0x03, 0xE0, 0xF0, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F,
  0x78, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01,
  0xF3, 0xC0, 0xF8, 0xF8, 0x3E, 0x3F, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x07, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0xCF,
  0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E,
  0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF8, 0x3E, 0x3F,
  0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xF3, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC7, 0x83, 0xC3, 0xCF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x79, 0xE0, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x7C, 0xF0, 0x1E, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xDE,
  0x1F, 0x02, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x80, 0xF8, 0xF3, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x00, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x3E,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x9F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x7C, 0x3E, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x0E, 0x1E,
  0x07, 0x1E, 0x03, 0x8F, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x77, 0x80, 0x3B,
  0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x81, 0xEF,
  0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x7E, 0x0F, 0x3C, 0x1F, 0x83,
  0xCF, 0x07, 0xE1, 0xE3, 0xC3, 0xB8, 0x78, 0xF0, 0xFE, 0x1C, 0x3C, 0x7F,
  0x8F, 0x0F, 0x1D, 0xE3, 0xC3, 0xC7, 0x79, 0xE0, 0xF3, 0xDE, 0x78, 0x3C,
  0xE7, 0x9C, 0x0F, 0x79, 0xEF, 0x03, 0xDC, 0x7B, 0xC0, 0xF7, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xE1, 0xDC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x03,
  0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0xF0,
  0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79,
  0xE0, 0x79, 0xE0, 0x3B, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE1,
  0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC7, 0x87, 0x0E,
  0x1E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x07, 0x3C, 0x0F, 0x1C, 0x0E, 0x1C,
  0x1C, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF9, 0xE7, 0x8E, 0x3C, 0x70, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF,
  0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C,
  0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0x70, 0x3E, 0x70, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x7F, 0xF8, 0xF7, 0xF0,
  0xE7, 0xE0, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x3E, 0x23, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x08, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x07, 0xCF, 0x03, 0xFB, 0xC1, 0xFF, 0xE0, 0x78, 0xF8,
  0x3C, 0x3E, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x83, 0xE7, 0xE0, 0xFF, 0xF8, 0x1F, 0xDC, 0x03, 0xE7, 0x00, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x3E,
  0xFF, 0xF3, 0xFF, 0x8F, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x08, 0x7F, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF7, 0x83, 0xFB, 0xC3, 0xFF, 0xE1, 0xE3, 0xE1,
  0xE1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF9,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC1, 0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F,
  0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0x87,
  0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3B, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xCF, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xF1, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1F, 0x00, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x0E, 0x7C, 0x3E,
  0x0E, 0xFE, 0xFF, 0x0F, 0xFE, 0xFF, 0x1F, 0x9F, 0x8F, 0x1F, 0x0F, 0x0F,
  0x1E, 0x0F, 0x0F, 0x1E, 0x1E, 0x0F, 0x1C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0E,
  0x3C, 0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x3C, 0x1E, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x78, 0x3C,
  0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x78, 0x0E, 0x7C, 0x0E, 0xFE, 0x0F, 0xFF,
  0x1F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF8,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0x3C, 0x3E,
  0x7C, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0x9F, 0x00, 0xEF,
  0xE0, 0x3F, 0xFC, 0x1F, 0x9F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F, 0xFE, 0x0F, 0x7F,
  0x03, 0xCF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE7, 0x0F,
  0xEF, 0x1F, 0xFE, 0x1E, 0x3E, 0x3C, 0x3E, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3E, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x0E, 0x78, 0x77, 0xC3, 0xFE, 0x3F, 0xE1, 0xF8, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xF0,
  0xFF, 0xC7, 0xFE, 0x7C, 0x23, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x98, 0x7C,
  0xFF, 0xC7, 0xFE, 0x3F, 0xC0, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xFE,
  0xFF, 0x9F, 0xF0, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0xE0, 0xFC, 0x1F,
  0x80, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF8, 0xFF, 0xF0, 0x7F,
  0x70, 0x7E, 0x70, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3,
  0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x07, 0x78, 0x1D, 0xE0,
  0x77, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x3F, 0xC3, 0xE0, 0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E,
  0xF1, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x3B, 0x8E, 0x3C, 0xEE, 0x78, 0xF7,
  0xB9, 0xE3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x3F, 0x8E, 0xE0, 0xFE, 0x3F,
  0x83, 0xB8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78,
  0xF8, 0x0E, 0x3C, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xDE, 0x01, 0xF7, 0x80, 0x78, 0xE0, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x83,
  0xC0, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x78, 0x0F, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x9E, 0x00, 0x73,
  0xC0, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xE3,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x01, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xFC, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xFC, 0x0F, 0xC0,
  0x7C, 0x03, 0x00, 0x00, 0x7C, 0x07, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x81,
  0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 12, 9, 14, 3, -25 },
  { 47, 19, 25, 18, 0, -25 },
  { 107, 16, 29, 16, 0, -27 },
  { 165, 22, 25, 25, 2, -25 },
  { 234, 19, 25, 19, 0, -25 },
  { 294, 6, 9, 8, 3, -25 },
  { 301, 11, 31, 10, 1, -25 },
  { 344, 12, 31, 10, -3, -25 },
  { 391, 13, 15, 15, 3, -27 },
  { 416, 14, 17, 17, 2, -21 },
  { 446, 8, 9, 8, -2, -4 },
  { 455, 8, 3, 10, 1, -11 },
  { 458, 5, 5, 8, 0, -5 },
  { 462, 18, 25, 13, -2, -25 },
  { 519, 15, 25, 16, 1, -25 },
  { 566, 11, 25, 16, 4, -25 },
  { 601, 17, 25, 16, -1, -25 },
  { 655, 16, 25, 16, 0, -25 },
  { 705, 16, 25, 16, 0, -25 },
  { 755, 16, 25, 16, 0, -25 },
  { 805, 16, 25, 16, 1, -25 },
  { 855, 17, 25, 16, 1, -25 },
  { 909, 16, 25, 16, 0, -25 },
  { 959, 16, 25, 16, 0, -25 },
  { 1009, 8, 19, 8, 0, -19 },
  { 1028, 10, 24, 8, -2, -19 },
  { 1058, 14, 17, 17, 2, -21 },
  { 1088, 14, 10, 17, 2, -17 },
  { 1106, 14, 17, 17, 2, -21 },
  { 1136, 13, 25, 12, 1, -25 },
  { 1177, 23, 28, 24, 1, -25 },
  { 1258, 17, 25, 17, -2, -25 },
  { 1312, 18, 25, 18, 0, -25 },
  { 1369, 17, 25, 17, 2, -25 },
  { 1423, 19, 25, 19, 0, -25 },
  { 1483, 17, 25, 15, 0, -25 },
  { 1537, 17, 25, 14, 0, -25 },
  { 1591, 18, 25, 20, 2, -25 },
  { 1648, 21, 25, 20, 0, -25 },
  { 1714, 14, 25, 11, -1, -25 },
  { 1758, 15, 32, 9, -5, -25 },
  { 1818, 20, 25, 17, 0, -25 },
  { 1881, 12, 25, 14, 0, -25 },
  { 1919, 26, 25, 26, 0, -25 },
  { 2001, 22, 25, 21, 0, -25 },
  { 2070, 18, 25, 21, 2, -25 },
  { 2127, 18, 25, 17, 0, -25 },
  { 2184, 18, 31, 21, 2, -25 },
  { 2254, 17, 25, 17, 0, -25 },
  { 2308, 16, 25, 15, 0, -25 },
  { 2358, 14, 25, 15, 3, -25 },
  { 2402, 18, 25, 19, 2, -25 },
  { 2459, 17, 25, 17, 3, -25 },
  { 2513, 26, 25, 26, 3, -25 },
  { 2595, 21, 25, 16, -2, -25 },
  { 2661, 16, 25, 15, 3, -25 },
  { 2711, 18, 25, 15, -1, -25 },
  { 2768, 14, 31, 10, -1, -25 },
  { 2823, 7, 25, 13, 4, -25 },
  { 2845, 13, 31, 10, -2, -25 },
  { 2896, 16, 15, 16, 0, -25 },
  { 2926, 12, 2, 12, -3, 3 },
  { 2929, 6, 6, 10, 5, -27 },
  { 2934, 16, 19, 17, 1, -19 },
  { 2972, 16, 27, 17, 0, -27 },
  { 3026, 13, 19, 13, 1, -19 },
  { 3057, 18, 27, 17, 1, -27 },
  { 3118, 14, 19, 16, 1, -19 },
  { 3152, 18, 35, 10, -4, -27 },
  { 3231, 17, 27, 17, 0, -19 },
  { 3289, 16, 27, 17, 0, -27 },
  { 3343, 9, 26, 8, 0, -26 },
  { 3373, 14, 34, 8, -4, -26 },
  { 3433, 17, 27, 16, 0, -27 },
  { 3491, 10, 27, 8, 0, -27 },
  { 3525, 24, 19, 25, 0, -19 },
  { 3582, 16, 19, 17, 0, -19 },
  { 3620, 15, 19, 17, 1, -19 },
  { 3656, 18, 27, 17, -2, -19 },
  { 3717, 16, 27, 17, 1, -19 },
  { 3771, 13, 19, 12, 0, -19 },
  { 3802, 13, 19, 13, 0, -19 },
  { 3833, 11, 23, 11, 1, -23 },
  { 3865, 16, 19, 17, 1, -19 },
  { 3903, 14, 19, 14, 2, -19 },
  { 3937, 22, 19, 22, 2, -19 },
  { 3990, 18, 19, 15, -2, -19 },
  { 4033, 19, 27, 15, -3, -19 },
  { 4098, 14, 19, 13, -1, -19 },
  { 4132, 14, 31, 12, 0, -25 },
  { 4187, 3, 35, 15, 6, -27 },
  { 4201, 13, 31, 12, -2, -25 },
  { 4252, 14, 5, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC35PT7B_H_
