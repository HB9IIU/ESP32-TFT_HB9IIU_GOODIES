#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x3F, 0x8F, 0xE7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0x98, 0xF0, 0x0F, 0xCE, 0x08, 0x07, 0xE3, 0x80, 0x01,
  0xF8, 0xE0, 0x00, 0x7E, 0x30, 0x00, 0x1F, 0x8C, 0x00, 0x07, 0xF7, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xDF, 0xC0, 0x00, 0x73, 0xF0,
  0x00, 0x1C, 0xFC, 0x00, 0x06, 0x3F, 0x00, 0x03, 0x8F, 0xC1, 0x00, 0xE3,
  0xF0, 0x60, 0x39, 0xFC, 0x1F, 0x0C, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xC0, 0x1F, 0xF8, 0x00, 0xF0, 0x07, 0xFF, 0x00,
  0x3E, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0x0F, 0x87,
  0xC0, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0x00, 0x3C, 0x1F, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x87, 0xC0,
  0x07, 0x83, 0xE0, 0xF0, 0x01, 0xF0, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x8F,
  0x80, 0x07, 0xC1, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F,
  0x8F, 0x1F, 0xF3, 0xE1, 0xF3, 0xE7, 0xFF, 0x7C, 0x7C, 0xF8, 0xFF, 0xEF,
  0xFF, 0x1F, 0x3E, 0x7C, 0xFF, 0xE7, 0xCF, 0x87, 0xDF, 0xF8, 0xF1, 0xF0,
  0xF9, 0xFE, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x8F, 0x83, 0xE0, 0x01, 0xF1,
  0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x0F, 0x00, 0x0F, 0x8F, 0x83, 0xE0, 0x03,
  0xE1, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0x01,
  0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x1F,
  0x83, 0xFF, 0xC0, 0xFC, 0x3F, 0xFF, 0x07, 0xE3, 0xF9, 0xF8, 0x7E, 0x1F,
  0x8F, 0xE3, 0xF1, 0xF8, 0x3F, 0x3F, 0x0F, 0xC1, 0xFD, 0xF8, 0xFC, 0x07,
  0xFF, 0x87, 0xE0, 0x3F, 0xFC, 0x3F, 0x00, 0xFF, 0xC3, 0xF8, 0x07, 0xFC,
  0x1F, 0xC0, 0x3F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x1F,
  0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xDF, 0xC0, 0x7F, 0xFC, 0x7F, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x04, 0x07, 0xC0, 0x38, 0x3E, 0x01,
  0xF1, 0xE0, 0x0F, 0xEF, 0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xF7, 0xC0, 0x3F, 0xBE, 0x03, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0x3C, 0x3F,
  0x00, 0xC0, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x0C,
  0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x30, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8,
  0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0x7E, 0x7F, 0x3F, 0x3F, 0x1F, 0x8F, 0x1F, 0x83, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0x07, 0xF8, 0x03, 0xC0, 0x7F, 0x00, 0x60, 0x0F,
  0xE0, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x81, 0xFE, 0x01, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x40, 0x03, 0xFC, 0x3C, 0x07, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x60, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xC0, 0x07, 0xF0,
  0x3C, 0x07, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x3F,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xC7, 0xF8, 0x7F, 0x83, 0xF8, 0xFF, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE3,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07,
  0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x83, 0xFE, 0x1F,
  0xEF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFC, 0x07,
  0xFD, 0xFC, 0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x3E, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0E, 0x07, 0xF0, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x03, 0xF8, 0x1E, 0x0F, 0x80, 0xFF, 0xE1, 0xF1, 0xF0, 0x3F, 0xFE, 0x1F,
  0x1F, 0x07, 0xFF, 0xE1, 0xF1, 0xE0, 0x7C, 0x3C, 0x1F, 0x3E, 0x0F, 0x83,
  0xC1, 0xF3, 0xC1, 0xF0, 0x7C, 0x1E, 0x7C, 0x1E, 0x07, 0xC1, 0xE7, 0xC3,
  0xE0, 0x78, 0x1E, 0x78, 0x3E, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0xF8, 0x3E,
  0xF8, 0x7C, 0x0F, 0x83, 0xCF, 0x87, 0xC0, 0xF0, 0x3C, 0xF8, 0x78, 0x1F,
  0x07, 0xCF, 0x07, 0x81, 0xF0, 0x78, 0xF0, 0x78, 0x1F, 0x07, 0x8F, 0x07,
  0x83, 0xF0, 0xF8, 0xF0, 0x78, 0x3F, 0x1F, 0x0F, 0x07, 0xC7, 0xF3, 0xE0,
  0xF0, 0x7F, 0xEF, 0xFE, 0x0F, 0x03, 0xFE, 0xFF, 0xC0, 0xF0, 0x3F, 0xC7,
  0xF8, 0x0F, 0x80, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0xE0, 0x1F, 0xE0, 0x04, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0xFF, 0x83, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7E, 0x3F, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80,
  0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x00,
  0x3F, 0x81, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE,
  0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0x00, 0xFF,
  0x80, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF8, 0x7F,
  0x01, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0x87, 0xE0, 0x1F, 0xFC, 0x1F, 0x80,
  0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01,
  0xFE, 0x00, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0E, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0x7C,
  0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0x7C,
  0xFC, 0x01, 0xF9, 0xF0, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x0F, 0x9F, 0xC0,
  0x1F, 0x1F, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x03, 0xF1,
  0xF0, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x1F,
  0x8F, 0xE0, 0x0F, 0x87, 0xC7, 0xC3, 0xF0, 0x07, 0xE1, 0xF3, 0xF0, 0xFC,
  0x01, 0xF8, 0x7C, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xBE, 0x0F, 0xC0, 0x1F,
  0x87, 0xFF, 0x07, 0xE0, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x7F,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x03, 0xFE,
  0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x1F,
  0xF8, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00,
  0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0x7C, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0x00, 0xFD, 0xF8, 0x1F, 0x80, 0x3E, 0x7E, 0x07,
  0xE0, 0x1F, 0x8F, 0x81, 0xF8, 0x07, 0xE3, 0xF0, 0x7E, 0x01, 0xF8, 0xFC,
  0x1F, 0x80, 0x7E, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xC3, 0xF0, 0x0F, 0xC1,
  0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x8F, 0x80, 0x3F,
  0x07, 0xE7, 0xE0, 0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xE0, 0x3F, 0x7E, 0x01,
  0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x7D, 0xF0,
  0x0F, 0xC0, 0x1F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F, 0xF8, 0x07, 0xE0, 0x03,
  0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC3, 0xFE, 0x01, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x03, 0xFC, 0x07, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x7F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xC1, 0xE0, 0x1F, 0xE0, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x40, 0x03, 0xF8, 0x0E, 0x00, 0xFF, 0x01, 0xF8, 0x7F,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xD0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xFC, 0x01, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0xFC, 0x03, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xFE, 0x01,
  0xF8, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0xFC,
  0x07, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0, 0xFC, 0x0F, 0xBE,
  0x07, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x3E, 0x1F, 0xC0, 0xFC, 0x3E, 0x3E, 0x1F, 0x80, 0xFC, 0x3E,
  0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x3E, 0x3F, 0x00, 0xFC, 0x7C, 0x3E, 0x3F,
  0x00, 0xFC, 0xFC, 0x3E, 0x3F, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0xFC,
  0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x3E, 0xFC, 0x00, 0xF9, 0xF0, 0x3E,
  0xFC, 0x00, 0xF9, 0xF0, 0x7E, 0xFC, 0x00, 0xFB, 0xE0, 0x7D, 0xF8, 0x00,
  0xFB, 0xE0, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x7D, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x41, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x8F, 0x80,
  0xFF, 0xE7, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8,
  0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0xFC, 0x03, 0xFE, 0x7E, 0x00,
  0xFE, 0x3F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x1F,
  0x9F, 0xF0, 0x0F, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFE, 0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x87, 0xFC,
  0x3F, 0x83, 0xFF, 0xFF, 0xC1, 0xF7, 0xFF, 0xC0, 0xFB, 0xFF, 0xC0, 0xFC,
  0xFF, 0xC0, 0x7C, 0x3F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF8,
  0x30, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x20,
  0xFF, 0x06, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x03, 0xFF, 0x7E, 0x00, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xE1, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xF8, 0x03, 0xFF, 0xDF, 0x00, 0x3F, 0xE3,
  0xE0, 0x03, 0xF8, 0x78, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFB, 0xF8, 0x3F,
  0x87, 0xE1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x81, 0xFC, 0x7E, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x01, 0x83, 0xFE, 0x7E, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC4, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x08, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0xF3, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xEF, 0xC0, 0x0F, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x81, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x0F, 0xE0, 0x0F, 0x81, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x1F, 0x9F, 0xF0, 0x0F, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x8F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF1, 0xFC,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF3,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xE1,
  0xFC, 0x0F, 0xE0, 0x0F, 0x8F, 0xF8, 0x7F, 0xE0, 0x3E, 0x7F, 0xF3, 0xFF,
  0x80, 0xFB, 0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC7, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x3F,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE1, 0xFC,
  0x01, 0xF1, 0xFF, 0x00, 0xF9, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x3F,
  0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF,
  0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01,
  0xFC, 0x7E, 0x07, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x80, 0x07, 0xC7, 0xFC, 0x00, 0x7C, 0xFF, 0xE0,
  0x07, 0xDF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0x00, 0xFF,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x0F, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFD, 0xFF, 0xC0, 0x0F, 0xDF, 0xF8, 0x01, 0xF8, 0xFF, 0x00, 0x1F, 0x81,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0x80,
  0xFF, 0xCF, 0x80, 0xFF, 0xE7, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0x0F, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xE0, 0xFE,
  0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFE, 0xFC, 0x03,
  0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xE1, 0xF8, 0x1F, 0x1F, 0xC0, 0xF9, 0xFC, 0x07, 0xDF, 0xE0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x30, 0x7F, 0x00,
  0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x10, 0x03, 0xF0, 0xE0, 0x3F, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x16, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x04, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0xFC, 0x0F, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFB, 0xE0, 0x7F, 0xF7, 0xE0, 0x7F, 0xE7, 0xC0, 0x3F, 0xC7, 0xC0,
  0x02, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x3E,
  0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0x01, 0xFB, 0xF0, 0x1F, 0xE0, 0x3F, 0x7E, 0x03, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFF, 0x81, 0xF9, 0xF8, 0x1F, 0xF0, 0x3F, 0x3F, 0x03, 0xFE, 0x0F,
  0xC7, 0xE0, 0xFF, 0xC1, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E, 0x1F, 0x87, 0xDF,
  0x0F, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7E, 0x1E, 0x7C, 0x7E, 0x0F, 0xC7,
  0xCF, 0x8F, 0xC1, 0xF8, 0xF9, 0xF3, 0xF0, 0x3F, 0x3E, 0x3E, 0x7E, 0x07,
  0xE7, 0xC7, 0xCF, 0x80, 0xFC, 0xF8, 0xFB, 0xF0, 0x1F, 0xBE, 0x1F, 0x7E,
  0x03, 0xF7, 0xC3, 0xCF, 0x80, 0x7F, 0xF0, 0x7B, 0xF0, 0x0F, 0xFE, 0x0F,
  0x7C, 0x01, 0xFF, 0xC1, 0xEF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x02, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x00, 0x01, 0x1F, 0xE0, 0x01, 0x7F, 0xFC, 0x07,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0xC0, 0x0F, 0xFC, 0x80, 0x00, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 40, 14, 0, -39 },
  { 81, 19, 14, 21, 5, -39 },
  { 115, 29, 39, 28, 0, -39 },
  { 257, 26, 45, 25, 0, -42 },
  { 404, 35, 41, 39, 3, -40 },
  { 584, 29, 41, 30, 0, -40 },
  { 733, 9, 14, 13, 5, -39 },
  { 749, 18, 48, 16, 1, -39 },
  { 857, 18, 49, 16, -4, -40 },
  { 968, 21, 23, 24, 5, -42 },
  { 1029, 23, 27, 27, 3, -33 },
  { 1107, 12, 14, 13, -3, -7 },
  { 1128, 14, 6, 16, 1, -18 },
  { 1139, 8, 9, 13, 0, -8 },
  { 1148, 28, 40, 20, -3, -40 },
  { 1288, 24, 41, 25, 1, -40 },
  { 1411, 17, 39, 25, 6, -39 },
  { 1494, 27, 40, 25, -2, -40 },
  { 1629, 25, 41, 25, 0, -40 },
  { 1758, 26, 39, 25, -1, -39 },
  { 1885, 26, 40, 25, 0, -39 },
  { 2015, 24, 41, 25, 2, -40 },
  { 2138, 26, 39, 25, 2, -39 },
  { 2265, 26, 41, 25, 0, -40 },
  { 2399, 24, 41, 25, 1, -40 },
  { 2522, 13, 31, 13, 0, -30 },
  { 2573, 16, 37, 13, -3, -30 },
  { 2647, 24, 26, 27, 2, -33 },
  { 2725, 23, 16, 27, 3, -27 },
  { 2771, 23, 26, 27, 3, -33 },
  { 2846, 20, 41, 20, 2, -40 },
  { 2949, 36, 45, 38, 2, -40 },
  { 3152, 27, 39, 27, -3, -39 },
  { 3284, 28, 39, 28, 0, -39 },
  { 3421, 27, 41, 26, 2, -40 },
  { 3560, 29, 39, 30, 0, -39 },
  { 3702, 26, 39, 24, 0, -39 },
  { 3829, 26, 39, 23, 0, -39 },
  { 3956, 30, 41, 31, 2, -40 },
  { 4110, 32, 39, 31, 0, -39 },
  { 4266, 23, 39, 17, -2, -39 },
  { 4379, 23, 50, 14, -8, -39 },
  { 4523, 32, 39, 27, 0, -39 },
  { 4679, 19, 39, 22, 0, -39 },
  { 4772, 42, 39, 40, 0, -39 },
  { 4977, 34, 39, 33, 0, -39 },
  { 5143, 29, 41, 32, 2, -40 },
  { 5292, 28, 39, 27, 0, -39 },
  { 5429, 29, 49, 32, 2, -40 },
  { 5607, 27, 39, 27, 0, -39 },
  { 5739, 27, 41, 24, -1, -40 },
  { 5878, 23, 39, 23, 4, -39 },
  { 5991, 30, 40, 31, 2, -39 },
  { 6141, 26, 39, 27, 5, -39 },
  { 6268, 40, 39, 41, 5, -39 },
  { 6463, 33, 39, 25, -3, -39 },
  { 6624, 24, 39, 24, 5, -39 },
  { 6741, 28, 39, 23, -2, -39 },
  { 6878, 22, 48, 16, -2, -39 },
  { 7010, 11, 40, 21, 6, -40 },
  { 7065, 22, 48, 16, -4, -39 },
  { 7197, 25, 23, 25, 0, -39 },
  { 7269, 19, 3, 19, -5, 5 },
  { 7277, 10, 9, 16, 8, -42 },
  { 7289, 25, 31, 27, 2, -30 },
  { 7386, 25, 43, 27, 0, -42 },
  { 7521, 21, 31, 21, 2, -30 },
  { 7603, 27, 43, 27, 2, -42 },
  { 7749, 22, 31, 24, 2, -30 },
  { 7835, 28, 55, 16, -6, -42 },
  { 8028, 28, 43, 27, -1, -30 },
  { 8179, 25, 42, 27, 0, -42 },
  { 8311, 15, 41, 13, 0, -41 },
  { 8388, 22, 54, 13, -7, -41 },
  { 8537, 27, 42, 24, 0, -42 },
  { 8679, 15, 42, 13, 0, -42 },
  { 8758, 38, 30, 40, 0, -30 },
  { 8901, 25, 30, 27, 0, -30 },
  { 8995, 23, 31, 26, 2, -30 },
  { 9085, 28, 43, 27, -3, -30 },
  { 9236, 25, 43, 27, 2, -30 },
  { 9371, 21, 30, 19, 0, -30 },
  { 9450, 21, 31, 21, 0, -30 },
  { 9532, 16, 37, 17, 2, -36 },
  { 9606, 24, 31, 27, 2, -30 },
  { 9699, 23, 30, 23, 3, -30 },
  { 9786, 35, 30, 35, 3, -30 },
  { 9918, 29, 30, 23, -3, -30 },
  { 10027, 30, 43, 23, -4, -30 },
  { 10189, 23, 30, 20, -2, -30 },
  { 10276, 21, 48, 19, 1, -39 },
  { 10402, 5, 55, 23, 9, -42 },
  { 10437, 21, 48, 19, -3, -39 },
  { 10563, 24, 9, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC55PT7B_H_
