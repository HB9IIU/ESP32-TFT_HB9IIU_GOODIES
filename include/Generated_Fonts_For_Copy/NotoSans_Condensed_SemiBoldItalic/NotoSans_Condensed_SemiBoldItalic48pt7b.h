#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0,
  0x03, 0x00, 0x00, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0xF8, 0xF0,
  0xF8, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x84, 0x3C, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x0F, 0x07, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE6, 0x78, 0x1F, 0x18, 0x40, 0x7C, 0xE0,
  0x01, 0xF3, 0x00, 0x07, 0xCC, 0x00, 0x1F, 0x30, 0x00, 0x7E, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0x7E, 0x00, 0x0C, 0xF8,
  0x00, 0x73, 0xE0, 0x01, 0xCF, 0x80, 0x06, 0x3E, 0x18, 0x19, 0xF8, 0x78,
  0x67, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0x80, 0xFF, 0x80, 0x3C, 0x07, 0xFE, 0x01, 0xE0, 0x3E, 0x78, 0x07,
  0x80, 0xF1, 0xE0, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0x1E, 0x1E, 0x07, 0x80,
  0x78, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0xF0, 0x0F, 0x07, 0x87, 0x80, 0x3C,
  0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0xF0, 0x03, 0xC3, 0xC7, 0x80, 0x0F, 0x0F,
  0x1E, 0x3E, 0x3C, 0x7C, 0xF1, 0xFE, 0xF1, 0xE7, 0xCF, 0xFB, 0xCF, 0x9E,
  0x7F, 0xFF, 0xFC, 0xF1, 0xE7, 0xFF, 0xE3, 0xCF, 0x0F, 0x7F, 0x1E, 0x3C,
  0x3C, 0x70, 0xF9, 0xE0, 0xF0, 0x03, 0xC7, 0x83, 0xC0, 0x1F, 0x1E, 0x1F,
  0x00, 0x78, 0xF8, 0x78, 0x03, 0xC3, 0xE1, 0xE0, 0x1F, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x3E, 0x03, 0xE0, 0xF0, 0xF0, 0x0F, 0x03, 0xC3, 0xC0, 0x78,
  0x0F, 0x1F, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x00, 0x7F, 0xC0, 0x7C, 0x01,
  0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFC, 0x3F, 0xFC, 0x3E, 0x1F,
  0xBF, 0x1F, 0x8F, 0xC7, 0xE7, 0xC3, 0xE1, 0xFB, 0xF1, 0xF8, 0x3E, 0xF8,
  0x7C, 0x0F, 0xFE, 0x1F, 0x01, 0xFF, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x1F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xF1, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xFC, 0x0F, 0xFF, 0x3F, 0x80, 0xFF, 0x07, 0xE0,
  0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xF3, 0xC7, 0x80, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x02, 0x0F,
  0x00, 0xE1, 0xE0, 0x1F, 0x3C, 0x03, 0xFF, 0x9E, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xDF,
  0x03, 0xF1, 0xE0, 0x3E, 0x3E, 0x03, 0x87, 0xE0, 0x20, 0x70, 0x00, 0x08,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x0C, 0x7D,
  0xFF, 0xFF, 0xFF, 0xDF, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F,
  0x7C, 0xFC, 0xF8, 0xF1, 0xF0, 0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0x70, 0x1F, 0x80, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x07, 0xF0,
  0x10, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC2, 0x00, 0x7F, 0x0F, 0x8F, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x3E,
  0x00, 0x78, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0xF8, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x18, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x20, 0x03, 0xF0, 0xC0, 0x1F, 0xC3, 0xE3, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFC, 0x08,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x1F, 0x01, 0xFB, 0xFC, 0x0F,
  0xBF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC3, 0xF1, 0xFC, 0x0F,
  0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8,
  0x7E, 0x1F, 0x83, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E,
  0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xF1,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xBE, 0x07, 0xFB,
  0xF0, 0x0E, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0x0F, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x80, 0xC0,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0xE0, 0xFC, 0x40, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07,
  0x81, 0xFF, 0x0F, 0x0F, 0x03, 0xFF, 0x0F, 0x1F, 0x07, 0xFF, 0x0F, 0x1E,
  0x0F, 0x8F, 0x0F, 0x1E, 0x1E, 0x0F, 0x0F, 0x3C, 0x3E, 0x1E, 0x0F, 0x3C,
  0x3C, 0x1E, 0x0F, 0x3C, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E, 0x78,
  0x78, 0x3C, 0x1E, 0x78, 0x78, 0x3C, 0x1E, 0x78, 0xF8, 0x3C, 0x3C, 0x78,
  0xF0, 0x7C, 0x3C, 0x70, 0xF0, 0x78, 0x38, 0xF0, 0xF0, 0xF8, 0x78, 0xF0,
  0xF8, 0xF8, 0xF0, 0xF0, 0x7F, 0xFF, 0xF0, 0x70, 0x7F, 0xBF, 0xE0, 0x78,
  0x3F, 0x1F, 0xC0, 0x78, 0x0C, 0x06, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x18, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x01, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0x87, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x03,
  0xF8, 0x3E, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFC,
  0x3C, 0x07, 0xF0, 0x08, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00,
  0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0xE0, 0x3E,
  0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xC0, 0x7F, 0x80, 0x30, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xFF, 0x1F, 0x81, 0xFF, 0x8F, 0xC0, 0x7F,
  0xE3, 0xF0, 0x1F, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0x83, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E,
  0x07, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x87, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x07, 0xDF,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x7C, 0xF8, 0x0F, 0x9F, 0x07, 0x9F, 0x80,
  0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0x1F, 0x01, 0xF9, 0xF1, 0xF1,
  0xF0, 0x1F, 0x1F, 0x1E, 0x1F, 0x01, 0xF1, 0xF3, 0xE3, 0xF0, 0x1F, 0x0F,
  0x3C, 0x3E, 0x01, 0xF0, 0xF7, 0xC3, 0xE0, 0x3F, 0x0F, 0x7C, 0x3E, 0x03,
  0xE0, 0xFF, 0x87, 0xE0, 0x3E, 0x0F, 0xF8, 0x7E, 0x03, 0xE0, 0xFF, 0x07,
  0xC0, 0x3E, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x7C, 0x0F,
  0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x3E, 0x01, 0xFE, 0x00, 0xF8, 0x0F,
  0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x7C, 0x03, 0xFF,
  0x01, 0xF0, 0x0F, 0x7C, 0x07, 0xC0, 0x7D, 0xF0, 0x3F, 0x01, 0xF7, 0xE0,
  0xF8, 0x07, 0xCF, 0x83, 0xE0, 0x1F, 0x3E, 0x0F, 0x80, 0xFC, 0xF8, 0x3E,
  0x03, 0xE3, 0xE1, 0xF8, 0x0F, 0x87, 0xC7, 0xC0, 0x3E, 0x1F, 0x1F, 0x00,
  0xF8, 0x7C, 0x7C, 0x07, 0xE1, 0xF1, 0xF0, 0x1F, 0x07, 0xEF, 0xC0, 0x7C,
  0x0F, 0xBE, 0x01, 0xF0, 0x3E, 0xF8, 0x07, 0xC0, 0xFB, 0xE0, 0x3F, 0x03,
  0xEF, 0x80, 0xF8, 0x07, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x7F,
  0xC0, 0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0,
  0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x0F, 0xCF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xF1, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0x9F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xBF, 0x01, 0xFC,
  0x04, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x08, 0x00, 0xFC, 0x1C, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80,
  0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x00,
  0x7E, 0xFC, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x7C, 0xFC, 0x03,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0xF8, 0xFC, 0x07, 0xF0, 0x1F, 0x8F,
  0xC0, 0xFF, 0x01, 0xF8, 0xF8, 0x0F, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0x03,
  0xF0, 0xF8, 0x1F, 0xF0, 0x3E, 0x0F, 0x81, 0xEF, 0x07, 0xE0, 0xF8, 0x3E,
  0xF0, 0x7E, 0x0F, 0x83, 0xEF, 0x07, 0xC0, 0xF8, 0x7C, 0xF0, 0xFC, 0x0F,
  0x87, 0xCF, 0x0F, 0x80, 0xF8, 0x78, 0xF1, 0xF8, 0x0F, 0x8F, 0x8F, 0x1F,
  0x00, 0xF8, 0xF8, 0xF1, 0xF0, 0x0F, 0x9F, 0x0F, 0x3F, 0x00, 0xF9, 0xF0,
  0xF3, 0xE0, 0x0F, 0x9E, 0x0F, 0x3E, 0x00, 0xFB, 0xE0, 0xF7, 0xC0, 0x0F,
  0xBC, 0x0F, 0x7C, 0x00, 0xFB, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFD, 0xF0, 0x07, 0xE7, 0xC0,
  0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F,
  0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0,
  0x07, 0xBF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFC,
  0xFC, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x00, 0x10, 0x00, 0x03, 0xF0,
  0xF0, 0x3F, 0xE7, 0xC1, 0xFF, 0xDF, 0x07, 0xFF, 0xFC, 0x3F, 0x9F, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x07, 0xE3, 0xFC, 0x1F, 0xFD,
  0xF0, 0x7F, 0xF7, 0x80, 0xFF, 0xBE, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x82, 0x00, 0x3E, 0x7E, 0x01, 0xFB, 0xFC, 0x07, 0xDF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0x9F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x87, 0xF0, 0x7E, 0x1F,
  0xE3, 0xF0, 0x7F, 0xFF, 0xC1, 0xEF, 0xFE, 0x0F, 0x9F, 0xF0, 0x3E, 0x3F,
  0x80, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xC3, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x08, 0x1F, 0xC7, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7C,
  0x00, 0xFE, 0x7C, 0x03, 0xFF, 0x7C, 0x07, 0xFF, 0x7C, 0x07, 0xFF, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0x80,
  0x3F, 0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3,
  0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0x07, 0xE0,
  0x30, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x11, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0x8F, 0x00, 0xFF, 0xDF, 0x01, 0xFF, 0xDF, 0x01, 0xFF, 0xFF,
  0x03, 0xF9, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x1F, 0x8F, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFB, 0xE0, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x80, 0x1F, 0x80,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x82, 0x00, 0x3E, 0x7F,
  0x01, 0xFB, 0xFE, 0x07, 0xDF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x9F, 0xC3,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x07,
  0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0x00, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x02,
  0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x80,
  0x10, 0x01, 0xE3, 0xF8, 0x7F, 0x01, 0xF7, 0xFC, 0x7F, 0xC0, 0xFB, 0xFF,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xCF, 0xF8, 0xFC, 0x3F, 0x83,
  0xF8, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xE0,
  0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xE1, 0xF8,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0xFC, 0x3E,
  0x07, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x07, 0xC3,
  0xF0, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0x1F, 0xC0, 0x7C, 0xFF, 0x81, 0xF7, 0xFE,
  0x07, 0xBF, 0xFC, 0x1F, 0xE7, 0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81,
  0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x1F,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x1F,
  0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC1, 0xFC, 0x7E,
  0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x20, 0x00, 0xF1, 0xFC, 0x01, 0xF3, 0xFE, 0x01, 0xF7, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x1F,
  0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xE3, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0x7F, 0xC0, 0x3F, 0x3F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF8, 0xF0,
  0x1F, 0xF7, 0xC0, 0xFF, 0xDF, 0x07, 0xFF, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x07, 0xE3, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xBE, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x80, 0xF1, 0xF0, 0x7C,
  0xFC, 0x1F, 0x7F, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xE0, 0xE1, 0xF8, 0x08, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x20, 0x1F, 0x8E, 0x0F, 0xE3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xFF, 0xDF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x10, 0xFF, 0xC3, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x83, 0xF8, 0x7E,
  0x3F, 0x83, 0xFF, 0xBC, 0x1F, 0xFD, 0xE0, 0x7F, 0xDF, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x80,
  0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F,
  0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C,
  0x03, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x7F, 0x03, 0xEF, 0x81,
  0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x7E, 0xF8, 0x3F, 0xC1, 0xF3, 0xE0, 0xFF,
  0x07, 0xCF, 0x87, 0xBC, 0x3E, 0x3E, 0x1E, 0xF0, 0xF8, 0xF8, 0x7B, 0xC7,
  0xC3, 0xE3, 0xDF, 0x1F, 0x0F, 0x8F, 0x7C, 0x7C, 0x3E, 0x7D, 0xF3, 0xE0,
  0xF9, 0xE7, 0xCF, 0x83, 0xE7, 0x9F, 0x7C, 0x0F, 0xBC, 0x7D, 0xF0, 0x3E,
  0xF1, 0xF7, 0xC0, 0xFF, 0xC7, 0xBE, 0x03, 0xFE, 0x1E, 0xF8, 0x0F, 0xF8,
  0x7B, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xCF, 0x80, 0x0F, 0xCF, 0x80, 0x0F, 0x8F, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC1,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x13, 0xFC,
  0x01, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xE8, 0x00, 0x38,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 35, 12, 0, -34 },
  { 63, 16, 12, 19, 5, -34 },
  { 87, 26, 34, 25, 0, -34 },
  { 198, 22, 39, 22, 0, -36 },
  { 306, 30, 35, 34, 3, -35 },
  { 438, 26, 35, 26, 0, -35 },
  { 552, 7, 12, 11, 5, -34 },
  { 563, 16, 42, 14, 1, -34 },
  { 647, 16, 43, 14, -4, -35 },
  { 733, 19, 20, 21, 4, -37 },
  { 781, 20, 23, 23, 2, -28 },
  { 839, 10, 12, 11, -2, -6 },
  { 854, 12, 5, 14, 1, -15 },
  { 862, 7, 8, 11, 0, -7 },
  { 869, 24, 35, 18, -2, -35 },
  { 974, 21, 35, 22, 1, -35 },
  { 1066, 15, 34, 22, 5, -34 },
  { 1130, 23, 35, 22, -1, -35 },
  { 1231, 22, 35, 22, 0, -35 },
  { 1328, 23, 34, 22, -1, -34 },
  { 1426, 22, 34, 22, 0, -34 },
  { 1520, 21, 35, 22, 2, -35 },
  { 1612, 22, 34, 22, 2, -34 },
  { 1706, 22, 35, 22, 0, -35 },
  { 1803, 21, 35, 22, 1, -35 },
  { 1895, 11, 27, 12, 0, -26 },
  { 1933, 14, 32, 12, -3, -26 },
  { 1989, 20, 23, 23, 2, -29 },
  { 2047, 20, 14, 23, 2, -24 },
  { 2082, 20, 23, 23, 2, -29 },
  { 2140, 17, 35, 17, 2, -35 },
  { 2215, 32, 39, 33, 1, -35 },
  { 2371, 24, 34, 24, -3, -34 },
  { 2473, 24, 34, 24, 0, -34 },
  { 2575, 24, 35, 23, 2, -35 },
  { 2680, 26, 34, 26, 0, -34 },
  { 2791, 23, 34, 21, 0, -34 },
  { 2889, 23, 34, 20, 0, -34 },
  { 2987, 26, 35, 27, 2, -35 },
  { 3101, 28, 34, 27, 0, -34 },
  { 3220, 20, 34, 15, -2, -34 },
  { 3305, 20, 44, 12, -7, -34 },
  { 3415, 28, 34, 23, 0, -34 },
  { 3534, 17, 34, 20, 0, -34 },
  { 3607, 36, 34, 35, 0, -34 },
  { 3760, 30, 34, 29, 0, -34 },
  { 3888, 25, 35, 28, 2, -35 },
  { 3998, 24, 34, 23, 0, -34 },
  { 4100, 25, 43, 28, 2, -35 },
  { 4235, 24, 34, 24, 0, -34 },
  { 4337, 23, 35, 21, 0, -35 },
  { 4438, 20, 34, 20, 4, -34 },
  { 4523, 26, 34, 27, 2, -34 },
  { 4634, 23, 34, 23, 4, -34 },
  { 4732, 36, 34, 36, 4, -34 },
  { 4885, 29, 34, 22, -3, -34 },
  { 5009, 22, 34, 21, 4, -34 },
  { 5103, 25, 34, 20, -2, -34 },
  { 5210, 18, 42, 14, -1, -34 },
  { 5305, 9, 35, 18, 5, -35 },
  { 5345, 19, 42, 14, -3, -34 },
  { 5445, 22, 20, 22, 0, -34 },
  { 5500, 17, 3, 16, -4, 4 },
  { 5507, 8, 8, 14, 7, -37 },
  { 5515, 22, 27, 23, 1, -27 },
  { 5590, 22, 36, 23, 0, -36 },
  { 5689, 19, 27, 18, 1, -27 },
  { 5754, 24, 36, 23, 1, -36 },
  { 5862, 20, 26, 21, 1, -26 },
  { 5927, 25, 49, 14, -6, -37 },
  { 6081, 24, 39, 24, -1, -27 },
  { 6198, 22, 36, 23, 0, -36 },
  { 6297, 13, 36, 11, 0, -36 },
  { 6356, 19, 48, 11, -6, -36 },
  { 6470, 23, 36, 21, 0, -36 },
  { 6574, 13, 36, 11, 0, -36 },
  { 6633, 33, 27, 35, 0, -27 },
  { 6745, 22, 27, 23, 0, -27 },
  { 6820, 20, 27, 23, 1, -27 },
  { 6888, 24, 38, 23, -2, -27 },
  { 7002, 22, 39, 23, 1, -27 },
  { 7110, 18, 27, 16, 0, -27 },
  { 7171, 18, 27, 18, 0, -27 },
  { 7232, 14, 32, 15, 2, -32 },
  { 7288, 21, 26, 23, 2, -26 },
  { 7357, 19, 26, 20, 3, -26 },
  { 7419, 30, 26, 31, 3, -26 },
  { 7517, 24, 26, 20, -2, -26 },
  { 7595, 26, 38, 20, -4, -26 },
  { 7719, 19, 26, 17, -1, -26 },
  { 7781, 18, 42, 16, 1, -34 },
  { 7876, 4, 48, 20, 8, -37 },
  { 7900, 19, 42, 16, -3, -34 },
  { 8000, 20, 8, 23, 2, -21 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC48PT7B_H_
