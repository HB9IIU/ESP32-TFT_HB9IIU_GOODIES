#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1, 0x83,
  0x00, 0x00, 0x38, 0xF1, 0xC0, 0x73, 0xB9, 0x9D, 0xCC, 0xE6, 0x73, 0x33,
  0x98, 0x03, 0x38, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x66, 0x1F, 0xFC, 0xFF,
  0xE1, 0x98, 0x0C, 0xC0, 0xC6, 0x06, 0x71, 0xFF, 0xEF, 0xFF, 0x19, 0xC0,
  0xCC, 0x06, 0x60, 0x63, 0x03, 0x30, 0x00, 0x00, 0x80, 0x18, 0x07, 0xE0,
  0xFF, 0x1F, 0xE3, 0xB0, 0x3B, 0x03, 0xA0, 0x1E, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x05, 0xC0, 0x5C, 0x85, 0xCF, 0xFC, 0xFF, 0x87, 0xE0, 0x08, 0x01,
  0x80, 0x1E, 0x0E, 0x3E, 0x0C, 0x37, 0x18, 0x67, 0x38, 0x67, 0x30, 0x66,
  0x60, 0xE6, 0x60, 0xE6, 0xCE, 0xED, 0xDF, 0x7D, 0xB3, 0x7B, 0xB3, 0x03,
  0x73, 0x06, 0x63, 0x0E, 0x67, 0x0C, 0x66, 0x1C, 0x66, 0x18, 0x7C, 0x30,
  0x3C, 0x03, 0xC0, 0x3F, 0x03, 0xB8, 0x18, 0xC1, 0xCE, 0x0E, 0x70, 0x37,
  0x01, 0xF0, 0x0F, 0x01, 0xF9, 0xCF, 0xCE, 0xE7, 0x6E, 0x3F, 0x70, 0xF3,
  0x87, 0x9E, 0x7C, 0x7F, 0xE3, 0xF3, 0x80, 0x77, 0x76, 0x66, 0xE0, 0x07,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x06, 0x07, 0x07,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x0E,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x0E, 0x03, 0x84, 0xC3, 0xF3,
  0x7F, 0xC7, 0xF3, 0xE1, 0xD8, 0x67, 0x08, 0x80, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x39, 0xDC, 0xEE, 0x70, 0x7E, 0xFB, 0xF0, 0x7F, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0x07, 0x87, 0xF1, 0xDC, 0xE7, 0x70, 0xDC, 0x77, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8E, 0xC3, 0xB0, 0xEE, 0x73, 0xBC, 0xFE, 0x1F, 0x00,
  0x0E, 0x3C, 0xFB, 0xFE, 0xFB, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xE0, 0x03, 0xE0, 0xFF, 0x1E, 0xF0, 0x87, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFC, 0x7F, 0xCF, 0xFC, 0x0F, 0xC3, 0xFC, 0x77, 0x88,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x1E, 0x1F, 0x03, 0xF0, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF6, 0x3C, 0xFF, 0x1F, 0xC0, 0x00, 0xE0, 0x1C, 0x07,
  0x81, 0xF0, 0x7E, 0x0D, 0x83, 0x70, 0xEE, 0x19, 0xC6, 0x31, 0xC6, 0x71,
  0xCF, 0xFF, 0xFF, 0x80, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xF8, 0x3F, 0xC2, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xCC, 0x78, 0xFF, 0x0F, 0xE0,
  0x03, 0xE1, 0xFC, 0x78, 0x8E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x7C, 0xFF,
  0x9E, 0x7B, 0x87, 0x70, 0xEE, 0x19, 0xC7, 0x38, 0xE7, 0x38, 0x7F, 0x0F,
  0xC0, 0x3F, 0xF3, 0xFE, 0x7F, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0xF1, 0x87, 0x18, 0x71,
  0x8E, 0x1C, 0xE1, 0xFC, 0x0F, 0x01, 0xF8, 0x7B, 0xC7, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x7F, 0x9C,
  0x73, 0x8E, 0x71, 0xDC, 0x3B, 0x87, 0x39, 0xE7, 0xFC, 0xFB, 0x04, 0xE0,
  0x1C, 0x07, 0x00, 0xE4, 0x78, 0xFE, 0x1F, 0x80, 0x08, 0xF3, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0x80, 0x04, 0x1C, 0x78, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x0E, 0x18, 0x70, 0xC0, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x7C,
  0x3E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x1F, 0x3F, 0x9D, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x70, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x07, 0x38,
  0x03, 0x31, 0xF3, 0x63, 0xF3, 0x66, 0x33, 0xE6, 0x73, 0xCC, 0x63, 0xCC,
  0x66, 0xCC, 0x66, 0xCC, 0xE6, 0xCF, 0xFC, 0xCF, 0x78, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x20, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0xE6, 0x07, 0x30, 0x71, 0x83,
  0x8E, 0x3F, 0xF1, 0xFF, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3F, 0x81,
  0xC0, 0x0F, 0xC0, 0x7F, 0x87, 0xFC, 0x38, 0x71, 0xC3, 0x8E, 0x18, 0x71,
  0xC7, 0x3C, 0x3F, 0xC1, 0xFE, 0x0E, 0x38, 0x61, 0xC7, 0x0E, 0x38, 0x71,
  0xC3, 0x8E, 0x78, 0x7F, 0xC7, 0xF8, 0x00, 0x03, 0xF0, 0xFF, 0x1F, 0x71,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x98, 0x7F, 0x83, 0xF8, 0x0F, 0xC0,
  0x7F, 0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE7, 0x07, 0x38, 0x79, 0xC7, 0x8F, 0xF8,
  0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0xF8, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x03, 0xF0,
  0x7F, 0xC7, 0xFE, 0x38, 0x13, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF1,
  0xF7, 0x0F, 0xB8, 0xFD, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0xC3, 0x8F, 0x3C,
  0x7F, 0xE1, 0xFE, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE1,
  0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0,
  0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x60, 0xE1,
  0xC1, 0xC0, 0x0F, 0xE3, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0xFE, 0x1F, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xC1, 0xF8, 0x3E, 0x00, 0x0E,
  0x1C, 0x38, 0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0xE0, 0x77, 0x01, 0xBC, 0x0E,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0C, 0xE0, 0x73, 0x81, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0x61, 0xC3, 0x87, 0x80, 0x0E, 0x07, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0x7F, 0x7F, 0x80, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x36, 0x1F, 0x86, 0xC3, 0x71, 0xD8, 0xEC, 0x3B,
  0x1B, 0x87, 0x67, 0x70, 0xCC, 0xCE, 0x19, 0xB9, 0x87, 0x36, 0x70, 0xE6,
  0xCE, 0x1C, 0xF9, 0xC3, 0x1E, 0x38, 0x63, 0xC6, 0x1C, 0x71, 0xC0, 0x0E,
  0x07, 0x0F, 0x06, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x1B, 0x0C, 0x1B,
  0x8C, 0x3B, 0x9C, 0x3B, 0x9C, 0x39, 0x9C, 0x31, 0xD8, 0x31, 0xD8, 0x71,
  0xF8, 0x70, 0xF8, 0x70, 0xF8, 0x60, 0xF0, 0x60, 0xF0, 0xE0, 0xF0, 0x03,
  0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3, 0x8F,
  0x78, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x87, 0xFC, 0x38, 0xF1,
  0xC3, 0x8E, 0x1C, 0x71, 0xC7, 0x0E, 0x38, 0xF1, 0xFF, 0x0F, 0xF0, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03,
  0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3, 0x8F,
  0x78, 0x7F, 0x81, 0xF8, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0xC0, 0xFE, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8F, 0x3F,
  0xE3, 0xFC, 0x3F, 0x83, 0x38, 0x73, 0x87, 0x18, 0x71, 0xC7, 0x1C, 0x61,
  0xCE, 0x1E, 0x07, 0xE0, 0xFF, 0x1F, 0xE3, 0xC2, 0x38, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x38, 0x83,
  0x8E, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x00, 0x1C, 0x1C, 0x70, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x38, 0xE1, 0xC3, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x3D, 0xF0, 0x7F, 0x80, 0xFC, 0x00,
  0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38,
  0x63, 0x06, 0x70, 0x67, 0x06, 0xE0, 0x6E, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x3B, 0x87, 0x87, 0x70, 0xF1,
  0xCE, 0x3E, 0x39, 0xC7, 0xC7, 0x38, 0xF9, 0xC7, 0x3F, 0x38, 0xE6, 0xEE,
  0x1D, 0xDD, 0xC3, 0xB3, 0xB0, 0x76, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xB0,
  0x3E, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x00, 0x0E, 0x1C,
  0x38, 0x70, 0xE3, 0x83, 0x9C, 0x06, 0x70, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C,
  0x1C, 0x70, 0x70, 0xE3, 0x83, 0x80, 0xE0, 0xFC, 0x3D, 0x87, 0x39, 0xC7,
  0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x07, 0xC1, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x7C, 0x3F, 0x00, 0xC6, 0x31, 0xCE, 0x73, 0x8C, 0x63, 0x18,
  0xE7, 0x39, 0xC6, 0x31, 0xC0, 0x07, 0xC1, 0xF0, 0x9C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x7C, 0x3F, 0x00, 0x03, 0x00, 0x70,
  0x1E, 0x03, 0xC0, 0xD8, 0x3B, 0x86, 0x31, 0xC6, 0x30, 0xEC, 0x0F, 0x81,
  0x80, 0xFF, 0xFF, 0x80, 0xEE, 0x73, 0x0E, 0x63, 0xFC, 0xFF, 0xBC, 0xF7,
  0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x73, 0xCF, 0xF8,
  0xF6, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xDC, 0x1B,
  0xE3, 0xFE, 0x3C, 0xE3, 0x87, 0x38, 0x63, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x1C, 0x73, 0xCF, 0xF8, 0xEF, 0x00, 0x07, 0x0F, 0xCF, 0xEE, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x4F, 0xE3, 0xF0, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0xEE, 0x1F, 0xE3, 0xFE, 0x71,
  0xC7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x38, 0xE7,
  0x8F, 0xF8, 0x7B, 0x00, 0x07, 0x07, 0xE3, 0xFD, 0xC7, 0x71, 0xF8, 0xEF,
  0xF3, 0xF8, 0xE0, 0x30, 0x0E, 0x03, 0x84, 0xFF, 0x1F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x72, 0x03, 0x80, 0x38, 0x01, 0xF0, 0x3F, 0x81, 0xFC, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x02, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0x07, 0x30, 0xFF, 0x1F, 0xF3, 0x8F, 0x38, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0x7F, 0xC3, 0xD8,
  0x03, 0x80, 0x38, 0x03, 0x8C, 0xF0, 0xFE, 0x0F, 0xC0, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0xC0, 0x3B, 0x86, 0xF9, 0xFF, 0x3C, 0xE7, 0x1C, 0xE3,
  0x9C, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x61, 0xDC, 0x3B, 0x8E, 0x00,
  0x0C, 0x1C, 0x38, 0x40, 0x03, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7, 0x0E,
  0x1C, 0x38, 0x61, 0xC3, 0x80, 0x01, 0x80, 0x70, 0x1C, 0x04, 0x00, 0x00,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x0F, 0x83, 0xC0, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC7, 0x1C, 0xE1,
  0x9E, 0x39, 0xC3, 0xB8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07,
  0x38, 0x63, 0x8E, 0x38, 0xE1, 0xC0, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x80, 0x19,
  0xC7, 0x0D, 0xF7, 0xC7, 0xFF, 0xE7, 0x9E, 0x73, 0x8E, 0x39, 0xC7, 0x1C,
  0xC3, 0x8E, 0xE1, 0x87, 0x71, 0xC3, 0x38, 0xE3, 0x9C, 0x71, 0xCC, 0x38,
  0xEE, 0x18, 0x67, 0x1C, 0x70, 0x19, 0xC3, 0x7C, 0x7F, 0x9E, 0x73, 0x8E,
  0x71, 0xCE, 0x3B, 0x87, 0x70, 0xCE, 0x39, 0xC7, 0x30, 0xEE, 0x1D, 0xC7,
  0x00, 0x0F, 0x07, 0xE3, 0xFD, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xEE, 0x3B, 0x9C, 0xFF, 0x1F, 0x80, 0x0C, 0xE0, 0x6F, 0x83, 0xFC,
  0x3C, 0x61, 0xC3, 0x8E, 0x18, 0x61, 0xC7, 0x0E, 0x38, 0x71, 0xC3, 0x8E,
  0x38, 0x73, 0xC7, 0xFC, 0x3B, 0xC1, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x0E, 0x63, 0xFC, 0xFF, 0xB8, 0xE7, 0x1D, 0xC3,
  0xB8, 0x77, 0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x73, 0xCF, 0xF8, 0xF6, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x19, 0xC6, 0xE1, 0xF8,
  0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x00, 0x0F, 0x0F, 0xF3, 0xF8, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x72, 0x3C, 0xFE, 0x3F, 0x00, 0x0C, 0x30, 0x61, 0xFF,
  0xFF, 0xDC, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x7C, 0x78, 0x38,
  0xE6, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x98, 0x77, 0x0C, 0xE3, 0x9C,
  0x73, 0x8E, 0x73, 0xCF, 0xF0, 0xF6, 0x00, 0xE0, 0xFC, 0x39, 0x87, 0x31,
  0xC6, 0x38, 0xCE, 0x19, 0xC3, 0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xE0, 0x00, 0xC3, 0x8F, 0x8F, 0x1F, 0x1E, 0x36, 0x3C, 0xEC, 0xD9,
  0xD9, 0xB7, 0x37, 0x6E, 0x6D, 0xD8, 0xDB, 0xF1, 0xE7, 0xC3, 0xCF, 0x87,
  0x9F, 0x0E, 0x3C, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0xE3, 0x87, 0x38, 0x19,
  0xC0, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x0E, 0xE0,
  0x67, 0x07, 0x18, 0x70, 0xE0, 0x1C, 0x1C, 0x30, 0xE0, 0xC3, 0x83, 0x1C,
  0x0C, 0x70, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x02, 0xF0,
  0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0xF1, 0xFE, 0x00,
  0x01, 0xC0, 0xF0, 0x7C, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x0F,
  0x07, 0x83, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x07, 0x87, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x01, 0xE0,
  0xF0, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x1F, 0x0F, 0x07, 0x00,
  0x30, 0x3F, 0xCF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 9, 7, 10, 2, -18 },
  { 25, 13, 18, 13, 0, -18 },
  { 55, 12, 20, 11, 0, -19 },
  { 85, 16, 18, 18, 1, -18 },
  { 121, 13, 18, 14, 0, -18 },
  { 151, 4, 7, 6, 2, -18 },
  { 155, 8, 22, 7, 1, -18 },
  { 177, 8, 22, 7, -2, -18 },
  { 199, 10, 10, 11, 2, -19 },
  { 212, 11, 12, 12, 1, -15 },
  { 229, 5, 6, 6, -1, -3 },
  { 233, 7, 3, 7, 0, -8 },
  { 236, 4, 3, 6, 0, -3 },
  { 238, 12, 18, 9, -1, -18 },
  { 265, 10, 18, 11, 1, -18 },
  { 288, 7, 18, 11, 3, -18 },
  { 304, 12, 18, 11, -1, -18 },
  { 331, 11, 18, 11, 0, -18 },
  { 356, 11, 18, 11, 0, -18 },
  { 381, 12, 18, 11, 0, -18 },
  { 408, 11, 18, 11, 1, -18 },
  { 433, 12, 18, 11, 1, -18 },
  { 460, 12, 18, 11, 0, -18 },
  { 487, 11, 18, 11, 0, -18 },
  { 512, 6, 14, 6, 0, -14 },
  { 523, 7, 17, 6, -1, -14 },
  { 538, 11, 12, 12, 1, -15 },
  { 555, 11, 7, 12, 1, -12 },
  { 565, 11, 12, 12, 1, -15 },
  { 582, 9, 18, 9, 1, -18 },
  { 603, 16, 20, 17, 1, -18 },
  { 643, 13, 18, 12, -2, -18 },
  { 673, 13, 18, 13, 0, -18 },
  { 703, 12, 18, 12, 1, -18 },
  { 730, 13, 18, 14, 0, -18 },
  { 760, 12, 18, 11, 0, -18 },
  { 787, 12, 18, 10, 0, -18 },
  { 814, 13, 18, 14, 1, -18 },
  { 844, 15, 18, 14, 0, -18 },
  { 878, 11, 18, 8, -1, -18 },
  { 903, 11, 23, 6, -4, -18 },
  { 935, 14, 18, 12, 0, -18 },
  { 967, 9, 18, 10, 0, -18 },
  { 988, 19, 18, 18, 0, -18 },
  { 1031, 16, 18, 15, 0, -18 },
  { 1067, 13, 18, 15, 1, -18 },
  { 1097, 13, 18, 12, 0, -18 },
  { 1127, 13, 22, 15, 1, -18 },
  { 1163, 12, 18, 12, 0, -18 },
  { 1190, 12, 18, 11, 0, -18 },
  { 1217, 10, 18, 11, 2, -18 },
  { 1240, 14, 18, 14, 1, -18 },
  { 1272, 12, 18, 12, 2, -18 },
  { 1299, 19, 18, 19, 2, -18 },
  { 1342, 14, 18, 12, -1, -18 },
  { 1374, 11, 18, 11, 2, -18 },
  { 1399, 13, 18, 10, -1, -18 },
  { 1429, 10, 22, 7, -1, -18 },
  { 1457, 5, 18, 9, 3, -18 },
  { 1469, 10, 22, 7, -2, -18 },
  { 1497, 11, 11, 12, 0, -18 },
  { 1513, 9, 2, 9, -2, 2 },
  { 1516, 4, 4, 7, 4, -19 },
  { 1518, 11, 14, 12, 1, -14 },
  { 1538, 12, 19, 12, 0, -19 },
  { 1567, 9, 14, 10, 1, -14 },
  { 1583, 12, 19, 12, 1, -19 },
  { 1612, 10, 14, 11, 1, -14 },
  { 1630, 13, 25, 7, -3, -19 },
  { 1671, 12, 20, 12, 0, -14 },
  { 1701, 11, 19, 12, 0, -19 },
  { 1728, 7, 19, 6, 0, -19 },
  { 1745, 10, 25, 6, -3, -19 },
  { 1777, 12, 19, 11, 0, -19 },
  { 1806, 7, 19, 6, 0, -19 },
  { 1823, 17, 14, 18, 0, -14 },
  { 1853, 11, 14, 12, 0, -14 },
  { 1873, 10, 14, 12, 1, -14 },
  { 1891, 13, 20, 12, -1, -14 },
  { 1924, 11, 20, 12, 1, -14 },
  { 1952, 10, 14, 8, 0, -14 },
  { 1970, 10, 14, 9, 0, -14 },
  { 1988, 7, 17, 8, 1, -17 },
  { 2003, 11, 14, 12, 1, -14 },
  { 2023, 11, 14, 10, 1, -14 },
  { 2043, 15, 14, 16, 2, -14 },
  { 2070, 13, 14, 11, -1, -14 },
  { 2093, 14, 20, 10, -2, -14 },
  { 2128, 11, 14, 9, -1, -14 },
  { 2148, 10, 22, 9, 0, -18 },
  { 2176, 2, 25, 11, 4, -19 },
  { 2183, 9, 22, 9, -1, -18 },
  { 2208, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC25PT7B_H_
