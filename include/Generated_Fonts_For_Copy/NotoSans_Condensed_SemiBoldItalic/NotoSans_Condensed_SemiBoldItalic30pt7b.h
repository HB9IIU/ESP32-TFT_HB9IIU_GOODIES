#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xDC,
  0xE7, 0x39, 0xCE, 0xE3, 0x39, 0xCE, 0x70, 0x01, 0xCE, 0x01, 0x8E, 0x01,
  0x8C, 0x03, 0x8C, 0x03, 0x1C, 0x03, 0x18, 0x3F, 0xFF, 0x3F, 0xFF, 0x06,
  0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x18, 0xC0, 0x38, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x71, 0x80, 0x73,
  0x80, 0x00, 0x60, 0x01, 0x00, 0x04, 0x01, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1,
  0xC8, 0x87, 0x20, 0x1D, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x9C, 0x02, 0x72, 0x09, 0xCF, 0x7F, 0x3F, 0xF8,
  0xFF, 0xC0, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x87,
  0xE0, 0x60, 0xFC, 0x1C, 0x39, 0x87, 0x06, 0x30, 0xC1, 0xC6, 0x38, 0x39,
  0xC6, 0x06, 0x39, 0xC0, 0xC7, 0x70, 0x18, 0xCC, 0xF3, 0x3B, 0xBF, 0x7E,
  0x66, 0x6F, 0xDD, 0xCE, 0xE7, 0x31, 0xC0, 0xEE, 0x30, 0x39, 0xC6, 0x06,
  0x39, 0xC1, 0xC7, 0x38, 0x70, 0xC6, 0x0E, 0x1D, 0xC3, 0x83, 0xF0, 0xE0,
  0x3C, 0x00, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x38, 0x0F, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0x80,
  0x1F, 0x87, 0x3F, 0xCF, 0x79, 0xCE, 0x71, 0xFE, 0xF0, 0xFC, 0xF0, 0xFC,
  0xF0, 0xF8, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x3E, 0x7B, 0x9C,
  0xEE, 0x73, 0x80, 0x03, 0xC1, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x18, 0x73, 0x0F, 0xE7, 0xFF, 0xC7, 0xF8, 0xF0, 0x7F, 0x1E, 0x61,
  0x8E, 0x11, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x3C, 0xF3, 0x9E, 0x71, 0xCE, 0x38, 0x7F, 0x7F,
  0x7F, 0xFE, 0x77, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x3F, 0x03, 0xFC, 0x3C, 0xE1, 0xC7, 0x9E, 0x3C, 0xE1,
  0xEF, 0x0F, 0x70, 0x73, 0x83, 0xBC, 0x1D, 0xE0, 0xEF, 0x0F, 0x70, 0x7B,
  0x83, 0x9C, 0x3C, 0xE1, 0xE7, 0x0E, 0x38, 0xF1, 0xFF, 0x07, 0xF0, 0x1F,
  0x00, 0x07, 0xC3, 0xE1, 0xF8, 0xFE, 0xFF, 0x1D, 0xC4, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x79, 0xE0,
  0x41, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xE0,
  0x3F, 0xE1, 0xFF, 0x83, 0x9F, 0x08, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC8, 0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x06, 0xE0,
  0x3F, 0x01, 0xDC, 0x06, 0x70, 0x39, 0xC1, 0xCF, 0x0E, 0x38, 0x38, 0xE1,
  0xC3, 0x8E, 0x1E, 0x3F, 0xFE, 0xFF, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF2, 0x07, 0x8F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x1F, 0x11,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x7B, 0x83, 0xBF, 0x1F, 0xF9, 0xF1,
  0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDC, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0x71,
  0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83,
  0x8F, 0x1E, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x8E, 0x0E, 0x78, 0x3F, 0xC0,
  0x7C, 0x03, 0xF0, 0x3F, 0xE1, 0xE3, 0xC7, 0x07, 0x3C, 0x1C, 0xF0, 0x73,
  0xC1, 0xCF, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x01, 0xC0, 0x1F,
  0xC0, 0xFF, 0x87, 0xDE, 0x1C, 0x38, 0xF0, 0xE3, 0xC3, 0xCE, 0x0E, 0x38,
  0x38, 0xE1, 0xE3, 0x87, 0x8F, 0xFE, 0x3F, 0xF8, 0x7D, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00,
  0x04, 0x3C, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0x78, 0xF0, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x1E,
  0x0E, 0x0E, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x0F, 0x00, 0x60, 0x00, 0x07, 0x07, 0xF8, 0xFF, 0x98, 0xF0, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x78, 0x1C, 0x0E, 0x00, 0xE1,
  0xC0, 0x06, 0x18, 0x3C, 0x63, 0x8F, 0xE6, 0x31, 0xCE, 0x77, 0x38, 0xC6,
  0x63, 0x1C, 0x66, 0x71, 0xC6, 0xE7, 0x1C, 0xEE, 0x61, 0x8E, 0xC6, 0x38,
  0xCC, 0x63, 0x9C, 0xC7, 0x7F, 0x8C, 0x7D, 0xF0, 0xE1, 0x8E, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3B, 0x80, 0x77, 0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x3C, 0x1C, 0x78, 0x78,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8E, 0x0F, 0x3C, 0x1E, 0x70, 0x3D,
  0xE0, 0x7B, 0xC0, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3C, 0xF8,
  0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC7, 0x87, 0x8F, 0x0E, 0x1F, 0xF8, 0x3F,
  0xE0, 0xFF, 0xC1, 0xE3, 0xC3, 0x83, 0x87, 0x07, 0x8E, 0x0F, 0x3C, 0x1C,
  0x78, 0x78, 0xE1, 0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xF0,
  0x07, 0xFC, 0x1F, 0xF8, 0x7E, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x83, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F,
  0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x3C, 0x78, 0x3C,
  0x78, 0x78, 0x79, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0x07,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xCE, 0x1F, 0x02, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7E, 0x70, 0xFE,
  0xF0, 0xFC, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x38,
  0x78, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0x03, 0xC3, 0xC0,
  0xE0, 0xF0, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0x70,
  0x78, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xF0, 0x38, 0x3C,
  0x1E, 0x0E, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x1C, 0x1E, 0x0F,
  0x07, 0x03, 0xC1, 0xC0, 0xE0, 0xF0, 0x38, 0x00, 0x0F, 0xF0, 0xFF, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3E,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xC7, 0x80, 0xE3, 0xC0, 0x73,
  0xC0, 0x7B, 0xC0, 0x3D, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xDE, 0x01, 0xCF, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xF0,
  0x38, 0x78, 0x1C, 0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0xFD, 0xFF, 0xFF, 0xC0,
  0x07, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0x70, 0x7E, 0x0E, 0xE1, 0xDC, 0x1D,
  0xC3, 0xF8, 0x3B, 0x8E, 0xF0, 0xF7, 0x1D, 0xC1, 0xCE, 0x73, 0x83, 0x9C,
  0xE7, 0x07, 0x3B, 0x9E, 0x0E, 0x77, 0x3C, 0x3C, 0xFC, 0x70, 0x71, 0xF8,
  0xE0, 0xE3, 0xE1, 0xC1, 0xC7, 0xC7, 0x83, 0x8F, 0x0E, 0x0F, 0x0E, 0x1C,
  0x00, 0x07, 0x81, 0xE1, 0xF0, 0x38, 0x3E, 0x07, 0x07, 0xE0, 0xE0, 0xFC,
  0x3C, 0x1F, 0x87, 0x07, 0x70, 0xE0, 0xEE, 0x1C, 0x1C, 0xE3, 0x83, 0x9C,
  0xF0, 0xF3, 0x9C, 0x1C, 0x73, 0x83, 0x8F, 0x70, 0x70, 0xEE, 0x0E, 0x1F,
  0xC3, 0xC3, 0xF0, 0x70, 0x7E, 0x0E, 0x07, 0xC1, 0xC0, 0xF8, 0x38, 0x1E,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9E, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC7, 0x87,
  0x8F, 0x0F, 0x1C, 0x1E, 0x38, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x9E, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xF8, 0x1F,
  0xF8, 0x3D, 0xF0, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0x0E,
  0x1C, 0x3C, 0x39, 0xF0, 0xFF, 0xE1, 0xFF, 0x03, 0x9E, 0x07, 0x3C, 0x0E,
  0x38, 0x3C, 0x70, 0x78, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x8F, 0x07,
  0x80, 0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1E, 0x08, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x8C, 0x1E, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x1E, 0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C,
  0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78,
  0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0xE0, 0x3F, 0x80,
  0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0xE1,
  0xC3, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x70,
  0x3F, 0x83, 0xC0, 0xEE, 0x0F, 0x07, 0xB8, 0x3C, 0x1C, 0xE1, 0xF0, 0xF3,
  0x87, 0xC3, 0x8E, 0x3F, 0x0E, 0x38, 0xFC, 0x78, 0xE3, 0x71, 0xC3, 0x9D,
  0xCF, 0x0E, 0x77, 0x38, 0x3B, 0x9C, 0xE0, 0xEE, 0x77, 0x83, 0xB1, 0xDC,
  0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F,
  0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0xE1,
  0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x0E,
  0x03, 0xC3, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x00, 0xE0, 0x7F, 0x07, 0xBC,
  0x39, 0xE3, 0xCF, 0x1C, 0x39, 0xE1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x07, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E,
  0x0F, 0xE0, 0xFC, 0x00, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x70, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x39,
  0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x30, 0xE0, 0xE7, 0x03, 0xBC, 0x0F, 0xFF,
  0xFF, 0xFC, 0xF1, 0xE3, 0x8E, 0x1C, 0x02, 0x04, 0x3E, 0xE1, 0xFF, 0x8F,
  0xBE, 0x38, 0x79, 0xE1, 0xE7, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xCE,
  0x0F, 0x38, 0x38, 0xE1, 0xE3, 0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0x7D, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE2,
  0x07, 0xBE, 0x1D, 0xF8, 0x7C, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0xE0,
  0xF3, 0x83, 0xCE, 0x0E, 0x78, 0x39, 0xE1, 0xE7, 0x87, 0x1E, 0x3C, 0x7F,
  0xE3, 0xBF, 0x8E, 0x78, 0x00, 0x01, 0x01, 0xFC, 0x7F, 0x9F, 0x23, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE1,
  0x3F, 0xE3, 0xFC, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x8F, 0x07, 0xDC, 0x1F, 0xF8, 0x79, 0xF0,
  0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x1E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xE0,
  0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x8F, 0x0F, 0xFE, 0x0F, 0xD8, 0x1F, 0x70,
  0x00, 0x01, 0x00, 0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0x77, 0x87, 0x70, 0xEF,
  0x7E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF9, 0x87,
  0xF8, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00,
  0x01, 0x82, 0x0F, 0xB8, 0x3F, 0xF0, 0xFB, 0xE1, 0xC3, 0xC7, 0x87, 0x8E,
  0x0E, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0x87, 0x0F,
  0x0F, 0x3E, 0x1F, 0xFC, 0x3F, 0xF0, 0x3E, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x08, 0x3C, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE2, 0x07, 0xFE, 0x1D,
  0xF8, 0x7D, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x8E,
  0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xF3, 0xC3, 0x8F,
  0x0E, 0x00, 0x02, 0x07, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0xF0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x8F,
  0x1E, 0x1E, 0x38, 0x38, 0xE0, 0x73, 0xC0, 0xEF, 0x03, 0xFC, 0x07, 0x70,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xF3, 0x81, 0xC7, 0x03, 0x8F, 0x07,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0x00, 0x60, 0x40, 0xEF, 0xCF, 0x87, 0xFE,
  0xFC, 0x3E, 0xFF, 0xF1, 0xE3, 0xC7, 0x8E, 0x1E, 0x3C, 0xF0, 0xE1, 0xC7,
  0x07, 0x0E, 0x38, 0x78, 0x71, 0xC3, 0x87, 0x9E, 0x1C, 0x3C, 0xF0, 0xE1,
  0xC7, 0x0F, 0x0E, 0x38, 0x78, 0x71, 0xC3, 0x87, 0x9E, 0x1C, 0x3C, 0xF0,
  0xE1, 0xC0, 0x00, 0x20, 0x77, 0xE1, 0xDF, 0x87, 0xDF, 0x1E, 0x3C, 0x70,
  0xF3, 0xC3, 0x8F, 0x0E, 0x38, 0x38, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70,
  0x71, 0xC3, 0xC7, 0x0F, 0x3C, 0x38, 0xF0, 0xE0, 0x01, 0x00, 0xFE, 0x1F,
  0xE3, 0xCF, 0x38, 0x77, 0x87, 0x70, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE1, 0xEF, 0x1E, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x10,
  0x1C, 0xF8, 0x3B, 0xF0, 0x7C, 0xF0, 0xF1, 0xE1, 0xC3, 0xC7, 0x87, 0x8E,
  0x0F, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0x87, 0x8F,
  0x0F, 0xFC, 0x3F, 0xF8, 0x7B, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x04, 0x3E, 0xE1, 0xFF,
  0x8F, 0x3E, 0x38, 0x79, 0xE1, 0xE7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0xC3,
  0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0x7D,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x63, 0xBC, 0x77, 0x8F, 0xF1, 0xF0, 0x3C, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x00, 0x02, 0x01, 0xFC, 0x7F, 0x9E, 0x33, 0x80, 0x70, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3D, 0x07, 0x3F, 0xE7, 0xF8, 0xFE,
  0x00, 0x0E, 0x07, 0x03, 0x03, 0x87, 0xFB, 0xFE, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x7E, 0x3F, 0x0F, 0x80,
  0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x39, 0xC1, 0xCE,
  0x1E, 0x70, 0xF7, 0x87, 0x3C, 0x39, 0xC3, 0xCE, 0x3E, 0x7F, 0xE3, 0xFF,
  0x0F, 0xB8, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7,
  0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x07, 0x00, 0xE1, 0xE1, 0xFC, 0x3C, 0x3B, 0x8F, 0x8F, 0x71, 0xF1, 0xCE,
  0x7E, 0x79, 0xCF, 0xCE, 0x39, 0xB9, 0xC7, 0x77, 0x70, 0xEE, 0xEE, 0x1F,
  0x9F, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x7B, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xEE, 0x03, 0xDE, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x78, 0x0E, 0x0F,
  0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x78,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0xFC, 0xFF, 0xCF, 0xF8, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E,
  0x07, 0xC0, 0x70, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0xC0, 0xF8,
  0x0C, 0x00, 0x3C, 0x0B, 0xF8, 0xFF, 0xFF, 0x87, 0xF8, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 21, 8, 0, -21 },
  { 22, 10, 7, 12, 3, -21 },
  { 31, 16, 21, 15, 0, -21 },
  { 73, 14, 25, 14, 0, -23 },
  { 117, 19, 22, 22, 2, -22 },
  { 170, 16, 22, 16, 0, -22 },
  { 214, 5, 7, 7, 3, -21 },
  { 219, 10, 26, 8, 1, -21 },
  { 252, 10, 27, 8, -2, -22 },
  { 286, 11, 12, 13, 3, -23 },
  { 303, 13, 15, 15, 1, -18 },
  { 328, 6, 8, 7, -1, -4 },
  { 334, 8, 4, 9, 0, -10 },
  { 338, 5, 4, 7, 0, -4 },
  { 341, 16, 22, 11, -2, -22 },
  { 385, 13, 22, 14, 1, -22 },
  { 421, 10, 21, 14, 3, -21 },
  { 448, 15, 22, 14, -1, -22 },
  { 490, 14, 22, 14, 0, -22 },
  { 529, 14, 22, 14, 0, -22 },
  { 568, 14, 21, 14, 0, -21 },
  { 605, 13, 22, 14, 1, -22 },
  { 641, 14, 21, 14, 1, -21 },
  { 678, 14, 22, 14, 0, -22 },
  { 717, 14, 22, 14, 0, -22 },
  { 756, 7, 17, 7, 0, -17 },
  { 771, 9, 21, 7, -2, -17 },
  { 795, 13, 14, 15, 1, -18 },
  { 818, 13, 9, 15, 1, -15 },
  { 833, 13, 14, 15, 1, -18 },
  { 856, 11, 22, 11, 1, -22 },
  { 887, 20, 25, 21, 1, -22 },
  { 950, 15, 21, 15, -2, -21 },
  { 990, 15, 21, 15, 0, -21 },
  { 1030, 15, 22, 14, 1, -22 },
  { 1072, 16, 21, 16, 0, -21 },
  { 1114, 14, 21, 13, 0, -21 },
  { 1151, 14, 21, 12, 0, -21 },
  { 1188, 16, 22, 17, 1, -22 },
  { 1232, 18, 21, 17, 0, -21 },
  { 1280, 12, 21, 9, -1, -21 },
  { 1312, 13, 27, 8, -5, -21 },
  { 1356, 17, 21, 15, 0, -21 },
  { 1401, 10, 21, 12, 0, -21 },
  { 1428, 23, 21, 22, 0, -21 },
  { 1489, 19, 21, 18, 0, -21 },
  { 1539, 16, 22, 18, 1, -22 },
  { 1583, 15, 21, 15, 0, -21 },
  { 1623, 16, 27, 18, 1, -22 },
  { 1677, 15, 21, 15, 0, -21 },
  { 1717, 14, 22, 13, 0, -22 },
  { 1756, 13, 21, 13, 2, -21 },
  { 1791, 16, 21, 17, 1, -21 },
  { 1833, 14, 21, 14, 3, -21 },
  { 1870, 22, 21, 22, 3, -21 },
  { 1928, 18, 21, 14, -2, -21 },
  { 1976, 13, 21, 13, 3, -21 },
  { 2011, 15, 21, 13, -1, -21 },
  { 2051, 12, 27, 9, -1, -22 },
  { 2092, 6, 22, 11, 3, -22 },
  { 2109, 12, 27, 9, -2, -22 },
  { 2150, 14, 12, 14, 0, -21 },
  { 2171, 11, 2, 10, -3, 3 },
  { 2174, 6, 5, 9, 4, -23 },
  { 2178, 14, 17, 15, 1, -17 },
  { 2208, 14, 23, 15, 0, -23 },
  { 2249, 11, 17, 12, 1, -17 },
  { 2273, 15, 23, 15, 1, -23 },
  { 2317, 12, 17, 13, 1, -17 },
  { 2343, 15, 30, 9, -3, -23 },
  { 2400, 15, 24, 15, 0, -17 },
  { 2445, 14, 23, 15, 0, -23 },
  { 2486, 8, 23, 7, 0, -23 },
  { 2509, 12, 30, 7, -4, -23 },
  { 2554, 15, 23, 13, 0, -23 },
  { 2598, 8, 23, 7, 0, -23 },
  { 2621, 21, 17, 22, 0, -17 },
  { 2666, 14, 17, 15, 0, -17 },
  { 2696, 12, 17, 14, 1, -17 },
  { 2722, 15, 24, 15, -1, -17 },
  { 2767, 14, 24, 15, 1, -17 },
  { 2809, 11, 17, 10, 0, -17 },
  { 2833, 11, 17, 11, 0, -17 },
  { 2857, 9, 20, 9, 1, -20 },
  { 2880, 13, 16, 15, 1, -16 },
  { 2906, 12, 16, 12, 2, -16 },
  { 2930, 19, 16, 19, 2, -16 },
  { 2968, 15, 16, 13, -1, -16 },
  { 2998, 16, 23, 12, -2, -16 },
  { 3044, 12, 16, 11, -1, -16 },
  { 3068, 12, 26, 10, 0, -21 },
  { 3107, 3, 30, 13, 5, -23 },
  { 3119, 12, 26, 10, -2, -21 },
  { 3158, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC30PT7B_H_
