#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x62, 0x31, 0x80, 0x06, 0x30, 0xDE, 0xA5, 0x60, 0x09,
  0x0D, 0x84, 0xAF, 0xE1, 0x61, 0xA3, 0xFD, 0xFC, 0x68, 0x24, 0x16, 0x00,
  0x04, 0x3C, 0xF9, 0x46, 0x87, 0x07, 0x0E, 0x15, 0xBB, 0xE1, 0x02, 0x00,
  0x20, 0x1C, 0x6D, 0xB3, 0x48, 0x96, 0x2D, 0x7E, 0xBD, 0x69, 0x12, 0xCD,
  0xB2, 0x69, 0x8C, 0x0C, 0x0F, 0x0D, 0x86, 0xC3, 0x40, 0xC0, 0xE6, 0xDE,
  0xCF, 0x67, 0x33, 0x8F, 0xE0, 0xFA, 0x1C, 0x43, 0x08, 0x61, 0x84, 0x30,
  0xC3, 0x0C, 0x10, 0x41, 0x80, 0x10, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0x8C,
  0x46, 0x22, 0x00, 0x18, 0xA3, 0xF1, 0xB7, 0x89, 0x80, 0x30, 0xC3, 0x3F,
  0x30, 0xC3, 0x00, 0x36, 0x6C, 0xFF, 0xF0, 0x03, 0x03, 0x06, 0x06, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x3C, 0xD9, 0x36, 0x6C,
  0xD9, 0xA3, 0xC5, 0x99, 0xE3, 0xC0, 0x3B, 0xBD, 0x63, 0x11, 0x8C, 0x63,
  0x30, 0x08, 0x7C, 0x98, 0x30, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0xF7, 0xE0,
  0x0C, 0x7C, 0x98, 0x30, 0x67, 0x8F, 0x06, 0x04, 0x1A, 0x77, 0xC0, 0x06,
  0x1C, 0x78, 0xA2, 0x4D, 0x93, 0x7F, 0xFE, 0x30, 0x60, 0x3E, 0x60, 0xC1,
  0x07, 0xC9, 0x81, 0x82, 0x0D, 0xBB, 0xE0, 0x0E, 0x79, 0xC3, 0x0C, 0x1F,
  0x33, 0x66, 0x8D, 0x33, 0x67, 0x80, 0x7E, 0x08, 0x30, 0x41, 0x86, 0x0C,
  0x30, 0x61, 0x83, 0x00, 0x0C, 0x7C, 0xC9, 0x13, 0x67, 0x8F, 0x36, 0xC7,
  0x8B, 0x33, 0xC0, 0x08, 0x7C, 0xDB, 0x36, 0x6C, 0xDF, 0x9B, 0x0C, 0x1A,
  0xE7, 0x80, 0x37, 0x20, 0x00, 0x0C, 0xC0, 0x19, 0xC4, 0x00, 0x00, 0x06,
  0x62, 0x30, 0x04, 0x33, 0xF8, 0xC1, 0xC1, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x07, 0x07, 0x0C, 0xEE, 0x20, 0x37, 0xE2, 0x11, 0x99, 0x88, 0xC0,
  0x31, 0x80, 0x01, 0x01, 0xF8, 0x61, 0x98, 0x56, 0x72, 0x92, 0x56, 0x5A,
  0xDA, 0x52, 0x5B, 0xF1, 0x00, 0x30, 0x03, 0xE0, 0x07, 0x0F, 0x0F, 0x1B,
  0x1B, 0x13, 0x3F, 0x3F, 0x63, 0x63, 0xC3, 0x3F, 0x33, 0x33, 0x33, 0x3E,
  0x7E, 0x66, 0x66, 0x46, 0xFE, 0xF8, 0x0C, 0x3F, 0x72, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xF8, 0x78, 0x3F, 0x19, 0x8C, 0xC6, 0x32, 0x33,
  0x19, 0x8C, 0xC6, 0x66, 0x7E, 0x3E, 0x00, 0x3F, 0x30, 0x30, 0x30, 0x3C,
  0x7C, 0x60, 0x60, 0x60, 0xFC, 0xF8, 0x3F, 0x30, 0x30, 0x30, 0x20, 0x7C,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0x0E, 0x3F, 0x71, 0x60, 0xC0, 0xC1, 0xCE,
  0xC6, 0xC6, 0xC6, 0xEC, 0x7C, 0x31, 0x98, 0xCC, 0x66, 0x33, 0xF3, 0xF9,
  0x8C, 0xC6, 0x63, 0x63, 0x31, 0x80, 0x1E, 0x10, 0x60, 0xC1, 0x83, 0x04,
  0x18, 0x30, 0x63, 0xE0, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0xC3,
  0x0C, 0xF3, 0x80, 0x33, 0x99, 0x8D, 0x87, 0x82, 0xC3, 0xC1, 0xB0, 0xD8,
  0x4C, 0x62, 0x31, 0x80, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x43, 0xFF,
  0x80, 0x38, 0x73, 0x87, 0x38, 0xE2, 0x8A, 0x29, 0xE6, 0x96, 0x6B, 0x66,
  0xA4, 0x4E, 0xCC, 0xCC, 0xCC, 0xC0, 0x38, 0xCE, 0x33, 0x88, 0xB6, 0x2D,
  0x9B, 0x66, 0xD9, 0x94, 0x47, 0x31, 0xCC, 0x70, 0x0C, 0x3E, 0x73, 0x63,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x78, 0x3F, 0x33, 0x33, 0x33,
  0x23, 0x7E, 0x7C, 0x60, 0x60, 0xC0, 0xC0, 0x0C, 0x3E, 0x73, 0x63, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x78, 0x18, 0x18, 0x0C, 0x3E, 0x33,
  0x33, 0x33, 0x26, 0x7E, 0x6C, 0x6C, 0x4C, 0xC4, 0xC6, 0x0C, 0x3F, 0x32,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0xFC, 0xF8, 0xFE, 0x60, 0xC1,
  0x83, 0x04, 0x18, 0x30, 0x60, 0xC3, 0x00, 0x63, 0x63, 0x63, 0x62, 0xC6,
  0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0xC3, 0xC6, 0x46, 0x4C, 0x4C, 0x48,
  0x58, 0x50, 0x70, 0x70, 0x60, 0xC6, 0x3C, 0x62, 0xCE, 0x6C, 0xA6, 0xCA,
  0xCD, 0xAC, 0xD2, 0x8F, 0x38, 0xE3, 0x8E, 0x30, 0xE7, 0x00, 0x19, 0xC6,
  0xC1, 0xB0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0xD8, 0x36, 0x19, 0x8C, 0x60,
  0xC7, 0x6C, 0x6C, 0x78, 0x78, 0x70, 0x20, 0x60, 0x60, 0x60, 0x60, 0x1F,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x3F, 0x3F, 0x00,
  0x3C, 0xC3, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xE3, 0x80, 0x93,
  0x6D, 0xB2, 0x49, 0xB0, 0x1C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC3,
  0x0C, 0xE3, 0x80, 0x0C, 0x38, 0xD1, 0x26, 0x78, 0xC0, 0xF8, 0xEC, 0x1B,
  0x3F, 0x66, 0x66, 0x66, 0x46, 0xCC, 0x6C, 0x7C, 0x30, 0x60, 0xC1, 0xE3,
  0xEE, 0xD9, 0xB3, 0x66, 0xCF, 0xB7, 0xC0, 0x1E, 0x79, 0x83, 0x06, 0x08,
  0x30, 0x34, 0x78, 0x01, 0x81, 0x80, 0xC3, 0x63, 0xF3, 0x31, 0x98, 0xCC,
  0x46, 0x62, 0x1B, 0x0E, 0x80, 0x1C, 0x7D, 0x9B, 0x37, 0xD8, 0x30, 0x32,
  0x7C, 0x07, 0x06, 0x0C, 0x0E, 0x1E, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0xE0, 0xE0, 0x1B, 0x3F, 0x66, 0x66, 0x66, 0x46, 0xCC,
  0x6C, 0x7C, 0x0C, 0x0C, 0xF8, 0xF0, 0x30, 0x60, 0xC1, 0xF3, 0xEE, 0xD9,
  0xB3, 0x66, 0x8B, 0x36, 0x60, 0x33, 0x03, 0x26, 0x66, 0x64, 0xCC, 0x0C,
  0x30, 0x03, 0x08, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xCE, 0x30, 0x10,
  0x30, 0x30, 0x33, 0x26, 0x6C, 0x78, 0x78, 0x78, 0x48, 0xCC, 0xCC, 0x13,
  0x33, 0x26, 0x66, 0x64, 0xCC, 0x2C, 0xC7, 0xFD, 0xD9, 0xB3, 0x36, 0x66,
  0xCC, 0x91, 0x36, 0x66, 0xCC, 0xC0, 0x2E, 0x7D, 0xDB, 0x36, 0x6C, 0xD1,
  0x66, 0xCC, 0x1C, 0x7D, 0x9B, 0x34, 0x78, 0xF1, 0x36, 0x78, 0x17, 0x1F,
  0x3B, 0x31, 0x33, 0x33, 0x33, 0x76, 0x7C, 0x60, 0x60, 0x40, 0xC0, 0x1B,
  0x3F, 0x66, 0x66, 0x66, 0x46, 0xCC, 0x6C, 0x7C, 0x0C, 0x0C, 0x08, 0x18,
  0x2C, 0xF7, 0x18, 0x61, 0x84, 0x30, 0xC0, 0x3D, 0xF6, 0x18, 0x30, 0x61,
  0xA6, 0xF0, 0x26, 0x7F, 0x4C, 0xCC, 0x8E, 0xE0, 0x66, 0x8B, 0x36, 0x6C,
  0xD9, 0xA6, 0x6C, 0xF8, 0xCF, 0x3C, 0xB6, 0xD3, 0xCE, 0x38, 0xE0, 0xCC,
  0xF3, 0x3D, 0x5B, 0x76, 0xFD, 0x3B, 0xCE, 0xE3, 0xB8, 0xCE, 0x00, 0x33,
  0x13, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x6C, 0xE6, 0x31, 0x33, 0x32, 0x36,
  0x34, 0x3C, 0x3C, 0x38, 0x18, 0x30, 0x30, 0xE0, 0xC0, 0x3E, 0x7C, 0x30,
  0x61, 0x86, 0x0C, 0x30, 0xFC, 0x0C, 0x61, 0x84, 0x30, 0xCC, 0x18, 0x21,
  0x86, 0x18, 0x70, 0x40, 0xFF, 0xFF, 0x18, 0x20, 0x86, 0x18, 0x60, 0xC6,
  0x30, 0xC3, 0x08, 0xE2, 0x00, 0xE7, 0xF8, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 6, 2, -11 },
  { 11, 9, 11, 8, 0, -11 },
  { 24, 7, 13, 7, 0, -12 },
  { 36, 10, 12, 11, 1, -12 },
  { 51, 9, 12, 9, 0, -12 },
  { 65, 2, 4, 4, 2, -11 },
  { 66, 6, 14, 5, 0, -11 },
  { 77, 5, 15, 5, -1, -12 },
  { 87, 7, 6, 7, 1, -12 },
  { 93, 6, 7, 8, 1, -9 },
  { 99, 4, 4, 4, -1, -2 },
  { 101, 4, 2, 5, 0, -5 },
  { 102, 2, 2, 4, 0, -2 },
  { 103, 8, 12, 6, -1, -12 },
  { 115, 7, 12, 7, 0, -12 },
  { 126, 5, 11, 7, 2, -11 },
  { 133, 7, 12, 7, 0, -12 },
  { 144, 7, 12, 7, 0, -12 },
  { 155, 7, 11, 7, 0, -11 },
  { 165, 7, 11, 7, 0, -11 },
  { 175, 7, 12, 7, 1, -12 },
  { 186, 7, 11, 7, 1, -11 },
  { 196, 7, 12, 7, 0, -12 },
  { 207, 7, 12, 7, 0, -12 },
  { 218, 4, 9, 4, 0, -9 },
  { 223, 5, 11, 4, -1, -9 },
  { 230, 6, 8, 8, 1, -10 },
  { 236, 6, 5, 8, 1, -8 },
  { 240, 6, 8, 8, 1, -10 },
  { 246, 5, 12, 6, 1, -12 },
  { 254, 11, 13, 11, 0, -12 },
  { 272, 8, 11, 8, -1, -11 },
  { 283, 8, 11, 8, 0, -11 },
  { 294, 8, 12, 8, 1, -12 },
  { 306, 9, 11, 9, 0, -11 },
  { 319, 8, 11, 7, 0, -11 },
  { 330, 8, 11, 7, 0, -11 },
  { 341, 8, 12, 9, 1, -12 },
  { 353, 9, 11, 9, 0, -11 },
  { 366, 7, 11, 5, -1, -11 },
  { 376, 6, 14, 4, -2, -11 },
  { 387, 9, 11, 8, 0, -11 },
  { 400, 6, 11, 7, 0, -11 },
  { 409, 12, 11, 12, 0, -11 },
  { 426, 10, 11, 10, 0, -11 },
  { 440, 8, 12, 9, 1, -12 },
  { 452, 8, 11, 8, 0, -11 },
  { 463, 8, 15, 9, 1, -12 },
  { 478, 8, 11, 8, 0, -11 },
  { 489, 8, 12, 7, 0, -12 },
  { 501, 7, 11, 7, 1, -11 },
  { 511, 8, 11, 9, 1, -11 },
  { 522, 8, 11, 8, 1, -11 },
  { 533, 12, 11, 12, 1, -11 },
  { 550, 10, 11, 7, -1, -11 },
  { 564, 8, 11, 7, 1, -11 },
  { 575, 9, 11, 7, -1, -11 },
  { 588, 6, 14, 5, 0, -11 },
  { 599, 3, 12, 6, 2, -12 },
  { 604, 6, 14, 5, -1, -11 },
  { 615, 7, 6, 7, 0, -11 },
  { 621, 5, 1, 5, -1, 1 },
  { 622, 3, 2, 5, 2, -12 },
  { 623, 8, 9, 8, 0, -9 },
  { 632, 7, 12, 8, 0, -12 },
  { 643, 7, 9, 6, 0, -9 },
  { 651, 9, 12, 8, 0, -12 },
  { 665, 7, 9, 7, 0, -9 },
  { 673, 8, 16, 5, -2, -12 },
  { 689, 8, 13, 8, 0, -9 },
  { 702, 7, 12, 8, 0, -12 },
  { 713, 4, 12, 4, 0, -12 },
  { 719, 6, 16, 4, -2, -12 },
  { 731, 8, 12, 7, 0, -12 },
  { 743, 4, 12, 4, 0, -12 },
  { 749, 11, 9, 12, 0, -9 },
  { 762, 7, 9, 8, 0, -9 },
  { 770, 7, 9, 8, 0, -9 },
  { 778, 8, 13, 8, -1, -9 },
  { 791, 8, 13, 8, 0, -9 },
  { 804, 6, 9, 5, 0, -9 },
  { 811, 6, 9, 6, 0, -9 },
  { 818, 4, 11, 5, 1, -11 },
  { 824, 7, 9, 8, 1, -9 },
  { 832, 6, 9, 7, 1, -9 },
  { 839, 10, 9, 10, 1, -9 },
  { 851, 8, 9, 7, -1, -9 },
  { 860, 8, 13, 7, -1, -9 },
  { 873, 7, 9, 6, -1, -9 },
  { 881, 6, 14, 5, 0, -11 },
  { 892, 1, 16, 7, 3, -12 },
  { 894, 6, 14, 5, -1, -11 },
  { 905, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC16PT7B_H_
