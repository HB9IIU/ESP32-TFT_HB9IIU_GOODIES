#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7F, 0xE0, 0x4D, 0x2C, 0xDF, 0x37, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0x56, 0x80, 0xB8, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40,
  0x76, 0xE0, 0xEA, 0xE5, 0x60, 0xE8, 0xE0, 0x6B, 0xA0, 0x78, 0xE0, 0x7A,
  0xE0, 0x69, 0x40, 0xEA, 0xE0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC,
  0x8F, 0x00, 0xDA, 0x7F, 0xF8, 0x60, 0x4B, 0xD0, 0x6E, 0xE0, 0x72, 0x60,
  0x76, 0xE0, 0x6A, 0x60, 0x7A, 0x40, 0x72, 0xF0, 0x56, 0xAA, 0x5A, 0x29,
  0x2C, 0x6B, 0x50, 0x6B, 0x5A, 0xBD, 0xA0, 0x5D, 0xAA, 0x76, 0xF0, 0x77,
  0x40, 0x76, 0xF2, 0x77, 0x50, 0xE9, 0x60, 0xE9, 0x40, 0x76, 0xF0, 0xFA,
  0xDE, 0xEC, 0x69, 0x60, 0xEA, 0x6A, 0x60, 0x6A, 0x80, 0xF0, 0x56, 0x80,
  0x54, 0xE0, 0x80, 0xF7, 0x00, 0x4A, 0xDC, 0xEC, 0x27, 0xDC, 0xFB, 0x00,
  0x25, 0x25, 0x80, 0xF7, 0x60, 0x4A, 0xDC, 0x4A, 0x80, 0x21, 0x25, 0x80,
  0x4B, 0xEC, 0x5A, 0x80, 0xFB, 0xD0, 0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x40,
  0xF7, 0x20, 0x68, 0xDC, 0x6A, 0xB7, 0x00, 0xBA, 0x00, 0xBE, 0xA0, 0xEB,
  0x00, 0xB9, 0x40, 0xEC, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 3, 3, 1, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 3, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 1, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 1, 0, -3 },
  { 44, 1, 4, 1, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 4, 5, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 2, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 4, 4, 3, 0, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 3, 5, 2, -1, -4 },
  { 73, 3, 4, 3, 0, -4 },
  { 75, 2, 4, 2, 0, -4 },
  { 76, 5, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 5, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 2, 4, 3, 1, -4 },
  { 96, 4, 4, 4, 1, -4 },
  { 98, 3, 4, 3, 0, -4 },
  { 100, 2, 4, 3, 1, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 2, 5, 2, 0, -4 },
  { 105, 1, 4, 2, 1, -4 },
  { 106, 2, 5, 2, 0, -4 },
  { 108, 3, 2, 3, 0, -4 },
  { 109, 3, 1, 2, -1, 0 },
  { 110, 1, 1, 2, 1, -5 },
  { 111, 3, 3, 3, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 2, 3, 2, 0, -3 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 6, 2, -1, -5 },
  { 123, 3, 4, 3, 0, -3 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 2, 5, 1, 0, -5 },
  { 129, 3, 6, 1, -1, -5 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 2, 5, 1, 0, -5 },
  { 136, 4, 3, 4, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 3, 4, 3, 0, -3 },
  { 146, 2, 3, 2, 0, -3 },
  { 147, 2, 3, 2, 0, -3 },
  { 148, 2, 4, 2, 0, -4 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 3, 2, 0, -3 },
  { 153, 4, 3, 4, 0, -3 },
  { 155, 3, 3, 3, 0, -3 },
  { 157, 3, 4, 2, 0, -3 },
  { 159, 2, 3, 2, 0, -3 },
  { 160, 2, 5, 2, 0, -4 },
  { 162, 1, 6, 3, 1, -5 },
  { 163, 2, 5, 2, 0, -4 },
  { 165, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC6PT7B_H_
