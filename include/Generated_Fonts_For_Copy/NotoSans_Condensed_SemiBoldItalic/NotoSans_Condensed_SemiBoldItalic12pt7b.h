#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0x82, 0xC0, 0x5D, 0xBA, 0x14, 0x52, 0x9F, 0x29, 0x2F,
  0xD4, 0xF0, 0x10, 0xF5, 0x18, 0x30, 0x62, 0xBC, 0x21, 0x00, 0x67, 0x4A,
  0xA5, 0x4F, 0x7D, 0x4A, 0xA5, 0xCC, 0x18, 0xA2, 0x8E, 0x31, 0x5D, 0xF6,
  0xFC, 0x5E, 0x12, 0x24, 0x44, 0xCC, 0xCC, 0x40, 0x31, 0x11, 0x11, 0x32,
  0x24, 0xC0, 0x27, 0x4F, 0xC5, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x6B, 0x00,
  0xE0, 0x70, 0x04, 0x10, 0x86, 0x10, 0xC2, 0x18, 0xC0, 0x19, 0xDA, 0x94,
  0xE7, 0x7A, 0x70, 0x17, 0xF2, 0x22, 0x66, 0x40, 0x33, 0xC2, 0x11, 0x99,
  0x98, 0xF0, 0x39, 0xE0, 0xC2, 0x30, 0x61, 0xA6, 0xF0, 0x0C, 0x61, 0x8A,
  0x59, 0x4F, 0x84, 0x30, 0x3C, 0xE6, 0x10, 0x78, 0x61, 0xA4, 0xF0, 0x0C,
  0xD6, 0x14, 0x7B, 0x2C, 0xB6, 0x70, 0x7D, 0xF0, 0x86, 0x10, 0xC2, 0x18,
  0xC0, 0x19, 0xB6, 0xDA, 0x31, 0x6C, 0xB6, 0x70, 0x33, 0xD2, 0x95, 0xB4,
  0x62, 0xE0, 0x2C, 0x01, 0xB0, 0x13, 0x00, 0x00, 0x64, 0x80, 0x1B, 0xB1,
  0xC3, 0x84, 0xF8, 0x3F, 0xF0, 0x87, 0x06, 0xEC, 0x40, 0x32, 0xC6, 0x22,
  0x20, 0x08, 0xC0, 0x0C, 0x33, 0x21, 0x5D, 0x55, 0xA5, 0xAE, 0x94, 0x40,
  0x3C, 0x0C, 0x31, 0x45, 0x34, 0xF7, 0xD1, 0xC4, 0x38, 0xF6, 0x5B, 0x71,
  0x24, 0xB2, 0xF0, 0x3B, 0xF1, 0x88, 0x42, 0x10, 0xF0, 0x30, 0xF6, 0x59,
  0x45, 0x14, 0xF6, 0xF0, 0x3C, 0xE6, 0x18, 0x79, 0x04, 0x30, 0xF0, 0x3C,
  0xE6, 0x18, 0x79, 0x04, 0x30, 0xC0, 0x19, 0xFC, 0x30, 0x9A, 0x68, 0xA6,
  0xF0, 0x22, 0x4D, 0x9B, 0x27, 0xC8, 0x93, 0x66, 0xC8, 0x79, 0x08, 0x46,
  0x31, 0x08, 0xE0, 0x08, 0x42, 0x31, 0x88, 0x46, 0x31, 0x38, 0x26, 0x49,
  0xA3, 0xC7, 0x0E, 0x14, 0x6C, 0xC8, 0x22, 0x66, 0x44, 0x4C, 0xF0, 0x31,
  0x98, 0xDC, 0xEE, 0x65, 0x52, 0xA9, 0x6D, 0xB6, 0x92, 0x00, 0x22, 0x65,
  0xCB, 0x95, 0x6B, 0x93, 0x66, 0x8C, 0x39, 0xFC, 0xE3, 0x8E, 0x38, 0xA6,
  0xF0, 0x38, 0xF6, 0x59, 0x4D, 0xC4, 0x30, 0xC0, 0x39, 0xFC, 0xE3, 0x8E,
  0x38, 0xA6, 0xF0, 0xC3, 0x00, 0x30, 0xF6, 0xDB, 0x79, 0xC5, 0x36, 0xC8,
  0x1D, 0xE6, 0x18, 0x30, 0x41, 0xA4, 0xF0, 0xFF, 0xD8, 0xC4, 0x21, 0x18,
  0xC0, 0x45, 0x3C, 0xF2, 0x8A, 0x69, 0xA4, 0xF0, 0x8E, 0x29, 0xA4, 0x93,
  0xCE, 0x38, 0xC0, 0x88, 0xCC, 0xA6, 0x53, 0x6A, 0xA5, 0x53, 0xB1, 0x98,
  0xCC, 0x00, 0x32, 0x2C, 0x50, 0xC1, 0x83, 0x0A, 0x34, 0xCC, 0x8E, 0xF4,
  0xE6, 0x21, 0x08, 0xC0, 0x7D, 0xE1, 0x84, 0x31, 0x84, 0x30, 0xF0, 0x32,
  0x64, 0x44, 0x4C, 0x88, 0xC0, 0x99, 0x24, 0x92, 0x60, 0x38, 0xC4, 0x21,
  0x08, 0xC4, 0x21, 0x38, 0x10, 0x8E, 0x94, 0xC4, 0xF0, 0x90, 0x35, 0xF4,
  0x92, 0xCB, 0x67, 0x80, 0x20, 0x87, 0x9E, 0x4D, 0x24, 0xB6, 0xB0, 0x13,
  0xD0, 0x8C, 0x61, 0xC0, 0x04, 0x13, 0xDF, 0x49, 0x2C, 0xB6, 0x78, 0x13,
  0x53, 0xEC, 0x61, 0xC0, 0x1C, 0x41, 0x8E, 0x30, 0x82, 0x08, 0x61, 0x04,
  0x30, 0x35, 0xF4, 0x92, 0xCB, 0x67, 0x84, 0xB3, 0x80, 0x21, 0x1E, 0xF4,
  0xA5, 0x3B, 0x98, 0x25, 0xB4, 0x96, 0xC0, 0x08, 0x46, 0x31, 0x08, 0x46,
  0x31, 0x09, 0x80, 0x20, 0x86, 0xDA, 0x51, 0xC5, 0x34, 0x98, 0x25, 0xB4,
  0x96, 0xC0, 0x5B, 0x7F, 0x49, 0x49, 0x4B, 0xDB, 0x92, 0x5B, 0xD2, 0x94,
  0xEE, 0x60, 0x13, 0xD3, 0x9C, 0xED, 0xC0, 0x2C, 0x78, 0x99, 0x22, 0x4D,
  0x96, 0x20, 0x41, 0x80, 0x35, 0xF4, 0x92, 0xCB, 0x67, 0x84, 0x10, 0xC0,
  0x7B, 0x98, 0x84, 0x63, 0x00, 0x3B, 0x90, 0xC3, 0x5B, 0x80, 0x23, 0x74,
  0x44, 0xC6, 0x6D, 0xB4, 0x92, 0x4B, 0x67, 0x00, 0x9C, 0xAD, 0x4E, 0x63,
  0x00, 0x93, 0x66, 0xD5, 0xAD, 0xDB, 0x26, 0x00, 0x26, 0x78, 0xE0, 0x83,
  0x8F, 0x32, 0x00, 0x26, 0x48, 0xB1, 0x43, 0x86, 0x0C, 0x10, 0x61, 0x80,
  0x7B, 0x8C, 0x44, 0x63, 0xC0, 0x09, 0xC8, 0x42, 0x61, 0x08, 0x42, 0x18,
  0xFF, 0xF0, 0x21, 0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xED, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 5, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 10, 5, 0, -9 },
  { 22, 7, 9, 9, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 2, 4, 3, 1, -9 },
  { 38, 4, 11, 3, 0, -9 },
  { 44, 4, 11, 3, -1, -9 },
  { 50, 5, 5, 5, 1, -9 },
  { 54, 5, 6, 6, 1, -7 },
  { 58, 3, 3, 3, -1, -1 },
  { 60, 3, 1, 3, 0, -4 },
  { 61, 2, 2, 3, 0, -2 },
  { 62, 6, 9, 4, -1, -9 },
  { 69, 5, 9, 5, 0, -9 },
  { 75, 4, 9, 6, 1, -9 },
  { 80, 5, 9, 5, 0, -9 },
  { 86, 6, 9, 5, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 6, 9, 5, 0, -9 },
  { 107, 6, 9, 5, 0, -9 },
  { 114, 6, 9, 5, 0, -9 },
  { 121, 6, 9, 5, 0, -9 },
  { 128, 5, 9, 5, 0, -9 },
  { 134, 3, 7, 3, 0, -7 },
  { 137, 4, 9, 3, -1, -7 },
  { 142, 5, 6, 6, 1, -7 },
  { 146, 5, 4, 6, 1, -6 },
  { 149, 5, 6, 6, 1, -7 },
  { 153, 5, 9, 4, 0, -9 },
  { 159, 8, 10, 8, 0, -9 },
  { 169, 6, 9, 6, -1, -9 },
  { 176, 6, 9, 6, 0, -9 },
  { 183, 5, 9, 6, 1, -9 },
  { 189, 6, 9, 7, 0, -9 },
  { 196, 6, 9, 5, 0, -9 },
  { 203, 6, 9, 5, 0, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 7, 9, 7, 0, -9 },
  { 225, 5, 9, 4, 0, -9 },
  { 231, 5, 11, 3, -2, -9 },
  { 238, 7, 9, 6, 0, -9 },
  { 246, 4, 9, 5, 0, -9 },
  { 251, 9, 9, 9, 0, -9 },
  { 262, 7, 9, 7, 0, -9 },
  { 270, 6, 9, 7, 1, -9 },
  { 277, 6, 9, 6, 0, -9 },
  { 284, 6, 11, 7, 1, -9 },
  { 293, 6, 9, 6, 0, -9 },
  { 300, 6, 9, 5, 0, -9 },
  { 307, 5, 9, 5, 1, -9 },
  { 313, 6, 9, 7, 1, -9 },
  { 320, 6, 9, 6, 1, -9 },
  { 327, 9, 9, 9, 1, -9 },
  { 338, 7, 9, 6, -1, -9 },
  { 346, 5, 9, 5, 1, -9 },
  { 352, 6, 9, 5, 0, -9 },
  { 359, 4, 11, 4, 0, -9 },
  { 365, 3, 9, 4, 1, -9 },
  { 369, 5, 11, 4, -1, -9 },
  { 376, 5, 6, 6, 0, -9 },
  { 380, 4, 1, 4, -1, 1 },
  { 381, 2, 2, 3, 2, -9 },
  { 382, 6, 7, 6, 0, -7 },
  { 388, 6, 9, 6, 0, -9 },
  { 395, 5, 7, 5, 0, -7 },
  { 400, 6, 9, 6, 0, -9 },
  { 407, 5, 7, 5, 0, -7 },
  { 412, 6, 12, 3, -1, -9 },
  { 421, 6, 10, 6, 0, -7 },
  { 429, 5, 9, 6, 0, -9 },
  { 435, 3, 9, 3, 0, -9 },
  { 439, 5, 12, 3, -2, -9 },
  { 447, 6, 9, 5, 0, -9 },
  { 454, 3, 9, 3, 0, -9 },
  { 458, 8, 7, 9, 0, -7 },
  { 465, 5, 7, 6, 0, -7 },
  { 470, 5, 7, 6, 0, -7 },
  { 475, 7, 10, 6, -1, -7 },
  { 484, 6, 10, 6, 0, -7 },
  { 492, 5, 7, 4, 0, -7 },
  { 497, 5, 7, 5, 0, -7 },
  { 502, 4, 8, 4, 0, -8 },
  { 506, 6, 7, 6, 0, -7 },
  { 512, 5, 7, 5, 1, -7 },
  { 517, 7, 7, 8, 1, -7 },
  { 524, 7, 7, 5, -1, -7 },
  { 531, 7, 10, 5, -1, -7 },
  { 540, 5, 7, 4, 0, -7 },
  { 545, 5, 11, 4, 0, -9 },
  { 552, 1, 12, 5, 2, -9 },
  { 554, 5, 11, 4, -1, -9 },
  { 561, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC12PT7B_H_
