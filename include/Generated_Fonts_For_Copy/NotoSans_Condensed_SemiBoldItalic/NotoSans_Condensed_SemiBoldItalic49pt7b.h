#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xC0, 0x0C, 0x00, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xCC, 0x30, 0x1F, 0x18, 0x00, 0x3E, 0x30, 0x00, 0x7C,
  0xE0, 0x00, 0xF9, 0x80, 0x01, 0xFB, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x19, 0xF8, 0x00, 0x33, 0xF0,
  0x00, 0x67, 0xE0, 0x01, 0xCF, 0xC2, 0x03, 0x9F, 0x86, 0x06, 0x3E, 0x0F,
  0x0D, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x1F,
  0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x0F, 0x00, 0xFB, 0xE0, 0x3E, 0x03, 0xE7,
  0xC0, 0x78, 0x07, 0x87, 0x81, 0xE0, 0x1F, 0x0F, 0x07, 0xC0, 0x3C, 0x3E,
  0x0F, 0x00, 0x78, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x78, 0x03, 0xC1, 0xE1,
  0xE0, 0x07, 0x83, 0xC7, 0xC0, 0x0F, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x3E,
  0x08, 0x3C, 0x3C, 0x78, 0xFE, 0x78, 0xF9, 0xE3, 0xFE, 0xF1, 0xE7, 0xCF,
  0xFD, 0xF7, 0xCF, 0x3F, 0xFB, 0xFF, 0x3E, 0x78, 0xFB, 0xFC, 0x79, 0xF1,
  0xF3, 0xF1, 0xE3, 0xC3, 0xE0, 0x07, 0xC7, 0x87, 0xC0, 0x0F, 0x1F, 0x0F,
  0x00, 0x3E, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x3C, 0x01, 0xF0, 0xF0, 0x78,
  0x03, 0xC1, 0xE1, 0xF0, 0x0F, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x87, 0x80,
  0x78, 0x1F, 0x1F, 0x01, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x3F, 0xF8, 0x0F,
  0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xF0, 0x7F, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3E, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xE7, 0xE3, 0xE1,
  0xF9, 0xF1, 0xF8, 0x3F, 0xFC, 0x7C, 0x0F, 0xFE, 0x1F, 0x01, 0xFF, 0x0F,
  0xC0, 0x7F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x83, 0xFE,
  0x07, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x1F, 0x80, 0xFF, 0x87, 0xF0, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x61, 0xF0, 0x1F, 0x3C, 0x03, 0xFF, 0x83, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xF9, 0xE0, 0x7E, 0x3E, 0x03, 0xC7, 0xE0, 0x30,
  0x7C, 0x04, 0x0E, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x00,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x7D, 0xFF, 0xFF,
  0xFF, 0xDF, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xBF, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0x9F,
  0x80, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFE,
  0xFC, 0xF9, 0xF1, 0xE3, 0xE1, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3C, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0x40,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x06, 0x03, 0xF0,
  0x10, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x80, 0x0F, 0xE3, 0x00, 0x7F, 0x0F, 0x8F, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x3D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0x9F, 0x80, 0x1F, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0,
  0x1E, 0x0F, 0xC0, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0xFC, 0x0F,
  0x01, 0xF8, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x10, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x08, 0x00, 0xFE,
  0x18, 0x03, 0xF8, 0x3F, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x08, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF9, 0xFC, 0x0F, 0xDF, 0xF0,
  0x7D, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xE3, 0xF1, 0xFE, 0x0F, 0xCF, 0xE0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7,
  0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x0F,
  0xC3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x0F,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x1F, 0x80,
  0x7E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x7E, 0x01, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFB, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0x03, 0xF1,
  0xF8, 0x3F, 0x8F, 0xE7, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFD,
  0xF0, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x1C, 0x7F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF1, 0xE3, 0xF8, 0xC0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0xFC, 0x1E, 0x1F, 0x03, 0xFF, 0x1E, 0x1E,
  0x0F, 0xFF, 0x0E, 0x3E, 0x1F, 0xFE, 0x0F, 0x3C, 0x1E, 0x1E, 0x0E, 0x7C,
  0x3C, 0x1E, 0x1E, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x3E, 0x1E, 0x78,
  0x78, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C, 0x1C, 0xF0,
  0xF0, 0x7C, 0x3C, 0xF0, 0xF0, 0x78, 0x3C, 0xF0, 0xF0, 0x78, 0x38, 0xF1,
  0xF0, 0xF8, 0x78, 0xF0, 0xF0, 0xF8, 0xF0, 0xE0, 0xF1, 0xF8, 0xF0, 0xE0,
  0xFF, 0xBF, 0xE0, 0xF0, 0xFF, 0x3F, 0xC0, 0xF0, 0x7E, 0x1F, 0x80, 0xF0,
  0x08, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x1F, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x0C, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x0F, 0x83, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x30, 0x1F, 0xC0, 0x04, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0xFF, 0xC7, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xF8, 0xFC,
  0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xF0, 0x1F, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x10, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE3, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x0F,
  0x9F, 0x00, 0xFB, 0xE0, 0x7D, 0xF8, 0x0F, 0xDF, 0x07, 0xCF, 0xC0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x03, 0xE3, 0xC3, 0xE3, 0xE0, 0x1F, 0x1E, 0x1F, 0x3F,
  0x01, 0xF8, 0xF1, 0xF1, 0xF8, 0x0F, 0xC7, 0x8F, 0x8F, 0x80, 0x7C, 0x3C,
  0xF8, 0x7C, 0x03, 0xE1, 0xE7, 0xC3, 0xE0, 0x1F, 0x0F, 0x3C, 0x3F, 0x01,
  0xF8, 0x7F, 0xE1, 0xF8, 0x0F, 0x83, 0xFE, 0x0F, 0x80, 0x7C, 0x1F, 0xF0,
  0x7C, 0x03, 0xE0, 0xFF, 0x03, 0xE0, 0x1F, 0x07, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x81, 0xF8, 0x0F, 0x81, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xE0, 0x7C,
  0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x0F, 0xF0,
  0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0xFF, 0xC0,
  0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x01, 0xF8, 0x07, 0xFE, 0x03,
  0xF0, 0x0F, 0xFE, 0x07, 0xC0, 0x3E, 0x7C, 0x0F, 0x80, 0x7C, 0xF8, 0x1F,
  0x00, 0xF9, 0xF0, 0x7E, 0x01, 0xF3, 0xE0, 0xF8, 0x03, 0xE7, 0xE1, 0xF0,
  0x0F, 0xC7, 0xC3, 0xE0, 0x1F, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x1F, 0x80,
  0x7C, 0x3F, 0x3E, 0x01, 0xF8, 0x3E, 0x7C, 0x03, 0xE0, 0x7C, 0xF8, 0x07,
  0xC0, 0xF9, 0xF0, 0x0F, 0x81, 0xF7, 0xE0, 0x1F, 0x03, 0xFF, 0x80, 0x7E,
  0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0xC0, 0x3E, 0x00,
  0x7F, 0x80, 0x7C, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x80,
  0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFE, 0x07, 0xC1, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x07, 0x01, 0xF8, 0x02, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x08, 0x00, 0xFC, 0x1C, 0x07, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00,
  0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0x7E, 0x7E, 0x01, 0xFC, 0x03,
  0xE3, 0xF0, 0x1F, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0x01, 0xF0, 0xFC, 0x07,
  0xF8, 0x1F, 0x87, 0xE0, 0x7F, 0xC0, 0xFC, 0x3F, 0x03, 0xFE, 0x07, 0xC1,
  0xF8, 0x3F, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0x83, 0xE0, 0x7E, 0x1F, 0x7C,
  0x1F, 0x03, 0xF0, 0xFB, 0xE1, 0xF8, 0x1F, 0x87, 0x9F, 0x0F, 0x80, 0xFC,
  0x7C, 0xF8, 0xFC, 0x07, 0xE3, 0xE7, 0xC7, 0xC0, 0x3E, 0x3E, 0x3E, 0x3E,
  0x01, 0xF1, 0xF1, 0xF3, 0xF0, 0x0F, 0x8F, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x7D, 0xF8, 0x03, 0xE7, 0xC3, 0xEF, 0x80, 0x1F, 0x7C, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0xFF, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x3D,
  0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00,
  0xFD, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0x80, 0xF8,
  0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xE0,
  0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x01,
  0xE3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x00, 0x7C, 0x3E, 0x03, 0xFC, 0x7C, 0x0F, 0xFD, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC,
  0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xF7,
  0xC0, 0x7F, 0xCF, 0x80, 0x7F, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x1F, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0xFB, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x83, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0xFF, 0x81, 0xEF, 0xFE, 0x07,
  0xCF, 0xF8, 0x0F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xC1, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x04, 0x1F, 0xC7,
  0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x3F, 0xCF,
  0xC0, 0x3F, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x87,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x80,
  0xF8, 0x3F, 0x80, 0x7E, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFD, 0xF0,
  0x07, 0xFC, 0xF0, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x3F, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xE3,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x10, 0x7F, 0x03, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF1, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x3F,
  0xE7, 0xC0, 0x3F, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xC7, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFD, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x80,
  0x1F, 0xC0, 0x78, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x7F, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xC0, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x0F, 0x9F,
  0x00, 0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xC3, 0xE0,
  0x3E, 0x00, 0xF3, 0xFC, 0x3F, 0xC0, 0x7D, 0xFF, 0x9F, 0xF8, 0x1F, 0xFF,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xC3, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE0, 0x3E,
  0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF0,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xC3, 0xE0, 0x0F, 0x3F, 0xE0, 0x7D, 0xFF,
  0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC3,
  0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E,
  0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xC7,
  0xC0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0xFF,
  0x00, 0x7D, 0xFF, 0x80, 0x3E, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xE1,
  0xF8, 0x07, 0xE0, 0x7C, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0x7F, 0xE0,
  0x0F, 0xBF, 0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x03,
  0xFE, 0x7C, 0x0F, 0xFC, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8,
  0x7F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x1F,
  0x8F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0x00, 0x7F,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xC3, 0xE0, 0x79, 0xF8, 0x1F, 0x7F, 0x03, 0xEF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFE, 0xF8, 0x3F, 0x01, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0x00, 0xFC, 0x3C, 0x3F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xF3, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x10,
  0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0xF8, 0xFC, 0x07,
  0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0xFC,
  0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x80,
  0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F,
  0x81, 0xF8, 0x7C, 0x1F, 0xC3, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xEF,
  0x03, 0xFE, 0x78, 0x0F, 0xE3, 0xC0, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8,
  0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F,
  0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0x78, 0xF8, 0x07, 0x9F, 0x80, 0x79, 0xF0,
  0x07, 0xBF, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x7F,
  0x03, 0xF7, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0x9F, 0x07, 0xF8,
  0x3F, 0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x3F, 0xE1, 0xF8, 0xF8, 0x7B, 0xC3,
  0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xE3, 0xEF, 0x1F, 0x87, 0xC7, 0x9E, 0x3E,
  0x0F, 0x9F, 0x3C, 0x7C, 0x1F, 0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF3, 0xE0,
  0x7D, 0xF1, 0xEF, 0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xFF, 0x87, 0xBE, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF7, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x02,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFA, 0x00,
  0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 36, 12, 0, -35 },
  { 64, 16, 13, 19, 5, -35 },
  { 90, 26, 35, 25, 0, -35 },
  { 204, 23, 40, 22, 0, -37 },
  { 319, 31, 35, 35, 3, -35 },
  { 455, 26, 35, 27, 0, -35 },
  { 569, 8, 13, 11, 5, -35 },
  { 582, 16, 43, 14, 1, -35 },
  { 668, 17, 43, 14, -4, -35 },
  { 760, 19, 21, 22, 4, -38 },
  { 810, 21, 23, 24, 2, -29 },
  { 871, 10, 13, 12, -2, -6 },
  { 888, 12, 5, 14, 1, -16 },
  { 896, 7, 8, 12, 0, -7 },
  { 903, 24, 35, 18, -2, -35 },
  { 1008, 21, 35, 22, 1, -35 },
  { 1100, 15, 35, 22, 5, -35 },
  { 1166, 23, 35, 22, -1, -35 },
  { 1267, 22, 35, 22, 0, -35 },
  { 1364, 23, 35, 22, -1, -35 },
  { 1465, 23, 35, 22, 0, -35 },
  { 1566, 21, 36, 22, 2, -36 },
  { 1661, 23, 35, 22, 2, -35 },
  { 1762, 23, 35, 22, 0, -35 },
  { 1863, 21, 36, 22, 1, -36 },
  { 1958, 11, 28, 12, 0, -27 },
  { 1997, 15, 34, 12, -3, -27 },
  { 2061, 21, 23, 24, 2, -29 },
  { 2122, 21, 14, 24, 2, -24 },
  { 2159, 21, 23, 24, 2, -29 },
  { 2220, 17, 35, 17, 2, -35 },
  { 2295, 32, 39, 34, 2, -35 },
  { 2451, 24, 35, 24, -3, -35 },
  { 2556, 25, 35, 25, 0, -35 },
  { 2666, 24, 36, 23, 2, -36 },
  { 2774, 26, 35, 27, 0, -35 },
  { 2888, 23, 35, 21, 0, -35 },
  { 2989, 23, 35, 20, 0, -35 },
  { 3090, 26, 36, 28, 2, -36 },
  { 3207, 29, 35, 28, 0, -35 },
  { 3334, 21, 35, 15, -2, -35 },
  { 3426, 22, 45, 12, -8, -35 },
  { 3550, 28, 35, 24, 0, -35 },
  { 3673, 17, 35, 20, 0, -35 },
  { 3748, 37, 35, 36, 0, -35 },
  { 3910, 31, 35, 30, 0, -35 },
  { 4046, 26, 36, 29, 2, -36 },
  { 4163, 25, 35, 24, 0, -35 },
  { 4273, 26, 44, 29, 2, -36 },
  { 4416, 24, 35, 24, 0, -35 },
  { 4521, 23, 35, 21, 0, -35 },
  { 4622, 20, 35, 21, 4, -35 },
  { 4710, 26, 35, 27, 2, -35 },
  { 4824, 24, 35, 24, 4, -35 },
  { 4929, 37, 35, 36, 4, -35 },
  { 5091, 29, 35, 23, -3, -35 },
  { 5218, 22, 35, 22, 4, -35 },
  { 5315, 25, 35, 20, -2, -35 },
  { 5425, 19, 43, 14, -1, -35 },
  { 5528, 10, 35, 18, 5, -35 },
  { 5572, 19, 43, 14, -3, -35 },
  { 5675, 22, 21, 23, 0, -35 },
  { 5733, 18, 3, 17, -5, 4 },
  { 5740, 9, 8, 14, 7, -38 },
  { 5749, 23, 27, 24, 1, -27 },
  { 5827, 23, 37, 24, 0, -37 },
  { 5934, 19, 27, 19, 1, -27 },
  { 5999, 25, 37, 24, 1, -37 },
  { 6115, 20, 27, 22, 1, -27 },
  { 6183, 26, 49, 14, -6, -37 },
  { 6343, 25, 39, 24, -1, -27 },
  { 6465, 22, 37, 24, 0, -37 },
  { 6567, 13, 37, 12, 0, -37 },
  { 6628, 19, 49, 12, -6, -37 },
  { 6745, 24, 37, 22, 0, -37 },
  { 6856, 14, 37, 11, 0, -37 },
  { 6921, 34, 27, 35, 0, -27 },
  { 7036, 22, 27, 24, 0, -27 },
  { 7111, 21, 27, 23, 1, -27 },
  { 7182, 25, 39, 24, -2, -27 },
  { 7304, 23, 39, 24, 1, -27 },
  { 7417, 19, 27, 17, 0, -27 },
  { 7482, 19, 27, 19, 0, -27 },
  { 7547, 14, 32, 15, 2, -32 },
  { 7603, 21, 27, 24, 2, -27 },
  { 7674, 20, 27, 20, 3, -27 },
  { 7742, 31, 27, 31, 3, -27 },
  { 7847, 25, 27, 21, -2, -27 },
  { 7932, 27, 39, 20, -4, -27 },
  { 8064, 21, 27, 18, -2, -27 },
  { 8135, 19, 43, 17, 1, -35 },
  { 8238, 5, 48, 21, 8, -37 },
  { 8268, 19, 43, 17, -3, -35 },
  { 8371, 21, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC49PT7B_H_
