#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8,
  0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE1,
  0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xCE, 0x3C, 0x01, 0xFC, 0x70, 0x60, 0x1F, 0xC3, 0x80,
  0x00, 0xFE, 0x38, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0x3F, 0x8E, 0x00, 0x01,
  0xFC, 0x70, 0x00, 0x0F, 0xF3, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3B, 0xFE, 0x00, 0x01,
  0xCF, 0xF0, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0x71, 0xFC, 0x00, 0x07, 0x0F,
  0xE0, 0x00, 0x38, 0x7F, 0x08, 0x01, 0xC3, 0xF8, 0x60, 0x0E, 0x3F, 0x83,
  0xC0, 0x73, 0xFC, 0x1F, 0xC7, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0x3E,
  0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x1F,
  0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x1F, 0x8F, 0xC0,
  0x00, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x1F, 0x8F, 0xFC, 0xF8,
  0x3E, 0x3F, 0x1F, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0xFE, 0xFC, 0xFC, 0x7E,
  0x3F, 0xFE, 0xFF, 0xFC, 0x7C, 0x7E, 0x3F, 0xFF, 0xF8, 0xFC, 0xFC, 0x3F,
  0x7F, 0xF1, 0xF8, 0xFC, 0x3F, 0x7F, 0xE1, 0xF0, 0xF8, 0x3F, 0x1F, 0xC3,
  0xF1, 0xF8, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x07, 0xE1, 0xF0,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x3E, 0x00,
  0x1F, 0x83, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xF0, 0x1F,
  0xC1, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0xBF, 0xC3, 0xF8, 0x1F,
  0xEF, 0xE1, 0xFE, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xFC, 0x1F, 0xC0,
  0x1F, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFE, 0x01,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xC3,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x40, 0x3F, 0x00, 0x70, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7F, 0x3E, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xEF, 0x80, 0x3F, 0xCF, 0xC0, 0x7F, 0x8F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xF0, 0x0E, 0x07, 0xF0, 0x04, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x0F, 0xE7, 0xF9, 0xFF, 0x7F,
  0xFF, 0xEF, 0xF9, 0xFC, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xFC,
  0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0xDF, 0xCF, 0xFB, 0xF8, 0xFE, 0x3F, 0x87, 0xC3,
  0xF8, 0x38, 0x7F, 0x83, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFF,
  0x80, 0x3F, 0x01, 0xFF, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x20, 0x03, 0xFC,
  0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0xE0, 0x0E, 0x00,
  0xFF, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x00,
  0x7F, 0x82, 0x00, 0x07, 0xFC, 0x1E, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x7C, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE6, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x82, 0x00,
  0x03, 0xFC, 0x0C, 0x00, 0x1F, 0xF0, 0x3E, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF3, 0xFF, 0x00, 0x7F, 0x7F,
  0xFC, 0x03, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC,
  0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xE1, 0xFE, 0x07, 0xFE, 0x1F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xFB, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x03, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x08, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xE0, 0x7F, 0x83, 0x00, 0x7F, 0x04, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0x83,
  0xF0, 0x7C, 0x03, 0xFF, 0xF0, 0x7C, 0x3F, 0x01, 0xFF, 0xFC, 0x1F, 0x0F,
  0x80, 0xFF, 0xFE, 0x07, 0xC7, 0xE0, 0x7E, 0x0F, 0x81, 0xF1, 0xF0, 0x3F,
  0x07, 0xE0, 0x7C, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0xCF, 0x81, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x0F, 0xC0, 0xF9,
  0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0x9F, 0x07,
  0xE0, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x1F, 0x81, 0xF3, 0xF0, 0x7C, 0x07,
  0xE0, 0x7C, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F,
  0x8F, 0x83, 0xF0, 0x3F, 0x03, 0xE3, 0xE0, 0xFC, 0x1F, 0xC1, 0xF0, 0xF8,
  0x3F, 0x07, 0xF0, 0xFC, 0x3E, 0x07, 0xC3, 0xFC, 0x3E, 0x0F, 0x81, 0xFF,
  0xEF, 0xFF, 0x03, 0xE0, 0x7F, 0xF3, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC, 0xFF,
  0xE0, 0x3E, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xFE, 0x00,
  0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x7E, 0x00, 0xFF, 0xC0, 0x18, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x3F, 0xF0, 0x1E, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0,
  0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xE0,
  0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x02,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xE3,
  0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF,
  0x0F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0x80, 0x7E, 0x7F,
  0x00, 0x7F, 0x3F, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x03, 0xF1, 0xFC,
  0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x80,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x87, 0xE1, 0xFE, 0x01,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x3F, 0x07, 0xF0, 0x07,
  0xF0, 0xFC, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF9, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xFB, 0xF0, 0x7F, 0x80, 0x7F, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0xFE,
  0x07, 0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xBF, 0x00,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0x01,
  0xFD, 0xFC, 0x03, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xE0, 0x07, 0xE3, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x0F, 0xE7, 0xF0,
  0x07, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x3C, 0x01, 0xFF, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0C, 0x00, 0x1F, 0xF0, 0x1E,
  0x00, 0x7F, 0xC0, 0x3F, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x3F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x7F, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xE0,
  0x7F, 0x01, 0xFB, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFB, 0xE0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x80,
  0x7F, 0x03, 0xF7, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xE7, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x00,
  0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x00,
  0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x07, 0xE3, 0xF8, 0x00,
  0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x87, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x9F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0xC1,
  0xF8, 0x03, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF7, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0,
  0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFC, 0xFC, 0x01, 0xFF, 0xC7, 0xE0,
  0x03, 0xFC, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xF8, 0x01, 0xFD, 0xFF, 0xE0,
  0x07, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xF8,
  0x07, 0xE7, 0xFF, 0xC0, 0x3F, 0x1F, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFC,
  0x0C, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x20, 0xFF, 0x80, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xE3, 0xF8, 0x00, 0xFF, 0xF3, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xDF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0xFC, 0x00,
  0x3F, 0xF8, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x1F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFC, 0x1F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x18, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xFC,
  0x3F, 0x00, 0x1F, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x7F, 0xFF,
  0x7E, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFE, 0x07,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xBF, 0x80, 0x07, 0xFF, 0x3F, 0x80, 0x03, 0xFE, 0x3F,
  0x80, 0x00, 0x20, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xFC, 0x01,
  0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x8F, 0xFE, 0x0F, 0xFC, 0x01, 0xF9,
  0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xFF,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xFF, 0x00, 0x7E, 0x7F, 0xFC, 0x03,
  0xF7, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0xF0, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0x3F, 0x7F,
  0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x80, 0x0F, 0xE7, 0xFF,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xFF, 0x8F,
  0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xBF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xC1, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF,
  0x80, 0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xCF, 0xE0, 0x07, 0xFC, 0x7F, 0x00,
  0x07, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0xFF, 0x01, 0xF9, 0xFF, 0x01, 0xF9, 0xFF, 0x01, 0xFB, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x82, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0,
  0x1C, 0x0F, 0xF0, 0x04, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x80, 0x0F, 0xF0, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFB, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x81, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xDF, 0x80, 0x7F, 0xFC, 0xFC, 0x01, 0xFF,
  0xC7, 0xE0, 0x07, 0xFC, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xEF, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0x00, 0xFE,
  0xFE, 0x03, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0xFE, 0x07,
  0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFF, 0x03,
  0xF8, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xBF, 0x07, 0xF0, 0xFE,
  0x1F, 0xBF, 0x0F, 0xE0, 0xFE, 0x1F, 0xBF, 0x0F, 0xE0, 0xFE, 0x1F, 0x3F,
  0x0F, 0xE0, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0,
  0xFE, 0x7E, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x3E, 0x3F, 0x80, 0xFC, 0x7C,
  0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x3E, 0x7F, 0x00, 0xFC, 0xFC, 0x3E, 0x7F,
  0x00, 0xFD, 0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x3E, 0xFE, 0x00, 0xFD,
  0xF0, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF6,
  0x00, 0x3F, 0xFC, 0x80, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 18, 47, 16, 0, -46 },
  { 107, 21, 17, 25, 6, -46 },
  { 152, 33, 46, 33, 1, -46 },
  { 342, 29, 53, 29, 1, -49 },
  { 535, 40, 47, 46, 4, -46 },
  { 770, 34, 47, 35, 0, -46 },
  { 970, 10, 17, 15, 6, -46 },
  { 992, 22, 56, 18, 1, -46 },
  { 1146, 21, 56, 18, -5, -46 },
  { 1293, 24, 26, 28, 6, -49 },
  { 1371, 27, 31, 31, 3, -38 },
  { 1476, 13, 17, 15, -3, -8 },
  { 1504, 16, 7, 19, 1, -21 },
  { 1518, 10, 10, 15, 0, -9 },
  { 1531, 32, 46, 24, -3, -46 },
  { 1715, 27, 47, 29, 2, -46 },
  { 1874, 20, 46, 29, 7, -46 },
  { 1989, 31, 46, 29, -2, -46 },
  { 2168, 29, 47, 29, 0, -46 },
  { 2339, 30, 46, 29, -1, -46 },
  { 2512, 30, 47, 29, 0, -46 },
  { 2689, 29, 47, 29, 2, -46 },
  { 2860, 30, 46, 29, 2, -46 },
  { 3033, 30, 47, 29, 0, -46 },
  { 3210, 28, 47, 29, 1, -46 },
  { 3375, 15, 36, 15, 0, -35 },
  { 3443, 18, 44, 15, -3, -35 },
  { 3542, 27, 30, 31, 3, -38 },
  { 3644, 27, 19, 31, 3, -32 },
  { 3709, 27, 30, 31, 3, -38 },
  { 3811, 23, 47, 23, 2, -46 },
  { 3947, 42, 51, 44, 2, -46 },
  { 4215, 32, 46, 32, -4, -46 },
  { 4399, 32, 46, 32, 1, -46 },
  { 4583, 31, 47, 30, 3, -46 },
  { 4766, 33, 46, 35, 1, -46 },
  { 4956, 29, 46, 28, 1, -46 },
  { 5123, 29, 46, 26, 1, -46 },
  { 5290, 34, 47, 36, 3, -46 },
  { 5490, 37, 46, 36, 1, -46 },
  { 5703, 28, 46, 20, -3, -46 },
  { 5864, 28, 59, 16, -10, -46 },
  { 6071, 36, 46, 31, 1, -46 },
  { 6278, 21, 46, 26, 1, -46 },
  { 6399, 47, 46, 47, 1, -46 },
  { 6670, 39, 46, 39, 1, -46 },
  { 6895, 33, 47, 38, 3, -46 },
  { 7089, 32, 46, 31, 1, -46 },
  { 7273, 33, 57, 38, 3, -46 },
  { 7509, 31, 46, 32, 1, -46 },
  { 7688, 31, 47, 28, -1, -46 },
  { 7871, 27, 46, 27, 5, -46 },
  { 8027, 34, 47, 36, 3, -46 },
  { 8227, 30, 46, 31, 6, -46 },
  { 8400, 48, 46, 47, 5, -46 },
  { 8676, 38, 46, 30, -4, -46 },
  { 8895, 28, 46, 28, 6, -46 },
  { 9056, 33, 46, 27, -2, -46 },
  { 9246, 25, 56, 19, -2, -46 },
  { 9421, 12, 46, 24, 7, -46 },
  { 9490, 25, 56, 19, -4, -46 },
  { 9665, 28, 28, 30, 1, -46 },
  { 9763, 23, 4, 22, -6, 6 },
  { 9775, 11, 10, 18, 9, -49 },
  { 9789, 29, 36, 31, 2, -35 },
  { 9920, 30, 50, 31, 0, -49 },
  { 10108, 24, 36, 25, 2, -35 },
  { 10216, 32, 50, 31, 2, -49 },
  { 10416, 25, 36, 28, 2, -35 },
  { 10529, 33, 64, 18, -7, -49 },
  { 10793, 32, 50, 31, -1, -35 },
  { 10993, 29, 49, 31, 0, -49 },
  { 11171, 17, 48, 15, 0, -48 },
  { 11273, 25, 63, 15, -8, -48 },
  { 11470, 31, 49, 28, 0, -49 },
  { 11660, 18, 49, 15, 0, -49 },
  { 11771, 44, 35, 46, 0, -35 },
  { 11964, 29, 35, 31, 0, -35 },
  { 12091, 27, 36, 30, 2, -35 },
  { 12213, 32, 50, 31, -3, -35 },
  { 12413, 29, 50, 31, 2, -35 },
  { 12595, 24, 35, 22, 0, -35 },
  { 12700, 24, 36, 24, 0, -35 },
  { 12808, 19, 43, 19, 2, -42 },
  { 12911, 29, 36, 31, 2, -35 },
  { 13042, 26, 35, 26, 4, -35 },
  { 13156, 40, 35, 41, 4, -35 },
  { 13331, 33, 35, 27, -3, -35 },
  { 13476, 35, 50, 27, -5, -35 },
  { 13695, 27, 35, 23, -2, -35 },
  { 13814, 25, 56, 22, 1, -46 },
  { 13989, 7, 64, 27, 10, -49 },
  { 14045, 25, 56, 22, -4, -46 },
  { 14220, 27, 9, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC64PT7B_H_
