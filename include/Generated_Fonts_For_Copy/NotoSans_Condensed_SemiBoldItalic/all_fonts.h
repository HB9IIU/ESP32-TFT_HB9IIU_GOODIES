#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_SemiBoldItalic
// Headers: 67

#include "NotoSans_Condensed_SemiBoldItalic6pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic7pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic8pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic9pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic10pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic11pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic12pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic13pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic14pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic15pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic16pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic17pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic18pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic19pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic20pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic21pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic22pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic23pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic24pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic25pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic26pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic27pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic28pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic29pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic30pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic31pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic32pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic33pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic34pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic35pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic36pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic37pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic38pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic39pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic40pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic41pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic42pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic43pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic44pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic45pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic46pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic47pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic48pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic49pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic50pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic51pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic52pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic53pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic54pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic55pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic56pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic57pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic58pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic59pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic60pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic61pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic62pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic63pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic64pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic65pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic66pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic67pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic68pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic69pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic70pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic71pt7b.h"
#include "NotoSans_Condensed_SemiBoldItalic72pt7b.h"
