#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0x3C, 0x00, 0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9E,
  0x38, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xC7, 0x0E, 0x00, 0x00, 0x38, 0xF0,
  0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x1E, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x80, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00,
  0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x70, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xDE, 0x0F, 0x30, 0x83, 0xCC, 0x00, 0xF3, 0x00,
  0x3C, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0x7C, 0x00, 0xDF, 0x00, 0x27,
  0xC8, 0x19, 0xF1, 0x86, 0x78, 0x7D, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x1C, 0x07, 0xF0, 0x1E, 0x07, 0xF8, 0x0E, 0x07, 0x9C, 0x0E, 0x03,
  0x8E, 0x0F, 0x03, 0xC7, 0x07, 0x01, 0xC3, 0x87, 0x80, 0xE1, 0xC3, 0x80,
  0x70, 0xE3, 0x80, 0x78, 0xF3, 0xC0, 0x3C, 0x79, 0xC0, 0x1E, 0x39, 0xE7,
  0xCF, 0x3C, 0xE7, 0xF7, 0x9C, 0xE7, 0xFB, 0xFE, 0xF3, 0x9E, 0xFE, 0x73,
  0xCF, 0x3E, 0x79, 0xC7, 0x80, 0x39, 0xE3, 0xC0, 0x3C, 0xE1, 0xE0, 0x3C,
  0x70, 0xE0, 0x1C, 0x38, 0x70, 0x1E, 0x1C, 0x78, 0x0E, 0x1E, 0x3C, 0x0F,
  0x0F, 0x1C, 0x0F, 0x03, 0x9E, 0x07, 0x01, 0xFE, 0x07, 0x80, 0xFE, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xCF, 0x00, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC3, 0xE3, 0xFF, 0x1E, 0x3E, 0xF8, 0xF1,
  0xE3, 0xEF, 0x1F, 0x1F, 0x78, 0xF0, 0x7F, 0x8F, 0x83, 0xFC, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xF0, 0x7E, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFD, 0xF0, 0x3F, 0x87, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x82, 0x0E,
  0x07, 0x1C, 0x0F, 0xB8, 0x5F, 0xFF, 0xDF, 0xFF, 0x07, 0xFE, 0x0F, 0x80,
  0x3F, 0x81, 0xF7, 0x07, 0xCF, 0x07, 0x9E, 0x06, 0x1E, 0x00, 0x30, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xFF,
  0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3C,
  0x1F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xEF, 0x81, 0xE7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F,
  0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x07,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0xFD, 0xEF, 0xBE, 0x73, 0xC2, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x38, 0x7E, 0x06, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x06, 0x07, 0xC1, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE2, 0x01, 0xF8, 0xFB, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3D,
  0xF0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0xF8,
  0x38, 0x3C, 0x1E, 0x0F, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xC7,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE2, 0x01, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC7, 0x80, 0xF7, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xE3, 0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x07, 0x8F, 0x81,
  0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC1, 0xE1, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F,
  0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07,
  0xC3, 0xE3, 0xE0, 0x79, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0x87, 0xC1, 0xF1, 0xE0,
  0x7C, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0x7C, 0x7E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x78,
  0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x87, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xEF, 0x01, 0xE3, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0xF7, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0x87,
  0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xE3,
  0xFF, 0xC7, 0xFF, 0x18, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x07, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x0C, 0x0E, 0x1E,
  0x1F, 0xF3, 0xC7, 0x0F, 0xF8, 0x73, 0xC7, 0x8E, 0x1C, 0xE1, 0xC3, 0x8F,
  0x78, 0xF1, 0xE3, 0xDC, 0x38, 0x70, 0xE7, 0x1E, 0x1C, 0x39, 0xC7, 0x07,
  0x0E, 0x71, 0xC3, 0xC7, 0xBC, 0x70, 0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x87,
  0x1E, 0x38, 0xE1, 0xCF, 0x9E, 0x38, 0x7F, 0x7F, 0x0F, 0x0F, 0x9F, 0x83,
  0xC1, 0xC1, 0x80, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x02, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80,
  0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC3, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xE1,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x08, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x40, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7C, 0x7F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F,
  0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0,
  0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x07, 0xE1,
  0xF0, 0x7E, 0x0F, 0x87, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x04, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x06, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0xF3, 0xE0,
  0xFF, 0x1F, 0x07, 0xF8, 0xF8, 0x3F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x81,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x0F,
  0x80, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x1E, 0x01,
  0xF0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x3E,
  0x07, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x01, 0x1F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0,
  0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE3, 0xE0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C,
  0x00, 0x79, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3E, 0x00,
  0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0,
  0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83,
  0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0x78,
  0x1F, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xDE, 0x0F, 0x78, 0x1E, 0xF0, 0x7B,
  0xC0, 0xF7, 0x87, 0x9E, 0x0F, 0xBC, 0x3D, 0xF0, 0x79, 0xE3, 0xCF, 0x03,
  0xCF, 0x1E, 0x78, 0x1E, 0x79, 0xE3, 0xC0, 0xF3, 0xCF, 0x3E, 0x0F, 0x9E,
  0xF1, 0xF0, 0x78, 0xF7, 0x8F, 0x03, 0xC7, 0xB8, 0x78, 0x1E, 0x1F, 0xC3,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x07, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x03,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x03,
  0xE0, 0x0F, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x0F, 0x07, 0xF0, 0x1F, 0x07,
  0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF8, 0x1E, 0x07, 0xF8, 0x1E, 0x0F,
  0x78, 0x3E, 0x0F, 0x78, 0x3C, 0x0F, 0x7C, 0x3C, 0x0F, 0x3C, 0x3C, 0x0F,
  0x3C, 0x7C, 0x1F, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x1E, 0x78, 0x1E,
  0x1E, 0x78, 0x1E, 0x1E, 0xF8, 0x3C, 0x1E, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x78, 0x0F, 0xE0, 0x78,
  0x07, 0xE0, 0x78, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1,
  0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0xE1, 0xF1, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x1F, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7C, 0x7E, 0x0F,
  0x87, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C,
  0x0F, 0x87, 0x83, 0xE0, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xE0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03,
  0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x88, 0x03, 0xC3, 0x03, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x87,
  0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x78,
  0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0,
  0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x03, 0xEF, 0x00, 0x7D,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F,
  0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x7B, 0xC0, 0x7C, 0x07, 0xDE, 0x03, 0xE0,
  0x3D, 0xF0, 0x1F, 0x03, 0xEF, 0x81, 0xF8, 0x1E, 0x7C, 0x0F, 0xC0, 0xF3,
  0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0xF0, 0x78, 0xF8, 0x7F, 0x87, 0xC7, 0xC3,
  0xFC, 0x3C, 0x3E, 0x1D, 0xE1, 0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x78,
  0xF0, 0x7C, 0xF3, 0xCF, 0x83, 0xE7, 0x9E, 0x78, 0x1F, 0x38, 0xF3, 0xC0,
  0xFB, 0xC7, 0xBE, 0x07, 0x9E, 0x3D, 0xE0, 0x3D, 0xE1, 0xEF, 0x01, 0xEF,
  0x0F, 0xF0, 0x0F, 0x70, 0x77, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF1, 0xE0, 0x07,
  0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xDE, 0x03, 0xE7, 0x80, 0xF1,
  0xE0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x78,
  0x3C, 0x1E, 0x07, 0x0F, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x0E, 0xF0, 0x03,
  0xC0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFB, 0xE7, 0x9F, 0x3C, 0x70,
  0x00, 0xC0, 0x00, 0xFC, 0xF0, 0x7F, 0xBC, 0x3F, 0xFE, 0x1F, 0x9F, 0x87,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F,
  0xCF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x84, 0x03, 0xEF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3C,
  0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x0F,
  0x87, 0xF7, 0xE1, 0xFF, 0xF0, 0xF7, 0xF8, 0x3C, 0xFC, 0x00, 0x00, 0x20,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xF8, 0xC7, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x21, 0xFB, 0x83, 0xFF, 0x03,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x83, 0xC0, 0x3F, 0x7C, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x9F,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0,
  0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xFC, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xBC, 0x03, 0xF3, 0xC0, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x7C, 0x3E, 0x78,
  0xFC, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x0B, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x3C, 0x0F, 0xF7, 0x83, 0xFF,
  0xE0, 0xFC, 0xFC, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x3E, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xFB, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x82, 0x03, 0xE0, 0x71, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x84, 0x03, 0xEF, 0xC0, 0xF7, 0xF8, 0x3F, 0xFE, 0x0F, 0xEF, 0xC3, 0xE1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F,
  0x80, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x3E, 0x1F, 0x07,
  0x87, 0xC0, 0xF1, 0xF0, 0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x1E,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE1,
  0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0x04, 0x02, 0x01, 0xE7, 0xE3, 0xF8, 0x3D, 0xFE,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF, 0x3E, 0x1F, 0x0F, 0xC7, 0xC7,
  0xC1, 0xF0, 0xF8, 0xF8, 0x3C, 0x1F, 0x1E, 0x07, 0x83, 0xC3, 0xC1, 0xF0,
  0x78, 0x78, 0x3E, 0x0F, 0x1F, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x7C, 0x78,
  0x1E, 0x0F, 0x0F, 0x07, 0xC1, 0xE3, 0xE0, 0xF0, 0x3C, 0x7C, 0x1E, 0x0F,
  0x8F, 0x03, 0xC1, 0xF1, 0xE0, 0x78, 0x3C, 0x3C, 0x1F, 0x07, 0x8F, 0x83,
  0xC0, 0xF1, 0xF0, 0x78, 0x3E, 0x00, 0x00, 0x04, 0x03, 0xCF, 0xC0, 0xF7,
  0xF8, 0x3F, 0xFE, 0x0F, 0xEF, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1E,
  0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x00, 0x60, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBF, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x3C, 0xFC, 0x03, 0xDF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0xDF, 0x81, 0xFF, 0xF0, 0x3E, 0xFE, 0x03, 0xEF, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xFC, 0xF0, 0x7F, 0xBC, 0x3F, 0xFE, 0x1F, 0x9F, 0x87, 0x83, 0xE3,
  0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x1F, 0x0F, 0xCF, 0xC1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F, 0xDF, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x04, 0x1E, 0x7C,
  0x3D, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xF1, 0xC7,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF1, 0x03, 0xE3,
  0xCF, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xFF, 0x7F, 0xF7, 0xFE, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xFD, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83,
  0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0x7F, 0x07, 0xFF, 0xC1, 0xFE, 0xF0, 0x3F, 0x38, 0x00, 0xF0,
  0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x7B, 0xE0, 0x7B,
  0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x3F, 0x07, 0xBE,
  0x1F, 0x87, 0xDF, 0x0F, 0xC3, 0xCF, 0x8F, 0xE1, 0xE7, 0x87, 0xF1, 0xF3,
  0xC7, 0xF8, 0xF1, 0xE3, 0xFC, 0xF8, 0xF1, 0xDE, 0x78, 0x79, 0xEF, 0x3C,
  0x3C, 0xE7, 0xBC, 0x1E, 0xF3, 0xDE, 0x0F, 0x79, 0xEF, 0x07, 0xB8, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xCF, 0x80,
  0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBC,
  0x00, 0xF3, 0xC0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x1E, 0x07, 0xC1,
  0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x7C,
  0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x27, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x18, 0x01, 0x7F, 0x81, 0xFF, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0x80,
  0x7E,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 28, 10, 0, -28 },
  { 40, 13, 10, 15, 4, -28 },
  { 57, 21, 28, 20, 0, -28 },
  { 131, 18, 32, 18, 0, -30 },
  { 203, 25, 28, 28, 2, -28 },
  { 291, 21, 28, 21, 0, -28 },
  { 365, 6, 10, 9, 4, -28 },
  { 373, 13, 34, 11, 1, -28 },
  { 429, 13, 34, 11, -3, -28 },
  { 485, 15, 16, 17, 3, -30 },
  { 515, 16, 19, 19, 2, -23 },
  { 553, 8, 10, 9, -2, -5 },
  { 563, 10, 5, 11, 1, -13 },
  { 570, 6, 5, 9, 0, -5 },
  { 574, 20, 28, 14, -2, -28 },
  { 644, 17, 28, 18, 1, -28 },
  { 704, 12, 28, 18, 4, -28 },
  { 746, 19, 28, 18, -1, -28 },
  { 813, 18, 28, 18, 0, -28 },
  { 876, 18, 28, 18, 0, -28 },
  { 939, 18, 28, 18, 0, -28 },
  { 1002, 18, 28, 18, 1, -28 },
  { 1065, 19, 28, 18, 1, -28 },
  { 1132, 18, 28, 18, 0, -28 },
  { 1195, 18, 28, 18, 0, -28 },
  { 1258, 9, 21, 9, 0, -21 },
  { 1282, 11, 26, 9, -2, -21 },
  { 1318, 16, 18, 19, 2, -23 },
  { 1354, 16, 11, 19, 2, -19 },
  { 1376, 16, 18, 19, 2, -23 },
  { 1412, 14, 28, 14, 1, -28 },
  { 1461, 26, 31, 27, 1, -28 },
  { 1562, 19, 28, 19, -2, -28 },
  { 1629, 20, 28, 20, 0, -28 },
  { 1699, 19, 28, 18, 2, -28 },
  { 1766, 21, 28, 21, 0, -28 },
  { 1840, 18, 28, 17, 0, -28 },
  { 1903, 18, 28, 16, 0, -28 },
  { 1966, 21, 28, 22, 2, -28 },
  { 2040, 23, 28, 22, 0, -28 },
  { 2121, 17, 28, 12, -2, -28 },
  { 2181, 17, 36, 10, -6, -28 },
  { 2258, 22, 28, 19, 0, -28 },
  { 2335, 13, 28, 16, 0, -28 },
  { 2381, 29, 28, 29, 0, -28 },
  { 2483, 24, 28, 23, 0, -28 },
  { 2567, 20, 28, 23, 2, -28 },
  { 2637, 20, 28, 19, 0, -28 },
  { 2707, 20, 35, 23, 2, -28 },
  { 2795, 19, 28, 19, 0, -28 },
  { 2862, 18, 28, 17, 0, -28 },
  { 2925, 16, 28, 16, 3, -28 },
  { 2981, 21, 28, 22, 2, -28 },
  { 3055, 19, 28, 19, 3, -28 },
  { 3122, 29, 28, 29, 3, -28 },
  { 3224, 23, 28, 18, -2, -28 },
  { 3305, 18, 28, 17, 3, -28 },
  { 3368, 20, 28, 16, -1, -28 },
  { 3438, 15, 34, 11, -1, -28 },
  { 3502, 8, 28, 15, 4, -28 },
  { 3530, 16, 34, 11, -3, -28 },
  { 3598, 18, 17, 18, 0, -28 },
  { 3637, 14, 3, 13, -4, 3 },
  { 3643, 6, 6, 11, 6, -30 },
  { 3648, 18, 22, 19, 1, -22 },
  { 3698, 18, 30, 19, 0, -30 },
  { 3766, 15, 22, 15, 1, -22 },
  { 3808, 20, 30, 19, 1, -30 },
  { 3883, 16, 21, 17, 1, -21 },
  { 3925, 20, 39, 11, -4, -30 },
  { 4023, 19, 31, 19, 0, -22 },
  { 4097, 18, 30, 19, 0, -30 },
  { 4165, 11, 29, 9, 0, -29 },
  { 4205, 16, 38, 9, -5, -29 },
  { 4281, 19, 30, 17, 0, -30 },
  { 4353, 11, 30, 9, 0, -30 },
  { 4395, 27, 22, 28, 0, -22 },
  { 4470, 18, 22, 19, 0, -22 },
  { 4520, 16, 22, 19, 1, -22 },
  { 4564, 20, 31, 19, -2, -22 },
  { 4642, 18, 31, 19, 1, -22 },
  { 4712, 15, 22, 13, 0, -22 },
  { 4754, 15, 22, 15, 0, -22 },
  { 4796, 12, 26, 12, 1, -26 },
  { 4835, 18, 21, 19, 1, -21 },
  { 4883, 16, 21, 16, 2, -21 },
  { 4925, 25, 21, 25, 2, -21 },
  { 4991, 20, 21, 16, -2, -21 },
  { 5044, 21, 30, 16, -3, -21 },
  { 5123, 16, 21, 14, -1, -21 },
  { 5165, 16, 34, 13, 0, -28 },
  { 5233, 4, 39, 17, 6, -30 },
  { 5253, 15, 34, 13, -2, -28 },
  { 5317, 16, 6, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC39PT7B_H_
