#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0x80,
  0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F,
  0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0,
  0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x83, 0xE0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC1, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0x01, 0xFC, 0xE1, 0xC0,
  0x7F, 0x1C, 0x08, 0x0F, 0xC3, 0x80, 0x01, 0xF8, 0x60, 0x00, 0x3F, 0x1C,
  0x00, 0x07, 0xE3, 0x80, 0x00, 0xFE, 0x70, 0x00, 0x1F, 0xEE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x39, 0xFE,
  0x00, 0x07, 0x1F, 0xC0, 0x00, 0xE3, 0xF8, 0x00, 0x1C, 0x7F, 0x00, 0x03,
  0x0F, 0xE2, 0x00, 0xE1, 0xF8, 0x70, 0x1C, 0x7F, 0x0F, 0x83, 0x9F, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x3F,
  0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x03,
  0xE0, 0x07, 0xE1, 0xF0, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x03,
  0xE0, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x1F, 0x00, 0x0F,
  0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x07, 0xC3,
  0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3E, 0x1F, 0x07, 0x83,
  0xF0, 0x7C, 0x7C, 0x3F, 0xC7, 0xE1, 0xF9, 0xF8, 0xFF, 0xCF, 0xC3, 0xE3,
  0xE3, 0xFF, 0xCF, 0x8F, 0xCF, 0xCF, 0xFF, 0x9F, 0xFF, 0x1F, 0x1F, 0x9F,
  0xBF, 0xFC, 0x7C, 0x7E, 0x3F, 0x3F, 0xF9, 0xF8, 0xF8, 0x3E, 0x7F, 0xC3,
  0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0x83,
  0xF0, 0x00, 0x7E, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x83, 0xE0, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x03,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFE, 0x07,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0x07,
  0xF9, 0xFE, 0x3F, 0x87, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0x3F, 0xDF, 0xC3,
  0xF8, 0x0F, 0xEF, 0xC1, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x0F, 0xFE,
  0x01, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0xC3, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x20, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x3E,
  0x00, 0x7F, 0xFE, 0x3E, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xEF, 0x80, 0x1F, 0xCF, 0xC0, 0x3F, 0xCF, 0xC0, 0x3F, 0x87,
  0xE0, 0x1F, 0x07, 0xE0, 0x0E, 0x07, 0xF0, 0x06, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x00, 0x1F,
  0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7,
  0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xE3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0x7E, 0x7F, 0x9F, 0xC7, 0xE3, 0xF8, 0x78,
  0x7F, 0x06, 0x0F, 0xC0, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0x38, 0x03, 0xFC, 0x00,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0xF0, 0x0E,
  0x00, 0xFF, 0x00, 0x40, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x80, 0x01, 0xFE, 0x0E, 0x00, 0x7F, 0xC0, 0xFE,
  0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x20, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x03,
  0xFE, 0x0F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x10, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xFF, 0x00, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFB, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x7F, 0x01,
  0xFF, 0x1F, 0xC0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xC0, 0x7F, 0xF7, 0xF0,
  0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F,
  0x9F, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF0, 0x3F, 0xC3, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0xF0, 0x3E,
  0x07, 0xC0, 0x3F, 0xFC, 0x1F, 0x0F, 0x80, 0xFF, 0xFC, 0x1F, 0x0F, 0x81,
  0xFF, 0xFC, 0x1F, 0x1F, 0x03, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1E, 0x3E,
  0x0F, 0x81, 0xF8, 0x3E, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x03, 0xF0, 0x3C,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E,
  0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xC0,
  0xF8, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3F, 0x3F, 0xE7, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF9,
  0xFF, 0x80, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x0F,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x83, 0xFF,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1E, 0x00, 0xFF, 0xC0, 0x18, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x01, 0xFF, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0x04, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0xFF,
  0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xF8, 0xFF,
  0x00, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x20, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x3F, 0x7E, 0x00, 0x7F, 0xFE, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF7,
  0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x07, 0xEF, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x03,
  0xF3, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0xC0, 0x3F, 0x9F, 0x81, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xF8, 0x7E, 0x1F, 0xC0,
  0x3F, 0x87, 0xC7, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF3, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0x9F, 0x83, 0xF8, 0x07, 0xF0,
  0x7E, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xFF,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0x81,
  0xFC, 0x01, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x01, 0xFB, 0xF0,
  0x07, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0x80, 0x1F, 0xBF, 0x80, 0xFE, 0x00,
  0x7E, 0x7E, 0x03, 0xF8, 0x03, 0xF9, 0xF8, 0x0F, 0xE0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0x7E, 0x3F, 0x80, 0x3F,
  0x81, 0xF8, 0xFE, 0x00, 0xFE, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0x1F, 0xCF,
  0xC0, 0x0F, 0xC0, 0x7F, 0x3F, 0x00, 0x3F, 0x00, 0xFD, 0xFC, 0x01, 0xFC,
  0x03, 0xF7, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xC0, 0x3F, 0x81,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0x7E, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0x00, 0x7F, 0xC0, 0x38, 0x01, 0xFE, 0x00, 0x20, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x10,
  0x00, 0x3F, 0xC0, 0x70, 0x01, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC, 0x7E, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x7D, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xEF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xF3,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x9F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xC7, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC0, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0x83, 0xF3, 0xF8, 0x01,
  0xFC, 0xFC, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x7F,
  0x7E, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xE0, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x01, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x7D, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x3F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFE, 0x7E, 0x03, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0x9F, 0x80, 0x3F, 0xF1, 0xF8, 0x01,
  0xFE, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x1C, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFD, 0xFF, 0xC0,
  0x1F, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF,
  0xFC, 0x07, 0xEF, 0xFF, 0x80, 0xFC, 0x7F, 0xF0, 0x0F, 0xC3, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x1E,
  0x07, 0xF8, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0x07, 0xF8, 0x04,
  0x0F, 0xFC, 0x78, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x07, 0xF0, 0x01, 0xFF,
  0x1F, 0x80, 0x0F, 0xFE, 0x7E, 0x00, 0x7F, 0xFB, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x03, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x7E, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x7F, 0x87,
  0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x7F, 0x80, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x8C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x7F, 0xF3, 0xF0, 0x01,
  0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xC0, 0x07,
  0xFF, 0xBF, 0x80, 0x07, 0xFE, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x03,
  0xFC, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFD,
  0xFF, 0xC0, 0x1F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0x9F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x7E, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0x1F, 0xFC,
  0x3F, 0xF8, 0x07, 0xCF, 0xFF, 0x1F, 0xFE, 0x03, 0xF7, 0xFF, 0xEF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0xE3, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xC1, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x1C,
  0x00, 0x1F, 0x07, 0xF8, 0x01, 0xF1, 0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x03,
  0xF7, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x03, 0xFF, 0x9F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0xFF, 0x07,
  0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0xF8, 0xFF, 0xE0, 0x01, 0xF3,
  0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xE7,
  0xFF, 0x80, 0x0F, 0xCF, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x03,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1,
  0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0xBF, 0x80, 0x3F, 0xF3, 0xF8, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x03,
  0xF1, 0xFC, 0x07, 0xE7, 0xF8, 0x0F, 0x9F, 0xF0, 0x3F, 0x7F, 0xC0, 0x7E,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xE4, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x0E, 0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC2, 0x00, 0x3F, 0x86, 0x00, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF1, 0x83, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x80, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F,
  0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC,
  0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0x7F, 0x8F, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFB, 0xF0, 0x1F, 0xFE, 0x7E, 0x01, 0xFF, 0x8F, 0xC0,
  0x1F, 0xE1, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0,
  0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF7, 0xF0,
  0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0xC0, 0x3F, 0xBF, 0x00, 0xFF, 0x00, 0xFE, 0xFC, 0x07,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xF0, 0x1F, 0xCF, 0xC0, 0xFF, 0xC0, 0x7E,
  0x3F, 0x03, 0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0, 0x7D,
  0xF0, 0x7F, 0x0F, 0xC1, 0xF7, 0xC1, 0xFC, 0x3F, 0x0F, 0xDF, 0x07, 0xE0,
  0xFC, 0x3E, 0x7C, 0x3F, 0x83, 0xF0, 0xF9, 0xF0, 0xFC, 0x0F, 0xC7, 0xE7,
  0xC7, 0xF0, 0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x7C, 0x7E, 0x03,
  0xF3, 0xE1, 0xF3, 0xF8, 0x0F, 0xCF, 0x87, 0xCF, 0xC0, 0x3F, 0x7E, 0x1F,
  0x3F, 0x00, 0xFD, 0xF0, 0x7D, 0xF8, 0x03, 0xFF, 0xC1, 0xF7, 0xE0, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x23, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x5F, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFA, 0x00, 0x3F, 0xFC, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 45, 16, 0, -44 },
  { 97, 20, 16, 24, 6, -44 },
  { 137, 33, 44, 31, 0, -44 },
  { 319, 27, 50, 28, 1, -46 },
  { 488, 39, 45, 44, 3, -44 },
  { 708, 33, 45, 33, 0, -44 },
  { 894, 10, 16, 14, 6, -44 },
  { 914, 21, 54, 17, 1, -44 },
  { 1056, 21, 54, 17, -5, -44 },
  { 1198, 24, 25, 27, 5, -47 },
  { 1273, 25, 29, 30, 3, -36 },
  { 1364, 13, 15, 15, -3, -7 },
  { 1389, 15, 7, 18, 1, -20 },
  { 1403, 9, 9, 15, 0, -8 },
  { 1414, 31, 44, 23, -3, -44 },
  { 1585, 26, 45, 28, 2, -44 },
  { 1732, 19, 44, 28, 6, -44 },
  { 1837, 30, 44, 28, -2, -44 },
  { 2002, 28, 45, 28, 0, -44 },
  { 2160, 29, 44, 28, -1, -44 },
  { 2320, 28, 45, 28, 0, -44 },
  { 2478, 27, 45, 28, 2, -44 },
  { 2630, 29, 44, 28, 2, -44 },
  { 2790, 28, 45, 28, 0, -44 },
  { 2948, 26, 45, 28, 1, -44 },
  { 3095, 14, 35, 15, 0, -34 },
  { 3157, 17, 42, 15, -3, -34 },
  { 3247, 25, 29, 30, 3, -36 },
  { 3338, 25, 17, 30, 3, -30 },
  { 3392, 25, 29, 30, 3, -36 },
  { 3483, 22, 45, 22, 2, -44 },
  { 3607, 40, 49, 42, 2, -44 },
  { 3852, 30, 44, 30, -4, -44 },
  { 4017, 31, 44, 31, 0, -44 },
  { 4188, 30, 45, 29, 3, -44 },
  { 4357, 33, 44, 33, 0, -44 },
  { 4539, 29, 44, 26, 0, -44 },
  { 4699, 29, 44, 25, 0, -44 },
  { 4859, 32, 45, 34, 3, -44 },
  { 5039, 36, 44, 35, 0, -44 },
  { 5237, 25, 44, 19, -2, -44 },
  { 5375, 26, 56, 16, -9, -44 },
  { 5557, 34, 44, 30, 1, -44 },
  { 5744, 21, 44, 25, 0, -44 },
  { 5860, 45, 44, 45, 1, -44 },
  { 6108, 38, 44, 37, 0, -44 },
  { 6317, 32, 45, 36, 3, -44 },
  { 6497, 31, 44, 30, 0, -44 },
  { 6668, 32, 54, 36, 3, -44 },
  { 6884, 29, 44, 30, 1, -44 },
  { 7044, 30, 45, 27, -1, -44 },
  { 7213, 25, 44, 26, 5, -44 },
  { 7351, 32, 45, 34, 3, -44 },
  { 7531, 30, 44, 29, 5, -44 },
  { 7696, 45, 44, 45, 5, -44 },
  { 7944, 36, 44, 28, -3, -44 },
  { 8142, 27, 44, 27, 5, -44 },
  { 8291, 31, 44, 26, -2, -44 },
  { 8462, 24, 54, 18, -2, -44 },
  { 8624, 12, 44, 23, 6, -44 },
  { 8690, 24, 54, 18, -4, -44 },
  { 8852, 28, 26, 28, 0, -44 },
  { 8943, 22, 4, 21, -6, 5 },
  { 8954, 11, 10, 18, 9, -47 },
  { 8968, 28, 35, 30, 2, -34 },
  { 9091, 28, 47, 30, 0, -46 },
  { 9256, 23, 35, 23, 2, -34 },
  { 9357, 30, 47, 30, 2, -46 },
  { 9534, 24, 35, 27, 2, -34 },
  { 9639, 32, 62, 18, -7, -47 },
  { 9887, 31, 49, 30, -1, -34 },
  { 10077, 28, 46, 30, 0, -46 },
  { 10238, 17, 46, 14, 0, -46 },
  { 10336, 25, 61, 14, -8, -46 },
  { 10527, 30, 46, 27, 0, -46 },
  { 10700, 17, 46, 14, 0, -46 },
  { 10798, 42, 34, 44, 0, -34 },
  { 10977, 28, 34, 30, 0, -34 },
  { 11096, 25, 35, 29, 2, -34 },
  { 11206, 31, 48, 30, -3, -34 },
  { 11392, 28, 49, 30, 2, -34 },
  { 11564, 23, 34, 21, 0, -34 },
  { 11662, 23, 35, 23, 0, -34 },
  { 11763, 18, 41, 19, 2, -40 },
  { 11856, 27, 34, 30, 2, -33 },
  { 11971, 25, 33, 25, 3, -33 },
  { 12075, 38, 33, 39, 4, -33 },
  { 12232, 31, 33, 26, -3, -33 },
  { 12360, 33, 48, 25, -5, -33 },
  { 12558, 25, 33, 22, -2, -33 },
  { 12662, 24, 54, 21, 1, -44 },
  { 12824, 6, 61, 26, 10, -47 },
  { 12870, 23, 54, 21, -3, -44 },
  { 13026, 26, 9, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC61PT7B_H_
