#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x06, 0x00,
  0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE7, 0xE1, 0xF3,
  0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F,
  0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xC1, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF3, 0x1C,
  0x07, 0xE3, 0x04, 0x07, 0xE7, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xC6, 0x00,
  0x07, 0xE6, 0x00, 0x07, 0xF6, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1B, 0xF8, 0x00, 0x39, 0xF8,
  0x00, 0x39, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x31, 0xF8, 0x40, 0x31, 0xF8,
  0x70, 0x73, 0xF0, 0x7E, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xE0, 0x1E, 0x01, 0xF1, 0xF0, 0x1F,
  0x00, 0xF8, 0xF8, 0x0F, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0x7C, 0x3E, 0x0F,
  0x80, 0x3C, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC3,
  0xC0, 0x0F, 0x83, 0xC3, 0xE0, 0x07, 0xC3, 0xE3, 0xE0, 0x03, 0xC1, 0xF1,
  0xE0, 0x01, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF8, 0xF1, 0xFE, 0x78, 0x7C,
  0xF9, 0xFF, 0xBE, 0x7C, 0xF9, 0xFF, 0xDF, 0xFE, 0x78, 0xFB, 0xEF, 0xFE,
  0x7C, 0xF8, 0xFB, 0xFE, 0x3C, 0x78, 0x7C, 0xFE, 0x3E, 0x7C, 0x3E, 0x08,
  0x3E, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x0F, 0x80, 0x1F, 0x1F, 0x07, 0x80,
  0x0F, 0x0F, 0x83, 0xC0, 0x0F, 0x87, 0xC3, 0xE0, 0x0F, 0x83, 0xC1, 0xF0,
  0x07, 0xC1, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x78, 0x03, 0xC0, 0x78, 0x7C,
  0x03, 0xE0, 0x3C, 0x3C, 0x03, 0xE0, 0x1E, 0x3E, 0x01, 0xF0, 0x0F, 0xFE,
  0x01, 0xF0, 0x07, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x07,
  0xFF, 0x83, 0xE0, 0xFF, 0xF8, 0x7E, 0x1F, 0xDF, 0x87, 0xE3, 0xF8, 0xFC,
  0xFC, 0x3F, 0x0F, 0xCF, 0xC7, 0xE0, 0x7F, 0xF8, 0x7E, 0x07, 0xFF, 0x87,
  0xE0, 0x7F, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xF0, 0x1F, 0xFE, 0x3F, 0x80, 0xFF,
  0x83, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x04, 0x0F, 0x80, 0xC1, 0xF0, 0x1E,
  0x3C, 0x07, 0xF7, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0x0E, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x7E,
  0x3E, 0x0F, 0xC7, 0xC0, 0xF0, 0xFC, 0x0C, 0x0F, 0x80, 0x81, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07,
  0xE0, 0x7C, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF9,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF, 0x7E,
  0x3F, 0x3F, 0x1F, 0x1F, 0x07, 0x1F, 0x81, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0x83, 0xF8, 0x03,
  0xC0, 0x7F, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xC0,
  0x7F, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x80, 0x07, 0xF0, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xBF, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xCF, 0x80, 0x03, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xE3, 0xF0,
  0x01, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF0, 0x7E,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x04, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x80, 0x0F, 0xE0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF7, 0x80, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x1F, 0xBF,
  0xE0, 0x7E, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0x3F,
  0x8F, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F,
  0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x01, 0xFB, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC7, 0xF0, 0x3F, 0x83, 0xF0, 0x3F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F,
  0xCF, 0xF3, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xDF, 0x81,
  0xFE, 0x7C, 0x01, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x08, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x7F, 0x87, 0x03, 0xF8, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x1F, 0xF8, 0x78, 0x7C, 0x0F, 0xFF,
  0x1F, 0x1E, 0x07, 0xFF, 0x87, 0xCF, 0x83, 0xE1, 0xE1, 0xF3, 0xC1, 0xF0,
  0xF8, 0x7C, 0xF0, 0x78, 0x3C, 0x1E, 0x7C, 0x3E, 0x0F, 0x07, 0x9E, 0x0F,
  0x03, 0xC1, 0xE7, 0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xE0, 0x7C, 0x1E, 0xF0,
  0x78, 0x1E, 0x0F, 0x3C, 0x3E, 0x0F, 0x83, 0xCF, 0x0F, 0x83, 0xE0, 0xF3,
  0xC3, 0xE0, 0xF0, 0x78, 0xF0, 0xF0, 0x7C, 0x1E, 0x3C, 0x3C, 0x1F, 0x0F,
  0x8F, 0x0F, 0x8F, 0xC3, 0xC3, 0xC3, 0xF7, 0x7B, 0xE0, 0xF0, 0x7F, 0xDF,
  0xF0, 0x3C, 0x1F, 0xE7, 0xFC, 0x0F, 0x03, 0xF0, 0xFC, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0,
  0x70, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0x87, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x03, 0xFC, 0x03, 0xF1, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xC0,
  0x3F, 0xC0, 0x04, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x04, 0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF,
  0x87, 0xE0, 0x3F, 0xF8, 0xFE, 0x03, 0xFF, 0x8F, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7D, 0xF0,
  0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFB, 0xE0, 0x3E, 0xFC,
  0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0x9F,
  0x03, 0xE7, 0xE0, 0x3F, 0x3E, 0x0F, 0x8F, 0x80, 0x7E, 0x7C, 0x1F, 0x3F,
  0x00, 0xF8, 0xF8, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0xF8, 0xFC, 0x03, 0xE3,
  0xE3, 0xE1, 0xF0, 0x0F, 0xC7, 0xC7, 0xC3, 0xE0, 0x1F, 0x8F, 0x9F, 0x0F,
  0xC0, 0x3E, 0x0F, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0xC1, 0xF8, 0x07, 0xE0, 0xFF, 0x83,
  0xF0, 0x0F, 0x81, 0xFF, 0x07, 0xE0, 0x1F, 0x03, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0,
  0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x3F,
  0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x3E,
  0x01, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x80, 0x7E,
  0x03, 0xEF, 0x80, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0x03, 0xEF, 0xC0, 0xFC,
  0x03, 0xEF, 0xC0, 0xFC, 0x07, 0xE7, 0xC0, 0xFC, 0x07, 0xE7, 0xC0, 0xF8,
  0x07, 0xC7, 0xE1, 0xF8, 0x07, 0xC7, 0xE1, 0xF8, 0x07, 0xC3, 0xE1, 0xF8,
  0x0F, 0xC3, 0xE1, 0xF0, 0x0F, 0xC3, 0xE1, 0xF0, 0x0F, 0x83, 0xF3, 0xF0,
  0x0F, 0x83, 0xF3, 0xF0, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x81, 0xF3, 0xE0,
  0x1F, 0x81, 0xFB, 0xE0, 0x1F, 0x01, 0xFB, 0xE0, 0x1F, 0x00, 0xFF, 0xE0,
  0x3F, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xC0,
  0x3E, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0,
  0x7E, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80,
  0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x07,
  0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFC, 0x1C, 0x07, 0xF0, 0x04, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0xE0, 0xF0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0xF8, 0x00, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF0, 0x03, 0xF3, 0xE0,
  0x07, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x80,
  0x3F, 0x1F, 0x00, 0xFF, 0x00, 0xFC, 0x3E, 0x01, 0xFE, 0x01, 0xF8, 0x7C,
  0x03, 0xFC, 0x03, 0xF0, 0xF8, 0x0F, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0xF0,
  0x1F, 0x83, 0xE0, 0x7D, 0xE0, 0x7E, 0x07, 0xC0, 0xFB, 0xC0, 0xFC, 0x0F,
  0x81, 0xFF, 0x81, 0xF0, 0x1F, 0x07, 0xDF, 0x07, 0xE0, 0x3E, 0x0F, 0xBE,
  0x0F, 0xC0, 0x7C, 0x3E, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0xF8, 0x7E, 0x01,
  0xF0, 0xF9, 0xF0, 0xF8, 0x03, 0xE3, 0xE3, 0xE3, 0xF0, 0x07, 0xC7, 0xC7,
  0xC7, 0xE0, 0x0F, 0x9F, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x1F, 0x3F, 0x00,
  0x3E, 0x7C, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x7D, 0xF8, 0x01, 0xFB, 0xE0,
  0xFB, 0xF0, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x0F,
  0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xCF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF1, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x1F, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x1F, 0x01, 0xFF, 0x9F, 0x03, 0xFF,
  0xBF, 0x07, 0xFF, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x3F, 0xE3,
  0xE0, 0x1F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x60, 0x03, 0xF3, 0xF8, 0x03, 0xE7,
  0xFC, 0x03, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0xFF, 0x07, 0xF8,
  0x7F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x03,
  0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0xEF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7D, 0xFF,
  0xC0, 0xF9, 0xFF, 0x80, 0xF8, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xE7,
  0x87, 0xF0, 0x11, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x30, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x0C, 0x1F, 0x80, 0x0F, 0xF3, 0xF0, 0x03, 0xFF, 0x7E, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xF3, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0xDF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xC0, 0x0F, 0xFC, 0xF8, 0x00, 0xFE, 0x1E,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF3, 0xF0,
  0x1F, 0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0xFE, 0xFC,
  0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x10, 0xFF, 0x0F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF1, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF1, 0xF0, 0x07,
  0xFE, 0x7C, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xE0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0x7E, 0x1F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0x80, 0x3F, 0xF7, 0xE0, 0x07,
  0xF1, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x08, 0x00, 0xFE, 0x03, 0x80, 0x7F,
  0x00, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x03, 0xF3, 0xFC, 0x03, 0xE7, 0xFC,
  0x03, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0x07, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8,
  0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF1,
  0xFC, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x01,
  0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x3E, 0x3F, 0x83, 0xFC, 0x03, 0xEF,
  0xFC, 0x7F, 0xE0, 0x3D, 0xFF, 0xEF, 0xFE, 0x07, 0xDF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xCF, 0xFE, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x07, 0xE1,
  0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0x83,
  0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0xE3, 0xFC, 0x03, 0xC7, 0xFC, 0x03, 0xCF, 0xFE,
  0x07, 0xDF, 0xFE, 0x07, 0xFE, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x3F,
  0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0x3F,
  0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3E, 0x3F, 0x80, 0x0F, 0x9F, 0xF0, 0x03, 0xEF, 0xFE, 0x01,
  0xF7, 0xFF, 0x80, 0x7F, 0xC7, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xF7,
  0xFF, 0x00, 0x7C, 0xFF, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xC0, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0x1F, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xF3, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xF7, 0xE0, 0x3F, 0xE7, 0xE0,
  0x1F, 0xC7, 0xC0, 0x02, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x3F, 0x03, 0xE7, 0xE0, 0x3E,
  0xFE, 0x07, 0xDF, 0xE0, 0x7F, 0xFE, 0x07, 0xFE, 0x40, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x1C, 0x1F, 0x80, 0x41, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x80,
  0x3F, 0x0C, 0x03, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xDC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x30,
  0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7C,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC,
  0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xF7,
  0xC1, 0xFF, 0xCF, 0x81, 0xFF, 0x9E, 0x01, 0xFC, 0x7C, 0x00, 0x40, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x1F, 0xBF,
  0x03, 0xFC, 0x0F, 0xDF, 0x81, 0xFE, 0x07, 0xCF, 0xC1, 0xFF, 0x07, 0xE7,
  0xE0, 0xFF, 0x83, 0xE3, 0xF0, 0x7F, 0x83, 0xF1, 0xF8, 0x7F, 0xC1, 0xF8,
  0xFC, 0x3D, 0xE0, 0xF8, 0x7E, 0x3E, 0xF0, 0xFC, 0x3F, 0x1F, 0x78, 0x7C,
  0x1F, 0x9F, 0x3C, 0x7E, 0x0F, 0xCF, 0x9E, 0x3E, 0x07, 0xE7, 0x8F, 0x1F,
  0x03, 0xE7, 0xC7, 0x9F, 0x81, 0xF3, 0xE3, 0xCF, 0x80, 0xF9, 0xE1, 0xEF,
  0xC0, 0x7D, 0xF0, 0xF7, 0xC0, 0x3E, 0xF0, 0x7B, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0x20, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 38, 13, 0, -37 },
  { 73, 17, 13, 20, 5, -37 },
  { 101, 28, 37, 27, 0, -37 },
  { 231, 24, 43, 24, 0, -40 },
  { 360, 33, 38, 37, 3, -38 },
  { 517, 28, 39, 28, 0, -38 },
  { 654, 8, 13, 12, 5, -37 },
  { 667, 17, 45, 15, 1, -37 },
  { 763, 17, 46, 15, -4, -38 },
  { 861, 19, 22, 23, 5, -40 },
  { 914, 22, 25, 25, 2, -31 },
  { 983, 11, 13, 12, -3, -6 },
  { 1001, 13, 6, 15, 1, -17 },
  { 1011, 8, 8, 12, 0, -7 },
  { 1019, 26, 37, 19, -3, -37 },
  { 1140, 23, 39, 24, 1, -38 },
  { 1253, 17, 37, 24, 5, -37 },
  { 1332, 26, 38, 24, -2, -38 },
  { 1456, 24, 39, 24, 0, -38 },
  { 1573, 25, 37, 24, -1, -37 },
  { 1689, 24, 38, 24, 0, -37 },
  { 1803, 23, 39, 24, 2, -38 },
  { 1916, 24, 37, 24, 2, -37 },
  { 2027, 24, 39, 24, 0, -38 },
  { 2144, 22, 39, 24, 1, -38 },
  { 2252, 12, 30, 13, 0, -29 },
  { 2297, 15, 36, 13, -3, -29 },
  { 2365, 22, 25, 25, 2, -31 },
  { 2434, 22, 15, 25, 2, -26 },
  { 2476, 22, 25, 25, 2, -31 },
  { 2545, 19, 39, 19, 2, -38 },
  { 2638, 34, 41, 36, 2, -37 },
  { 2813, 25, 37, 26, -3, -37 },
  { 2929, 26, 37, 26, 0, -37 },
  { 3050, 26, 39, 25, 2, -38 },
  { 3177, 28, 37, 29, 0, -37 },
  { 3307, 25, 37, 22, 0, -37 },
  { 3423, 25, 37, 21, 0, -37 },
  { 3539, 28, 39, 29, 2, -38 },
  { 3676, 31, 37, 29, 0, -37 },
  { 3820, 22, 37, 16, -2, -37 },
  { 3922, 23, 48, 13, -8, -37 },
  { 4060, 30, 37, 25, 0, -37 },
  { 4199, 18, 37, 21, 0, -37 },
  { 4283, 39, 37, 38, 0, -37 },
  { 4464, 32, 37, 31, 0, -37 },
  { 4612, 28, 39, 30, 2, -38 },
  { 4749, 26, 37, 25, 0, -37 },
  { 4870, 28, 47, 30, 2, -38 },
  { 5035, 26, 37, 26, 0, -37 },
  { 5156, 24, 39, 23, 0, -38 },
  { 5273, 22, 37, 22, 4, -37 },
  { 5375, 28, 38, 29, 2, -37 },
  { 5508, 25, 37, 25, 5, -37 },
  { 5624, 39, 37, 39, 4, -37 },
  { 5805, 31, 37, 24, -3, -37 },
  { 5949, 23, 37, 23, 5, -37 },
  { 6056, 27, 37, 22, -2, -37 },
  { 6181, 21, 45, 15, -2, -37 },
  { 6300, 11, 37, 19, 5, -37 },
  { 6351, 21, 45, 15, -4, -37 },
  { 6470, 24, 22, 24, 0, -37 },
  { 6536, 19, 3, 18, -5, 5 },
  { 6544, 9, 8, 15, 8, -40 },
  { 6553, 24, 30, 25, 1, -29 },
  { 6643, 24, 41, 25, 0, -40 },
  { 6766, 19, 30, 20, 2, -29 },
  { 6838, 27, 41, 25, 1, -40 },
  { 6977, 20, 30, 23, 2, -29 },
  { 7052, 27, 52, 15, -6, -40 },
  { 7228, 26, 41, 25, -1, -29 },
  { 7362, 24, 40, 25, 0, -40 },
  { 7482, 14, 39, 12, 0, -39 },
  { 7551, 21, 51, 12, -7, -39 },
  { 7685, 25, 40, 23, 0, -40 },
  { 7810, 15, 40, 12, 0, -40 },
  { 7885, 36, 29, 38, 0, -29 },
  { 8016, 24, 29, 25, 0, -29 },
  { 8103, 21, 30, 25, 2, -29 },
  { 8182, 26, 41, 25, -2, -29 },
  { 8316, 24, 41, 25, 1, -29 },
  { 8439, 20, 29, 18, 0, -29 },
  { 8512, 20, 30, 20, 0, -29 },
  { 8587, 15, 35, 16, 2, -34 },
  { 8653, 23, 29, 25, 2, -28 },
  { 8737, 21, 28, 21, 3, -28 },
  { 8811, 33, 28, 33, 3, -28 },
  { 8927, 26, 28, 22, -2, -28 },
  { 9018, 28, 40, 22, -4, -28 },
  { 9158, 22, 28, 19, -2, -28 },
  { 9235, 20, 45, 18, 1, -37 },
  { 9348, 5, 52, 22, 8, -40 },
  { 9381, 20, 45, 18, -3, -37 },
  { 9494, 22, 8, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC52PT7B_H_
