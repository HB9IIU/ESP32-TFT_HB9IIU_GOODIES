#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x00, 0x01, 0x8E,
  0x38, 0x76, 0xCD, 0x9B, 0x7C, 0xD9, 0x80, 0x06, 0x60, 0x66, 0x06, 0x40,
  0x4C, 0x0C, 0xC3, 0xFF, 0x09, 0x81, 0x98, 0x19, 0x81, 0x90, 0xFF, 0xC3,
  0x30, 0x32, 0x06, 0x60, 0x66, 0x06, 0x60, 0x01, 0x00, 0xC0, 0xFC, 0x7F,
  0x3A, 0x8C, 0x83, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x2E, 0x0B, 0xB2,
  0xEF, 0xF1, 0xF8, 0x10, 0x04, 0x00, 0x1C, 0x18, 0xF0, 0xC6, 0x62, 0x19,
  0x98, 0x44, 0xC3, 0x33, 0x0C, 0xD9, 0xB3, 0x4F, 0xFB, 0x6D, 0xDB, 0x30,
  0x6C, 0xC3, 0x33, 0x0C, 0xCC, 0x63, 0x63, 0x0F, 0x9C, 0x3C, 0x07, 0x80,
  0xFC, 0x1D, 0xC1, 0x8C, 0x19, 0xC1, 0xD8, 0x1F, 0x00, 0xE0, 0x3E, 0x77,
  0x66, 0x67, 0xEE, 0x3C, 0xE3, 0xCE, 0x38, 0xFF, 0xC7, 0xCE, 0x76, 0x66,
  0xCC, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0xE0, 0x0C, 0x0C, 0x48, 0xFB, 0x7F, 0x38, 0x7C, 0xEE, 0x44,
  0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00,
  0x39, 0x9C, 0xCE, 0x60, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x0F, 0x0F, 0x8E, 0xEE, 0x77, 0x1B,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xB1, 0xD8, 0xEC, 0x66, 0x73, 0xF0, 0xF0,
  0x06, 0x3C, 0xFB, 0xEE, 0xC9, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86,
  0x0C, 0x38, 0x07, 0x81, 0xF8, 0x73, 0x84, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xE7, 0xFC,
  0x0F, 0x8F, 0xF1, 0x9C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x78, 0x1F, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0xA1, 0xCF, 0xE3, 0xF0, 0x01, 0xC0, 0x70, 0x3C,
  0x1E, 0x05, 0x83, 0x61, 0xB8, 0xCE, 0x33, 0x18, 0xCC, 0x37, 0xFE, 0xFF,
  0x81, 0x80, 0x60, 0x38, 0x0F, 0xC7, 0xF1, 0xFC, 0x60, 0x18, 0x0E, 0x03,
  0xE0, 0xFC, 0x27, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xA1, 0xCF, 0xE3, 0xF0,
  0x07, 0xC3, 0xE1, 0xC0, 0xE0, 0x70, 0x18, 0x06, 0xE3, 0xFC, 0xE3, 0x38,
  0xCC, 0x33, 0x0C, 0xC7, 0x39, 0x8F, 0xE1, 0xF0, 0x3F, 0xDF, 0xF7, 0xF8,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0x07, 0x87, 0xF1, 0x9C, 0xE3, 0x38, 0xCE, 0x71,
  0xF8, 0x3C, 0x3F, 0x1C, 0xC6, 0x3B, 0x86, 0xE3, 0xB8, 0xE7, 0xF0, 0xF8,
  0x0F, 0x07, 0xE3, 0x9C, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xCF, 0x3F, 0x8F,
  0x60, 0x38, 0x0C, 0x07, 0x03, 0x8F, 0xC3, 0xE0, 0x19, 0xCE, 0x00, 0x00,
  0x00, 0x03, 0x39, 0xC0, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC3,
  0x1C, 0x63, 0x8C, 0x00, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x1C, 0x3C, 0xF8, 0xF0, 0x60, 0x00, 0x3C,
  0x7E, 0x67, 0x07, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x70, 0x60, 0x00, 0x00,
  0xE0, 0xE0, 0xC0, 0x01, 0xE0, 0x1F, 0xC1, 0xC1, 0x8E, 0x03, 0x31, 0x8D,
  0x9F, 0xB6, 0x6C, 0xF3, 0x33, 0xCC, 0xCF, 0x63, 0x2D, 0x99, 0xA6, 0x66,
  0xCE, 0xF3, 0x11, 0x0C, 0x00, 0x18, 0x10, 0x7F, 0x80, 0x7C, 0x00, 0x01,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x1D, 0x83, 0x30, 0xE6, 0x1C, 0xC3,
  0xF8, 0xFF, 0x1F, 0xE7, 0x0C, 0xC1, 0xB8, 0x37, 0x07, 0x1F, 0x83, 0xF8,
  0x73, 0x8C, 0x71, 0x8E, 0x71, 0xCE, 0x71, 0xFC, 0x3F, 0x86, 0x39, 0xC7,
  0x38, 0xE6, 0x1C, 0xC7, 0x3F, 0xE7, 0xF0, 0x07, 0xC1, 0xFC, 0x73, 0x1C,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE2, 0x1F, 0xC1, 0xF8, 0x1F, 0x01, 0xFC, 0x1F, 0xE1, 0x86, 0x18,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x63, 0x0E, 0x70, 0xE7, 0x0C, 0x61,
  0xC6, 0x78, 0xFF, 0x0F, 0xC0, 0x1F, 0xC7, 0xF1, 0xFC, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xFE, 0x3F, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x4F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF1, 0xFC, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xFE, 0x3F,
  0x0F, 0xC7, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x07, 0xE0, 0xFF,
  0x1E, 0x63, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x3E, 0xE3, 0xCE, 0x3C,
  0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x18, 0x7F, 0x83, 0xF8, 0x1C, 0x38, 0xE1,
  0xC7, 0x0C, 0x30, 0x61, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0xFC, 0x3F, 0xE1,
  0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x30, 0x63, 0x87, 0x1C, 0x38, 0x1F,
  0x8F, 0xC1, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0x81, 0xC1, 0xF1, 0xF8, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x3E, 0x1E, 0x00, 0x1C, 0x38, 0xE3, 0x87, 0x38, 0x33, 0x81, 0x9C,
  0x1D, 0xC0, 0xFC, 0x06, 0xC0, 0x3E, 0x01, 0xF8, 0x1D, 0xC0, 0xE6, 0x06,
  0x38, 0x31, 0xC1, 0x8E, 0x1C, 0x30, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x61, 0xFE, 0xFE, 0x1E, 0x07,
  0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0xD8, 0x6C, 0x6C, 0x36, 0x6E, 0x1B, 0x37, 0x1D, 0xB3, 0x0C, 0xD9, 0x86,
  0x78, 0xC3, 0x3C, 0xE1, 0x9C, 0x71, 0xC6, 0x30, 0x1C, 0x1C, 0x78, 0x61,
  0xE1, 0x87, 0x86, 0x1E, 0x38, 0xFC, 0xE3, 0x73, 0x0C, 0xCC, 0x33, 0x30,
  0xCD, 0xC7, 0x3F, 0x18, 0x78, 0x61, 0xE1, 0x87, 0x8E, 0x1E, 0x38, 0x70,
  0x07, 0x81, 0xFE, 0x1C, 0xE3, 0x86, 0x70, 0x77, 0x07, 0x60, 0x6E, 0x06,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0,
  0x1F, 0x83, 0xF8, 0x7F, 0x8C, 0x71, 0x86, 0x71, 0xCE, 0x39, 0xCE, 0x3F,
  0xC7, 0xE1, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x07, 0x81,
  0xFE, 0x1C, 0xE3, 0x86, 0x70, 0x77, 0x07, 0x60, 0x6E, 0x06, 0xE0, 0xEE,
  0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x1F, 0x03, 0xF8, 0x77, 0x8C, 0x71, 0x8E, 0x71,
  0xCE, 0x31, 0x9E, 0x3F, 0x87, 0xE1, 0xDC, 0x39, 0x86, 0x30, 0xC7, 0x18,
  0xE7, 0x0C, 0x07, 0x87, 0xF3, 0xDC, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x21, 0xCF, 0xE3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0x38, 0x73, 0x87, 0x38, 0x63, 0x06, 0x30, 0xE7,
  0x0E, 0x70, 0xC6, 0x0C, 0x61, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E,
  0x38, 0xFF, 0x07, 0xE0, 0xC0, 0xF8, 0x3B, 0x86, 0x71, 0xCE, 0x39, 0xC6,
  0x39, 0xC7, 0x30, 0xEE, 0x1D, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xC1, 0x83, 0xC1, 0x87, 0xC3, 0x86, 0xC3, 0x8E, 0xC7, 0x8C,
  0xC7, 0x8C, 0xCF, 0x9C, 0xCD, 0x98, 0xCD, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0,
  0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0x1C, 0x38,
  0x63, 0x83, 0x18, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x07, 0xE0, 0x37, 0x03, 0xB8, 0x38, 0xC1, 0x86, 0x1C, 0x38,
  0xE1, 0xF8, 0xEE, 0x33, 0x9C, 0x66, 0x1B, 0x86, 0xC1, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0x87, 0xC3, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x1E, 0x1F, 0x00, 0xC7, 0x18, 0xC6, 0x31, 0x8C,
  0x73, 0x8C, 0x63, 0x18, 0xC7, 0x0F, 0x87, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x1E, 0x1F, 0x00, 0x02, 0x01, 0xC0, 0x70, 0x3C, 0x1B, 0x06, 0x63,
  0x19, 0xC6, 0x60, 0xF0, 0x30, 0xFF, 0xE6, 0x73, 0x1D, 0xCF, 0xE7, 0x39,
  0x8E, 0xE3, 0xB8, 0xEC, 0x33, 0x0C, 0xC7, 0x33, 0xCF, 0xE1, 0xD8, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0xE3, 0xFC, 0xE7, 0x38, 0xCC, 0x37,
  0x1D, 0xC7, 0x71, 0xD8, 0x67, 0x3B, 0xFC, 0xDE, 0x00, 0x1F, 0x3F, 0x71,
  0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE4, 0xFC, 0x7C, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x3B, 0x8F, 0xE3, 0x9C, 0x63, 0x9C, 0x73, 0x8E,
  0x61, 0x8C, 0x31, 0x8E, 0x31, 0xC7, 0xF0, 0x76, 0x00, 0x1E, 0x3F, 0x73,
  0x63, 0xE7, 0xFE, 0xF8, 0xC0, 0xC0, 0xC2, 0xFE, 0x7C, 0x00, 0xF0, 0x1F,
  0x01, 0x90, 0x38, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x0E, 0xE3, 0xF8, 0xE7, 0x18, 0xE7,
  0x1C, 0xE3, 0x98, 0x63, 0x0C, 0x63, 0x8C, 0xF1, 0xFC, 0x3D, 0x80, 0x30,
  0x0E, 0x21, 0x87, 0xF0, 0xFC, 0x00, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0xE3, 0xFC, 0xE7, 0x39, 0xCC, 0x77, 0x1D, 0xC6, 0x61, 0x98, 0xE6,
  0x3B, 0x8C, 0xE3, 0x00, 0x08, 0x71, 0xC0, 0x00, 0x63, 0x8E, 0x30, 0xC7,
  0x1C, 0x71, 0x86, 0x38, 0xE0, 0x01, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x06, 0x07, 0x0F, 0x87, 0x80, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x31, 0xCE, 0x71, 0xDC, 0x37, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0x60,
  0xCE, 0x19, 0xC7, 0x38, 0xE3, 0x00, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x8E,
  0x30, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE0, 0x1B, 0x9E, 0x6F, 0xFC, 0xE7,
  0x99, 0xCE, 0x33, 0x1C, 0xEE, 0x31, 0xDC, 0x63, 0x31, 0xC6, 0x63, 0x8C,
  0xC6, 0x3B, 0x8C, 0x77, 0x18, 0xC0, 0x1B, 0x8D, 0xF3, 0x9C, 0xE7, 0x31,
  0xDC, 0x77, 0x19, 0x86, 0x63, 0x98, 0xEE, 0x33, 0x8C, 0x1E, 0x1F, 0x9C,
  0xEC, 0x7E, 0x3E, 0x1F, 0x0F, 0x86, 0xC7, 0x63, 0x3F, 0x8F, 0x80, 0x0D,
  0xC3, 0x7C, 0x73, 0x8E, 0x31, 0x86, 0x71, 0xCE, 0x39, 0xC7, 0x30, 0xC7,
  0x39, 0xFE, 0x3F, 0x86, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x00, 0x1D,
  0xCF, 0xE7, 0x39, 0x8E, 0xE3, 0xB8, 0xEC, 0x33, 0x0C, 0xC7, 0x31, 0xCF,
  0xE3, 0xD8, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x1B, 0x37, 0x3D,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x1F, 0x3F, 0x71,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x0E, 0x8E, 0xFC, 0xFC, 0x18, 0x63, 0x1F,
  0xFD, 0xC6, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0xCF, 0x00, 0x71, 0xDC, 0x66,
  0x19, 0x8E, 0x63, 0xB8, 0xCE, 0x33, 0x1C, 0xC7, 0x33, 0xCF, 0xE3, 0xD8,
  0xE3, 0xF1, 0xF8, 0xDC, 0xEE, 0x63, 0x71, 0xB0, 0xF8, 0x78, 0x3C, 0x1C,
  0x0E, 0x00, 0xE3, 0x8F, 0x9E, 0x7E, 0x79, 0xBB, 0x4E, 0xED, 0x33, 0xB4,
  0xCF, 0xB6, 0x3E, 0xD8, 0xD3, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0x18,
  0xE3, 0x98, 0x77, 0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0xF8, 0x3F, 0x06,
  0x61, 0xCC, 0x71, 0xC0, 0x1C, 0x31, 0xC7, 0x1C, 0x60, 0xCE, 0x0C, 0xC0,
  0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x30, 0x38, 0x38, 0x1F, 0xDF, 0xC0, 0x01, 0x83, 0xC3, 0x81,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x38, 0x38, 0x3C, 0x06, 0x03, 0x81, 0x80,
  0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x08, 0x1E, 0x0E, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0E, 0x07, 0x0F, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x30, 0xF0, 0xE0, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 12, 16, 11, 0, -16 },
  { 43, 10, 18, 10, 0, -17 },
  { 66, 14, 16, 16, 1, -16 },
  { 94, 12, 16, 12, 0, -16 },
  { 118, 4, 6, 5, 2, -16 },
  { 121, 8, 19, 6, 0, -16 },
  { 140, 8, 19, 6, -2, -16 },
  { 159, 8, 9, 10, 2, -17 },
  { 168, 9, 10, 11, 1, -13 },
  { 180, 5, 6, 5, -1, -3 },
  { 184, 6, 2, 6, 0, -7 },
  { 186, 3, 3, 5, 0, -3 },
  { 188, 11, 16, 8, -1, -16 },
  { 210, 9, 16, 10, 1, -16 },
  { 228, 7, 16, 10, 2, -16 },
  { 242, 11, 16, 10, -1, -16 },
  { 264, 10, 16, 10, 0, -16 },
  { 284, 10, 16, 10, 0, -16 },
  { 304, 10, 16, 10, 0, -16 },
  { 324, 10, 16, 10, 1, -16 },
  { 344, 10, 16, 10, 1, -16 },
  { 364, 10, 16, 10, 0, -16 },
  { 384, 10, 16, 10, 0, -16 },
  { 404, 5, 12, 5, 0, -12 },
  { 412, 6, 15, 5, -1, -12 },
  { 424, 9, 10, 11, 1, -13 },
  { 436, 9, 6, 11, 1, -11 },
  { 443, 9, 10, 11, 1, -13 },
  { 455, 8, 16, 8, 1, -16 },
  { 471, 14, 18, 15, 1, -16 },
  { 503, 11, 16, 11, -1, -16 },
  { 525, 11, 16, 11, 0, -16 },
  { 547, 11, 16, 10, 1, -16 },
  { 569, 12, 16, 12, 0, -16 },
  { 593, 10, 16, 9, 0, -16 },
  { 613, 10, 16, 9, 0, -16 },
  { 633, 12, 16, 12, 1, -16 },
  { 657, 13, 16, 12, 0, -16 },
  { 683, 9, 16, 7, -1, -16 },
  { 701, 9, 20, 6, -3, -16 },
  { 724, 13, 16, 11, 0, -16 },
  { 750, 8, 16, 9, 0, -16 },
  { 766, 17, 16, 16, 0, -16 },
  { 800, 14, 16, 13, 0, -16 },
  { 828, 12, 16, 13, 1, -16 },
  { 852, 11, 16, 11, 0, -16 },
  { 874, 12, 20, 13, 1, -16 },
  { 904, 11, 16, 11, 0, -16 },
  { 926, 10, 16, 10, 0, -16 },
  { 946, 9, 16, 9, 2, -16 },
  { 964, 12, 16, 12, 1, -16 },
  { 988, 11, 16, 11, 2, -16 },
  { 1010, 16, 16, 16, 2, -16 },
  { 1042, 13, 16, 10, -1, -16 },
  { 1068, 10, 16, 10, 2, -16 },
  { 1088, 12, 16, 9, -1, -16 },
  { 1112, 9, 20, 6, -1, -16 },
  { 1135, 5, 16, 8, 2, -16 },
  { 1145, 9, 20, 6, -2, -16 },
  { 1168, 10, 10, 10, 0, -16 },
  { 1181, 8, 1, 8, -2, 2 },
  { 1182, 4, 4, 6, 3, -17 },
  { 1184, 10, 12, 11, 1, -12 },
  { 1199, 10, 17, 11, 0, -17 },
  { 1221, 8, 12, 8, 1, -12 },
  { 1233, 11, 17, 11, 1, -17 },
  { 1257, 8, 12, 10, 1, -12 },
  { 1269, 12, 22, 6, -3, -17 },
  { 1302, 11, 17, 11, 0, -12 },
  { 1326, 10, 17, 11, 0, -17 },
  { 1348, 6, 17, 5, 0, -17 },
  { 1361, 9, 22, 5, -3, -17 },
  { 1386, 11, 17, 10, 0, -17 },
  { 1410, 6, 17, 5, 0, -17 },
  { 1423, 15, 12, 16, 0, -12 },
  { 1446, 10, 12, 11, 0, -12 },
  { 1461, 9, 12, 10, 1, -12 },
  { 1475, 11, 17, 11, -1, -12 },
  { 1499, 10, 17, 11, 1, -12 },
  { 1521, 8, 12, 7, 0, -12 },
  { 1533, 8, 12, 8, 0, -12 },
  { 1545, 6, 15, 7, 1, -15 },
  { 1557, 10, 12, 11, 1, -12 },
  { 1572, 9, 12, 9, 1, -12 },
  { 1586, 14, 12, 14, 1, -12 },
  { 1607, 11, 12, 9, -1, -12 },
  { 1624, 12, 17, 9, -2, -12 },
  { 1650, 9, 12, 8, -1, -12 },
  { 1664, 9, 19, 7, 0, -16 },
  { 1686, 2, 22, 9, 4, -17 },
  { 1692, 8, 19, 7, -1, -16 },
  { 1711, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC22PT7B_H_
