#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0xDF, 0x1F, 0x7C, 0x79, 0xE1, 0xE7, 0x8F,
  0x9E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1C, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x03,
  0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x70,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xDC,
  0xC0, 0xF9, 0x84, 0x0F, 0x98, 0x00, 0xF9, 0x80, 0x0F, 0x98, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x06, 0xF8, 0x00, 0x67, 0x80,
  0x0C, 0x78, 0x00, 0xCF, 0x84, 0x0C, 0xF8, 0x78, 0xDF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xEF, 0x81, 0xE0, 0x3C, 0x78,
  0x1C, 0x03, 0xC7, 0x83, 0xC0, 0x38, 0x78, 0x78, 0x07, 0x87, 0x87, 0x80,
  0x78, 0x78, 0xF0, 0x07, 0x87, 0x0E, 0x00, 0x70, 0xF1, 0xE0, 0x0F, 0x0F,
  0x3C, 0x00, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x79, 0xFC, 0xF1, 0xE7, 0x3F,
  0xE7, 0xBC, 0xF3, 0xFE, 0x7F, 0xDE, 0x79, 0xE7, 0xF9, 0xE7, 0x8F, 0x3E,
  0x3C, 0xF0, 0xE0, 0x03, 0x8F, 0x0E, 0x00, 0x78, 0xE1, 0xE0, 0x0F, 0x1E,
  0x1E, 0x00, 0xF1, 0xE1, 0xE0, 0x1E, 0x1E, 0x1E, 0x01, 0xE1, 0xE1, 0xC0,
  0x3C, 0x1E, 0x3C, 0x07, 0x81, 0xE3, 0xC0, 0x78, 0x1E, 0x78, 0x0F, 0x01,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1E, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x1F, 0x0F, 0xFC, 0x3E, 0x3F, 0xF8,
  0x78, 0xFD, 0xF9, 0xF1, 0xF1, 0xF3, 0xC7, 0xC3, 0xFF, 0x8F, 0x83, 0xFE,
  0x3E, 0x07, 0xFC, 0x7C, 0x07, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83,
  0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x3E, 0x07,
  0xF8, 0x7E, 0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xE3,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x01, 0xD0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x61,
  0xE0, 0x79, 0xC0, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3E, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0x38, 0x7C, 0x10,
  0x70, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x78, 0x3C, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x3D,
  0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x07,
  0xE7, 0xC3, 0xF1, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0xC0,
  0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F,
  0x87, 0xCF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF,
  0xBF, 0xBC, 0x7D, 0xF0, 0xC7, 0xC2, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x3F, 0x01, 0xC0, 0xF8, 0x04,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xC7, 0xF0, 0x20, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x43, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x88, 0x01, 0xF0, 0xC0, 0x7F,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3F, 0xE0, 0x03,
  0xDF, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xE0,
  0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83,
  0xE0, 0x78, 0x1F, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x08, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x88,
  0x03, 0xF0, 0xE0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xF8, 0x20, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0x80, 0x3E, 0xFE, 0x03,
  0xDF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x1F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8,
  0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xCF,
  0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x83, 0xF3, 0xE1, 0xFC, 0xFC,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFE, 0xF8, 0x1E, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x08,
  0x1F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x01,
  0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x60, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF3, 0x87, 0xE4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x70,
  0xE0, 0x7F, 0xC7, 0x1E, 0x0F, 0xFC, 0x71, 0xC1, 0xE3, 0x87, 0x3C, 0x3C,
  0x78, 0x73, 0xC7, 0x87, 0x87, 0x38, 0x70, 0x78, 0x77, 0x8F, 0x07, 0x0F,
  0x78, 0xF0, 0xF0, 0xF7, 0x0E, 0x0F, 0x0E, 0x70, 0xE0, 0xF0, 0xE7, 0x1E,
  0x0E, 0x1E, 0xF1, 0xE1, 0xE1, 0xCF, 0x1E, 0x1E, 0x3C, 0xF1, 0xE3, 0xE3,
  0x8F, 0x0F, 0xFF, 0xF8, 0xF0, 0xFE, 0x7F, 0x0F, 0x07, 0xC7, 0xC0, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x60, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x7E, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE3, 0xFC, 0x0F,
  0x83, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7C, 0x1F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC1, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x8E,
  0x07, 0xF0, 0x10, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x3F,
  0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xF3, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xCF, 0xC0, 0xFC, 0x01, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xFE, 0x7E, 0x0F,
  0xFC, 0xFC, 0x1F, 0xF1, 0xF0, 0x3F, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x81, 0xFC, 0x1F, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03,
  0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xBC, 0x07, 0xBE, 0x07,
  0xBC, 0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x7C, 0x0F, 0xBC, 0x0F, 0x7C, 0x0F,
  0xBC, 0x1F, 0x7C, 0x0F, 0x3C, 0x1E, 0x78, 0x0F, 0x3C, 0x3E, 0xF8, 0x1F,
  0x3C, 0x3C, 0xF8, 0x1F, 0x3C, 0x7C, 0xF8, 0x1F, 0x3C, 0x78, 0xF8, 0x1E,
  0x3C, 0xF8, 0xF0, 0x1E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3D, 0xF1, 0xF0, 0x3E,
  0x3D, 0xE1, 0xF0, 0x3E, 0x3F, 0xE1, 0xF0, 0x3C, 0x1F, 0xC1, 0xE0, 0x3C,
  0x1F, 0xC3, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x01,
  0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x01, 0xFC, 0x03,
  0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xE0, 0x3F,
  0xE0, 0x3C, 0x07, 0xBC, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x1E, 0xF8, 0x3E,
  0x07, 0xDF, 0x07, 0x80, 0xF9, 0xE0, 0xF0, 0x1F, 0x3C, 0x3E, 0x03, 0xC7,
  0xC7, 0xC0, 0x78, 0xF8, 0xF8, 0x1F, 0x0F, 0x1E, 0x03, 0xE1, 0xE3, 0xC0,
  0x7C, 0x3E, 0xF8, 0x0F, 0x07, 0xDF, 0x01, 0xE0, 0xFB, 0xE0, 0x7C, 0x0F,
  0x78, 0x0F, 0x81, 0xEF, 0x01, 0xF0, 0x3F, 0xE0, 0x3C, 0x07, 0xFC, 0x0F,
  0x80, 0x7F, 0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0x80, 0x3F,
  0x80, 0xF0, 0x07, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8,
  0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFB,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8,
  0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7E,
  0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3E, 0x7F, 0x81, 0xF0, 0xFC, 0x0F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F,
  0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x3F, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x7C, 0x01, 0xF1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03,
  0xE3, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x04, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x08, 0x03, 0xF0, 0xF0, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9,
  0xF0, 0x07, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x0F, 0xC0, 0x7C,
  0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0x78, 0xF8, 0x1F, 0xC0, 0xF8,
  0xF8, 0x1F, 0xC0, 0xF8, 0xF0, 0x3F, 0xC1, 0xF0, 0xF0, 0x3F, 0xC1, 0xF0,
  0xF0, 0x7B, 0xC1, 0xE0, 0xF0, 0x7B, 0xC3, 0xE0, 0xF0, 0x7B, 0xC3, 0xE0,
  0xF0, 0xF3, 0xC7, 0xC0, 0xF0, 0xF3, 0xC7, 0xC0, 0xF1, 0xE3, 0xC7, 0x80,
  0xF1, 0xE3, 0xCF, 0x80, 0xF3, 0xE3, 0xCF, 0x80, 0xF3, 0xC3, 0xDF, 0x00,
  0xF3, 0xC3, 0xDF, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x83, 0xFE, 0x00,
  0xF7, 0x83, 0xBE, 0x00, 0xFF, 0x03, 0xBC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07,
  0xC0, 0x0F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81,
  0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF3, 0xE0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x80,
  0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3E, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1F, 0x3C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E,
  0x0F, 0x00, 0xE0, 0x00, 0x3F, 0x9F, 0x07, 0xFD, 0xF0, 0xFF, 0xDE, 0x0F,
  0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7,
  0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x8F, 0xC0, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F,
  0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xE0, 0x3F, 0xDE, 0x03, 0xF1,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x70, 0x07, 0xDF, 0xC0, 0x7B, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xF8, 0x7E,
  0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xBF, 0xC0, 0xF1, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFE, 0xE0, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x83, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x03, 0x87, 0xC0, 0x3F, 0x9F, 0x01, 0xFF, 0x78,
  0x0F, 0xFF, 0xE0, 0x3F, 0x7F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xF7, 0x80, 0x1F, 0x9E, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xF8, 0xF8, 0xF8, 0x3C, 0x78,
  0x1E, 0x7C, 0x0F, 0x3C, 0x0F, 0xBE, 0x0F, 0x9F, 0x7F, 0xCF, 0xFF, 0xC7,
  0xFF, 0x87, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x87, 0xF7, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xC8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0xE7, 0xC0, 0xFF, 0xBE, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE1,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x3F, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F,
  0x07, 0xE0, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xF7, 0xC0, 0xFF, 0xFC,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x60, 0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x70, 0x07, 0xDF, 0xC0, 0x7B, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0xFC, 0x1E, 0x0F, 0x83,
  0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0,
  0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x1E, 0x7F, 0x1F, 0xC0,
  0x7B, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFC, 0x3F,
  0x0F, 0xE1, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x1F, 0x03,
  0xE0, 0x78, 0x7C, 0x0F, 0x83, 0xE1, 0xF0, 0x3C, 0x0F, 0x87, 0xC1, 0xF0,
  0x3E, 0x1E, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x03, 0xC3, 0xE0, 0x7C, 0x1F,
  0x0F, 0x81, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0x87,
  0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xC0, 0xF8, 0x7C, 0x0F, 0x03, 0xE1, 0xE0,
  0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x3C, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0x00, 0x79, 0xFC, 0x07, 0xBF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x78,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xC7, 0xE1, 0xF3,
  0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x9F, 0xC0, 0x1E, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0,
  0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7B, 0xFE, 0x03, 0xEF, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x8F, 0x07, 0xFD, 0xE0, 0xFF, 0xFE,
  0x0F, 0xDF, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8,
  0x3F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x07, 0xFD, 0xE0, 0x7F, 0xDE, 0x03,
  0xF3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x07, 0x9F, 0x07, 0xBF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xF2, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0x8E, 0x1F, 0x02, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0xC0, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3C,
  0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x81,
  0xF0, 0x78, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFD, 0xE0, 0x3F, 0x1E, 0x00, 0xF8, 0x07, 0xDE, 0x03, 0xE7,
  0x80, 0xF9, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xE1,
  0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xF0,
  0x1E, 0x78, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x3F, 0x07, 0xFE, 0x07, 0xE0, 0xFB, 0xC1, 0xFC, 0x1E, 0x78, 0x3F, 0x87,
  0xCF, 0x0F, 0xF0, 0xF9, 0xE1, 0xFE, 0x1E, 0x3C, 0x3B, 0xC7, 0xC7, 0x8F,
  0x78, 0xF0, 0xF1, 0xEF, 0x3E, 0x1E, 0x79, 0xE7, 0x83, 0xCF, 0x38, 0xF0,
  0x79, 0xE7, 0x3E, 0x0F, 0x78, 0xE7, 0x81, 0xEF, 0x1D, 0xF0, 0x3F, 0xC3,
  0xBC, 0x07, 0xF8, 0x77, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0x9E, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x3E,
  0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x80,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x07, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 14, 11, 17, 4, -31 },
  { 68, 23, 31, 22, 0, -31 },
  { 158, 20, 36, 19, 0, -33 },
  { 248, 28, 31, 31, 2, -31 },
  { 357, 23, 31, 23, 0, -31 },
  { 447, 7, 11, 10, 4, -31 },
  { 457, 14, 38, 12, 1, -31 },
  { 524, 14, 38, 12, -3, -31 },
  { 591, 16, 18, 19, 4, -33 },
  { 627, 18, 21, 21, 2, -26 },
  { 675, 9, 11, 10, -2, -5 },
  { 688, 11, 5, 12, 1, -14 },
  { 695, 6, 6, 10, 0, -6 },
  { 700, 21, 31, 16, -2, -31 },
  { 782, 18, 31, 19, 1, -31 },
  { 852, 14, 31, 20, 4, -31 },
  { 907, 21, 31, 19, -1, -31 },
  { 989, 20, 31, 19, 0, -31 },
  { 1067, 21, 31, 20, -1, -31 },
  { 1149, 20, 31, 19, 0, -31 },
  { 1227, 20, 31, 19, 1, -31 },
  { 1305, 21, 31, 19, 1, -31 },
  { 1387, 20, 31, 19, 0, -31 },
  { 1465, 18, 31, 19, 1, -31 },
  { 1535, 10, 24, 10, 0, -24 },
  { 1565, 12, 30, 10, -2, -24 },
  { 1610, 18, 21, 21, 2, -26 },
  { 1658, 18, 12, 21, 2, -21 },
  { 1685, 18, 21, 21, 2, -26 },
  { 1733, 15, 31, 15, 2, -31 },
  { 1792, 28, 35, 30, 1, -31 },
  { 1915, 22, 31, 21, -3, -31 },
  { 2001, 22, 31, 22, 0, -31 },
  { 2087, 21, 31, 20, 2, -31 },
  { 2169, 23, 31, 24, 0, -31 },
  { 2259, 20, 31, 18, 0, -31 },
  { 2337, 20, 31, 18, 0, -31 },
  { 2415, 23, 31, 24, 2, -31 },
  { 2505, 25, 31, 24, 0, -31 },
  { 2602, 18, 31, 14, -2, -31 },
  { 2672, 19, 40, 11, -7, -31 },
  { 2767, 25, 31, 21, 0, -31 },
  { 2864, 15, 31, 18, 0, -31 },
  { 2923, 32, 31, 32, 0, -31 },
  { 3047, 27, 31, 26, 0, -31 },
  { 3152, 23, 31, 25, 2, -31 },
  { 3242, 22, 31, 21, 0, -31 },
  { 3328, 23, 38, 25, 2, -31 },
  { 3438, 21, 31, 21, 0, -31 },
  { 3520, 20, 31, 19, 0, -31 },
  { 3598, 18, 31, 18, 3, -31 },
  { 3668, 23, 31, 24, 2, -31 },
  { 3758, 20, 31, 21, 4, -31 },
  { 3836, 32, 31, 32, 4, -31 },
  { 3960, 25, 31, 20, -2, -31 },
  { 4057, 19, 31, 19, 4, -31 },
  { 4131, 23, 31, 18, -2, -31 },
  { 4221, 17, 38, 13, -1, -31 },
  { 4302, 9, 31, 16, 4, -31 },
  { 4337, 17, 38, 13, -3, -31 },
  { 4418, 19, 19, 20, 0, -31 },
  { 4464, 15, 3, 15, -4, 4 },
  { 4470, 8, 7, 12, 6, -33 },
  { 4477, 20, 24, 21, 1, -24 },
  { 4537, 20, 33, 21, 0, -33 },
  { 4620, 17, 24, 17, 1, -24 },
  { 4671, 22, 33, 21, 1, -33 },
  { 4762, 17, 24, 19, 1, -24 },
  { 4813, 22, 43, 12, -5, -33 },
  { 4932, 21, 34, 21, 0, -24 },
  { 5022, 20, 33, 21, 0, -33 },
  { 5105, 12, 32, 10, 0, -32 },
  { 5153, 17, 42, 10, -5, -32 },
  { 5243, 21, 33, 19, 0, -33 },
  { 5330, 12, 33, 10, 0, -33 },
  { 5380, 30, 24, 31, 0, -24 },
  { 5470, 20, 24, 21, 0, -24 },
  { 5530, 18, 24, 20, 1, -24 },
  { 5584, 22, 34, 21, -2, -24 },
  { 5678, 20, 34, 21, 1, -24 },
  { 5763, 16, 24, 14, 0, -24 },
  { 5811, 16, 24, 16, 0, -24 },
  { 5859, 12, 28, 13, 2, -28 },
  { 5901, 20, 23, 21, 1, -23 },
  { 5959, 18, 23, 18, 2, -23 },
  { 6011, 27, 23, 28, 3, -23 },
  { 6089, 22, 23, 18, -2, -23 },
  { 6153, 23, 33, 18, -3, -23 },
  { 6248, 17, 23, 16, -1, -23 },
  { 6297, 16, 38, 15, 1, -31 },
  { 6373, 4, 43, 18, 7, -33 },
  { 6395, 16, 38, 15, -2, -31 },
  { 6471, 18, 6, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC43PT7B_H_
