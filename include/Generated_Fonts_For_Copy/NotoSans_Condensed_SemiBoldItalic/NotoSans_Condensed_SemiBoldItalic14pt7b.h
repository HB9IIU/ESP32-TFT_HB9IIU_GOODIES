#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x26, 0x66, 0x40, 0xCC, 0x7A, 0xD5, 0xA0, 0x1A, 0x2C, 0x53,
  0xF2, 0x45, 0x3F, 0xA4, 0x59, 0xA0, 0x08, 0x10, 0xFB, 0x87, 0x06, 0x06,
  0x0E, 0xAD, 0xF0, 0x81, 0x00, 0x73, 0x69, 0x25, 0x17, 0x8A, 0xB7, 0xAC,
  0x56, 0x4A, 0x65, 0x23, 0x00, 0x1C, 0x34, 0x24, 0x3C, 0x39, 0x7A, 0xDE,
  0xCC, 0xDC, 0x76, 0x69, 0x60, 0x19, 0x88, 0xC4, 0x23, 0x18, 0xC6, 0x30,
  0x80, 0x10, 0x86, 0x31, 0x88, 0x46, 0x31, 0x19, 0x80, 0x12, 0x4F, 0xCF,
  0x51, 0x60, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0x2D, 0x60, 0x7F, 0xF0, 0x02,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x1C, 0xD6, 0x59, 0x45,
  0x3C, 0xF2, 0xD9, 0xC0, 0x19, 0xF4, 0x23, 0x18, 0x84, 0x63, 0x00, 0x3D,
  0xB0, 0x43, 0x08, 0x63, 0x18, 0xC3, 0xE0, 0x3C, 0xB0, 0x43, 0x38, 0xE0,
  0xC3, 0x9B, 0xC0, 0x0C, 0x31, 0xCF, 0x29, 0x29, 0xBF, 0x18, 0x40, 0x3E,
  0x40, 0x83, 0x07, 0x81, 0x83, 0x06, 0x99, 0xE0, 0x1E, 0x60, 0x83, 0x07,
  0xCD, 0xB3, 0x66, 0x58, 0xF0, 0x3E, 0x8C, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0x61, 0x80, 0x3C, 0x4D, 0x91, 0x63, 0x8F, 0x33, 0x66, 0xC8, 0xF0, 0x3D,
  0xB6, 0x51, 0x4D, 0xF0, 0xC2, 0x1B, 0xC0, 0x2C, 0x00, 0x36, 0x13, 0x00,
  0x00, 0x66, 0x4C, 0x0C, 0xEE, 0x30, 0x38, 0x30, 0xFC, 0x00, 0x3F, 0x81,
  0x81, 0x87, 0x62, 0x00, 0xF4, 0xC4, 0x66, 0x23, 0x00, 0x84, 0x00, 0x0F,
  0x04, 0x22, 0x09, 0x3B, 0x52, 0xD4, 0xAD, 0x6B, 0x6C, 0x40, 0x10, 0x03,
  0xE0, 0x0E, 0x1C, 0x38, 0xF1, 0x66, 0xCF, 0xB3, 0x67, 0x8C, 0x3C, 0x6C,
  0x9B, 0x37, 0xCD, 0x91, 0x22, 0xCD, 0xF0, 0x3D, 0xD4, 0x30, 0xC2, 0x08,
  0x20, 0xC9, 0xC0, 0x3C, 0x6C, 0x8B, 0x16, 0x2C, 0xD1, 0xA2, 0xDD, 0xE0,
  0x3E, 0x60, 0x83, 0x07, 0xCF, 0x10, 0x20, 0xC1, 0xF0, 0x3E, 0x60, 0x83,
  0x07, 0x8F, 0x10, 0x20, 0xC1, 0x80, 0x3E, 0xE5, 0x86, 0x0C, 0x13, 0xA3,
  0x46, 0xCC, 0xF0, 0x31, 0x33, 0x23, 0x63, 0x7E, 0x7E, 0x46, 0x46, 0xC4,
  0xCC, 0x3C, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x23, 0xC0, 0x0C, 0x30, 0x82,
  0x18, 0x61, 0x84, 0x30, 0xC3, 0x38, 0xC0, 0x33, 0x36, 0x2C, 0x68, 0x78,
  0x78, 0x58, 0x48, 0xCC, 0xCC, 0x31, 0x88, 0xC6, 0x31, 0x08, 0xC7, 0xC0,
  0x30, 0xE6, 0x18, 0xC7, 0x3C, 0xE7, 0xBC, 0xF5, 0x17, 0xA2, 0xEC, 0xDD,
  0x99, 0x30, 0x31, 0x98, 0x8E, 0x4F, 0x66, 0xB3, 0x59, 0x38, 0x9C, 0xCE,
  0x63, 0x00, 0x3C, 0xCD, 0x1E, 0x3C, 0x70, 0xE1, 0x46, 0xD8, 0xE0, 0x3C,
  0x6C, 0x9B, 0x36, 0x6F, 0x90, 0x20, 0xC1, 0x80, 0x3C, 0xCD, 0x1E, 0x3C,
  0x70, 0xE1, 0x46, 0xD8, 0xE0, 0x40, 0xC0, 0x3C, 0x6C, 0x9B, 0x36, 0xCF,
  0x16, 0x24, 0xCD, 0x98, 0x3E, 0xE9, 0x83, 0x03, 0x03, 0x06, 0x04, 0x99,
  0xE0, 0xFC, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x00, 0x66, 0x8D, 0x1E,
  0x2C, 0x59, 0xA3, 0x46, 0xD9, 0xE0, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x3C,
  0x38, 0x60, 0xC0, 0xC4, 0x79, 0x9B, 0x33, 0x6E, 0x4D, 0x59, 0xEA, 0x39,
  0xC7, 0x38, 0xE6, 0x18, 0xC0, 0x33, 0x89, 0x87, 0x83, 0x81, 0xC0, 0xE0,
  0xF0, 0x58, 0x64, 0x63, 0x00, 0xCF, 0x35, 0x94, 0x71, 0x86, 0x18, 0x43,
  0x00, 0x3E, 0x98, 0x30, 0xC1, 0x06, 0x18, 0x20, 0xC1, 0xF0, 0x39, 0x08,
  0xC6, 0x21, 0x08, 0xC6, 0x21, 0xC0, 0xC9, 0x24, 0xDB, 0x24, 0x3C, 0x20,
  0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x38, 0x18, 0x63, 0x8B, 0x47, 0x10,
  0xF8, 0xD4, 0x16, 0x7D, 0x92, 0x2C, 0xD9, 0xB7, 0x34, 0x30, 0xC2, 0x0B,
  0x7D, 0x96, 0x51, 0x4F, 0x2B, 0x80, 0x1C, 0xE6, 0x10, 0xC3, 0x0C, 0x9C,
  0x02, 0x04, 0x18, 0xB3, 0xEC, 0x91, 0x26, 0xCD, 0xB9, 0xE0, 0x18, 0xF6,
  0x57, 0xF3, 0x04, 0x9E, 0x07, 0x0E, 0x0C, 0x0E, 0x1C, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x30, 0x20, 0xE0, 0x16, 0x7D, 0x92, 0x2C, 0xD9, 0xB7,
  0x34, 0x09, 0x33, 0xC0, 0x30, 0xC2, 0x0B, 0x7D, 0x96, 0x53, 0x4F, 0x3C,
  0x80, 0x13, 0x02, 0x66, 0x64, 0x4C, 0xC0, 0x04, 0x30, 0x02, 0x18, 0x61,
  0x84, 0x10, 0xC3, 0x0C, 0x23, 0x80, 0x30, 0x60, 0x81, 0x36, 0xCF, 0x14,
  0x38, 0x59, 0xB3, 0x20, 0x33, 0x22, 0x66, 0x64, 0x4C, 0xC0, 0x2D, 0x9F,
  0xF6, 0x4D, 0xB2, 0x4C, 0x93, 0x6C, 0x9B, 0x26, 0x2D, 0xF6, 0x59, 0x4D,
  0x3C, 0xF2, 0x18, 0xF6, 0x51, 0xCF, 0x34, 0x9E, 0x16, 0x7C, 0xC9, 0x92,
  0x24, 0xD9, 0x3E, 0x60, 0x83, 0x00, 0x16, 0x7D, 0x92, 0x24, 0xD9, 0xB7,
  0x34, 0x08, 0x30, 0x60, 0x2B, 0xD8, 0xC4, 0x23, 0x18, 0x3B, 0xD0, 0xC3,
  0x0E, 0x5E, 0x67, 0xEC, 0xC8, 0x88, 0xC0, 0x26, 0xC9, 0x93, 0x24, 0xC9,
  0xB6, 0x34, 0x8E, 0x69, 0xAC, 0xB2, 0x8E, 0x30, 0x99, 0xCC, 0xA6, 0xD5,
  0x4A, 0xE7, 0x63, 0x31, 0x98, 0x33, 0x36, 0x1C, 0x18, 0x18, 0x38, 0x6C,
  0xCC, 0x23, 0x26, 0x26, 0x24, 0x3C, 0x38, 0x38, 0x30, 0x30, 0x20, 0xE0,
  0x7B, 0xC4, 0x66, 0x23, 0x1E, 0x1C, 0x63, 0x0C, 0x33, 0x8C, 0x18, 0x61,
  0x84, 0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x61, 0x86, 0x10, 0x71, 0x8C,
  0x30, 0x86, 0x38, 0xE6, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 5, 1, -10 },
  { 9, 7, 10, 7, 0, -10 },
  { 18, 7, 12, 6, 0, -11 },
  { 29, 9, 10, 10, 1, -10 },
  { 41, 8, 10, 8, 0, -10 },
  { 51, 3, 4, 3, 1, -10 },
  { 53, 5, 12, 4, 0, -10 },
  { 61, 5, 12, 4, -1, -10 },
  { 69, 6, 6, 6, 1, -11 },
  { 74, 6, 6, 7, 1, -8 },
  { 79, 3, 4, 3, -1, -2 },
  { 81, 4, 2, 4, 0, -5 },
  { 82, 2, 2, 3, 0, -2 },
  { 83, 7, 10, 5, -1, -10 },
  { 92, 6, 10, 6, 0, -10 },
  { 100, 5, 10, 6, 1, -10 },
  { 107, 6, 10, 6, 0, -10 },
  { 115, 6, 10, 6, 0, -10 },
  { 123, 6, 10, 6, 0, -10 },
  { 131, 7, 10, 6, 0, -10 },
  { 140, 7, 10, 6, 0, -10 },
  { 149, 7, 10, 6, 0, -10 },
  { 158, 7, 10, 6, 0, -10 },
  { 167, 6, 10, 6, 0, -10 },
  { 175, 3, 8, 3, 0, -8 },
  { 178, 4, 10, 3, -1, -8 },
  { 183, 6, 6, 7, 1, -8 },
  { 188, 6, 4, 7, 1, -7 },
  { 191, 6, 6, 7, 1, -8 },
  { 196, 5, 10, 5, 1, -10 },
  { 203, 10, 11, 10, 0, -10 },
  { 217, 7, 10, 7, -1, -10 },
  { 226, 7, 10, 7, 0, -10 },
  { 235, 6, 10, 7, 1, -10 },
  { 243, 7, 10, 8, 0, -10 },
  { 252, 7, 10, 6, 0, -10 },
  { 261, 7, 10, 6, 0, -10 },
  { 270, 7, 10, 8, 1, -10 },
  { 279, 8, 10, 8, 0, -10 },
  { 289, 6, 10, 4, -1, -10 },
  { 297, 6, 13, 4, -2, -10 },
  { 307, 8, 10, 7, 0, -10 },
  { 317, 5, 10, 6, 0, -10 },
  { 324, 11, 10, 10, 0, -10 },
  { 338, 9, 10, 8, 0, -10 },
  { 350, 7, 10, 8, 1, -10 },
  { 359, 7, 10, 7, 0, -10 },
  { 368, 7, 12, 8, 1, -10 },
  { 379, 7, 10, 7, 0, -10 },
  { 388, 7, 10, 6, 0, -10 },
  { 397, 6, 10, 6, 1, -10 },
  { 405, 7, 10, 8, 1, -10 },
  { 414, 7, 10, 7, 1, -10 },
  { 423, 11, 10, 10, 1, -10 },
  { 437, 9, 10, 6, -1, -10 },
  { 449, 6, 10, 6, 1, -10 },
  { 457, 7, 10, 6, 0, -10 },
  { 466, 5, 12, 4, 0, -10 },
  { 474, 3, 10, 5, 1, -10 },
  { 478, 6, 12, 4, -1, -10 },
  { 487, 6, 6, 6, 0, -10 },
  { 492, 5, 1, 5, -1, 1 },
  { 493, 2, 3, 4, 2, -11 },
  { 494, 7, 8, 7, 0, -8 },
  { 501, 6, 11, 7, 0, -11 },
  { 510, 6, 8, 5, 0, -8 },
  { 516, 7, 11, 7, 0, -11 },
  { 526, 6, 8, 6, 0, -8 },
  { 532, 8, 14, 4, -2, -11 },
  { 546, 7, 11, 7, 0, -8 },
  { 556, 6, 11, 7, 0, -11 },
  { 565, 4, 11, 3, 0, -11 },
  { 571, 6, 14, 3, -2, -11 },
  { 582, 7, 11, 6, 0, -11 },
  { 592, 4, 11, 3, 0, -11 },
  { 598, 10, 8, 10, 0, -8 },
  { 608, 6, 8, 7, 0, -8 },
  { 614, 6, 8, 7, 0, -8 },
  { 620, 7, 11, 7, -1, -8 },
  { 630, 7, 11, 7, 0, -8 },
  { 640, 5, 8, 5, 0, -8 },
  { 645, 5, 8, 5, 0, -8 },
  { 650, 4, 9, 4, 1, -9 },
  { 655, 7, 8, 7, 0, -8 },
  { 662, 6, 8, 6, 1, -8 },
  { 668, 9, 8, 9, 1, -8 },
  { 677, 8, 8, 6, -1, -8 },
  { 685, 8, 11, 6, -1, -8 },
  { 696, 5, 8, 5, 0, -8 },
  { 701, 6, 12, 5, 0, -10 },
  { 710, 2, 14, 6, 2, -11 },
  { 714, 6, 12, 5, -1, -10 },
  { 723, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC14PT7B_H_
