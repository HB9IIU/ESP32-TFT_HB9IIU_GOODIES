#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x7C, 0x7D, 0xF1,
  0xE7, 0xCF, 0x9E, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x3C, 0x38, 0xF1,
  0xE3, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x1E, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38,
  0x70, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x70, 0xE0,
  0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07,
  0x8F, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3E, 0xCE, 0x0F, 0x98, 0x81, 0xE2, 0x00, 0x3C,
  0xC0, 0x07, 0x98, 0x00, 0xFB, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x6F, 0x80, 0x0C,
  0xF8, 0x01, 0x9F, 0x00, 0x33, 0xE2, 0x06, 0x78, 0x71, 0x9F, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x01, 0x01, 0xF8, 0x03,
  0x80, 0xFE, 0x01, 0xE0, 0x7F, 0xC0, 0xF0, 0x3C, 0xF0, 0x38, 0x0E, 0x1C,
  0x1E, 0x07, 0x8F, 0x07, 0x01, 0xE3, 0xC3, 0xC0, 0x70, 0xF1, 0xE0, 0x1C,
  0x3C, 0x70, 0x0F, 0x0F, 0x3C, 0x03, 0xC3, 0x8E, 0x00, 0xF1, 0xE7, 0x8F,
  0x3C, 0x7B, 0xCF, 0xEF, 0x3C, 0xE7, 0xFF, 0xFF, 0x79, 0xEF, 0x7F, 0x9C,
  0xF3, 0xCF, 0xCF, 0x38, 0x70, 0xC7, 0x9E, 0x3C, 0x01, 0xC7, 0x8F, 0x00,
  0xF1, 0xC3, 0xC0, 0x38, 0x70, 0xF0, 0x1E, 0x3C, 0x38, 0x0F, 0x0F, 0x1E,
  0x03, 0xC3, 0xC7, 0x81, 0xE0, 0xF1, 0xC0, 0x70, 0x3C, 0xF0, 0x3C, 0x07,
  0xF8, 0x1E, 0x01, 0xFE, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3C, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x1F, 0x0F, 0xF8, 0x7C, 0x7D, 0xF1, 0xE3, 0xE7, 0xCF,
  0x9F, 0x0F, 0xBC, 0x7C, 0x3F, 0xF1, 0xE0, 0xFF, 0x8F, 0x81, 0xFC, 0x3E,
  0x07, 0xF0, 0xF8, 0x0F, 0x83, 0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0x8F, 0xC0, 0x3D, 0xF7, 0xDE, 0x79, 0xE7,
  0xBC, 0xF3, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x02, 0x1E, 0x0F, 0x3C, 0x1F, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0x07,
  0xFE, 0x1F, 0x80, 0x7F, 0x01, 0xFF, 0x0F, 0xCF, 0x0F, 0x1E, 0x0C, 0x3E,
  0x08, 0x30, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x8F, 0x87,
  0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x19, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xE1, 0xE0, 0xF8, 0x78,
  0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x7C,
  0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF,
  0x1F, 0xFB, 0xFF, 0xCF, 0x3C, 0x71, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x38, 0x3F, 0x03, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0xFE, 0x04, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x18, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xBC, 0x00, 0xEF, 0x80, 0x3D, 0xF0, 0x0F, 0x3E, 0x01, 0xC7, 0x80,
  0x78, 0xF0, 0x1E, 0x3E, 0x03, 0x87, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC4, 0x01,
  0xF8, 0xC0, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0x8C, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x3C, 0x03, 0xCF, 0xE0, 0x7B, 0xFC, 0x1F, 0xFF,
  0xC3, 0xF8, 0xF8, 0x7E, 0x1F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x7C, 0x07,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E,
  0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x7C, 0x7E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x1F, 0x03, 0xE7, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xE7, 0xE0, 0xF8, 0x7C, 0x3E,
  0x07, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x1F, 0x83, 0xE1, 0xF9, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07,
  0xEF, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFD, 0xE0, 0xFE, 0xF8, 0x04, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0x01,
  0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0x80, 0x00, 0x40, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFF, 0x8F, 0xFF, 0x3C, 0xFC, 0xC1, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x1C, 0x0F, 0x1E, 0x0F, 0xF8,
  0xE3, 0x83, 0xFF, 0x1C, 0xF0, 0xF1, 0xC3, 0x9E, 0x3C, 0x38, 0x73, 0x87,
  0x0F, 0x0E, 0xF1, 0xE1, 0xE3, 0xDC, 0x38, 0x38, 0x7B, 0x87, 0x07, 0x0E,
  0x71, 0xE1, 0xE1, 0xCE, 0x3C, 0x3C, 0x7B, 0xC7, 0x07, 0x0E, 0x78, 0xE1,
  0xE1, 0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0xDF, 0xFE, 0x3C, 0x3F, 0x3F, 0x87,
  0x87, 0xE7, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x04, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F,
  0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x04, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x40, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC3, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x03, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x07,
  0xF0, 0x7C, 0x7F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0x80, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC1, 0xFF, 0x3E, 0x07, 0xF8, 0xF8, 0x1F, 0xE3, 0xE0, 0xFF, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x1E, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xC1, 0xF8,
  0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0,
  0x07, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B,
  0xE0, 0x7B, 0xC0, 0xF7, 0x80, 0xF3, 0x83, 0xCF, 0x01, 0xE7, 0x07, 0x9E,
  0x07, 0xCF, 0x1E, 0x7C, 0x0F, 0x9E, 0x3C, 0xF8, 0x1E, 0x3C, 0xF1, 0xE0,
  0x3C, 0x79, 0xE3, 0xC0, 0x78, 0xF7, 0xCF, 0x81, 0xF1, 0xEF, 0x1F, 0x03,
  0xE3, 0xDE, 0x3E, 0x07, 0x87, 0xF8, 0x78, 0x0F, 0x0F, 0xF0, 0xF0, 0x1E,
  0x1F, 0xC3, 0xE0, 0x7C, 0x3F, 0x87, 0xC0, 0xF0, 0x7E, 0x0F, 0x81, 0xE0,
  0xFC, 0x1E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xE0, 0x3F, 0x00, 0x78, 0x0F, 0xE0, 0x3E,
  0x07, 0xF8, 0x0F, 0x81, 0xFE, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x1F, 0xF0,
  0x7C, 0x07, 0xBC, 0x1F, 0x03, 0xEF, 0x07, 0x80, 0xFB, 0xC1, 0xE0, 0x3C,
  0xF0, 0x78, 0x0F, 0x3E, 0x3E, 0x03, 0xC7, 0x8F, 0x81, 0xF1, 0xE3, 0xC0,
  0x7C, 0x78, 0xF0, 0x1E, 0x1F, 0x3C, 0x07, 0x83, 0xDF, 0x01, 0xE0, 0xF7,
  0xC0, 0xF8, 0x3D, 0xE0, 0x3E, 0x0F, 0xF8, 0x0F, 0x03, 0xFE, 0x03, 0xC0,
  0x7F, 0x81, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF0, 0x1E, 0x01, 0xFC, 0x07,
  0x80, 0x3F, 0x01, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x3F, 0x07, 0x83, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xC3,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xE3, 0xC0, 0x1E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x1E, 0x03, 0xE1, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F,
  0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0x81, 0x83, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x80, 0x3E,
  0x1C, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8,
  0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C,
  0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xFC, 0x3F, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF0,
  0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0xF9, 0xE0,
  0x1F, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0xF0, 0x0F, 0x80, 0xF9, 0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0x7E, 0x03, 0xC7,
  0x80, 0xFC, 0x0F, 0x8F, 0x03, 0xF8, 0x1F, 0x1E, 0x07, 0xF0, 0x7C, 0x3C,
  0x0F, 0xE0, 0xF8, 0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0x7F, 0x87, 0xC1, 0xE1,
  0xEF, 0x0F, 0x83, 0xC3, 0xDE, 0x1E, 0x07, 0x8F, 0x3C, 0x7C, 0x0F, 0x1E,
  0x78, 0xF0, 0x1E, 0x3C, 0xF3, 0xE0, 0x3C, 0xF1, 0xE7, 0x80, 0x79, 0xE3,
  0xCF, 0x00, 0xF7, 0x87, 0xBE, 0x01, 0xEF, 0x0F, 0x78, 0x03, 0xDE, 0x1F,
  0xF0, 0x07, 0xF8, 0x3B, 0xC0, 0x0F, 0xF0, 0x77, 0x80, 0x1F, 0xC0, 0xFF,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFB, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF,
  0x00, 0x07, 0xCF, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x0F,
  0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xE3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x7C, 0x07, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7B,
  0x80, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0xF9, 0xF1, 0xE1, 0xE3, 0xC0, 0x00,
  0x40, 0x00, 0x7F, 0x3C, 0x1F, 0xEF, 0x87, 0xFF, 0xE1, 0xFD, 0xFC, 0x3E,
  0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7F, 0xFF, 0x07, 0xFD,
  0xE0, 0xFF, 0x3C, 0x0F, 0xCF, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x86, 0x00, 0xF3, 0xF0, 0x3E, 0xFF, 0x07, 0xFF, 0xE0, 0xFE,
  0x7E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7C, 0x3F, 0xFF,
  0x07, 0xFF, 0xE1, 0xE7, 0xF8, 0x3C, 0xFE, 0x00, 0x00, 0x38, 0x01, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xCC, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x43, 0xE0, 0x1F, 0xDF, 0x01, 0xFE, 0xF8, 0x1F,
  0xFF, 0x81, 0xF9, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0,
  0x3C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80,
  0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xFF, 0xFC, 0x07, 0xFD, 0xE0, 0x3F, 0xCF,
  0x00, 0xFC, 0x70, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF8, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E, 0x78, 0x1E, 0x7C, 0x1F, 0x3E,
  0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0x0F, 0xC7, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x8F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xCF, 0x03, 0xFD, 0xF0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE0, 0xF8,
  0x7E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFD, 0xF0, 0x1F, 0x9E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x08, 0x07, 0xC0, 0xC0, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x86, 0x00, 0xF3, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x1E, 0x1F,
  0x03, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x7C,
  0x0F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0,
  0x3C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x80, 0x01,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x9F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F,
  0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xEF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07,
  0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x00, 0x00, 0x06, 0x01, 0x80, 0x73, 0xF8, 0xFE,
  0x0F, 0x7F, 0xDF, 0xF0, 0xF7, 0xFF, 0xFF, 0x0F, 0xE7, 0xF9, 0xF0, 0xFC,
  0x7F, 0x1F, 0x0F, 0x83, 0xE0, 0xF1, 0xF0, 0x7C, 0x0F, 0x1F, 0x07, 0xC1,
  0xF1, 0xF0, 0x7C, 0x1F, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x3E,
  0x07, 0x81, 0xE3, 0xE0, 0xF8, 0x3E, 0x3C, 0x0F, 0x83, 0xE3, 0xC0, 0xF0,
  0x3C, 0x7C, 0x0F, 0x03, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7,
  0x81, 0xF0, 0x7C, 0x78, 0x1E, 0x07, 0x8F, 0x81, 0xE0, 0x78, 0xF8, 0x3E,
  0x0F, 0x80, 0x00, 0x06, 0x00, 0xE3, 0xF0, 0x3C, 0xFF, 0x07, 0xBF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xFC, 0x1E, 0x1F, 0x03, 0xC3,
  0xE0, 0xF8, 0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F,
  0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E,
  0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x80, 0x00, 0x30, 0x01,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E,
  0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x01,
  0x80, 0x0E, 0x3F, 0x00, 0xF3, 0xFC, 0x07, 0xBF, 0xE0, 0x3F, 0x9F, 0x81,
  0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xFC, 0x1F, 0x07, 0xE1, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0x7F, 0x80, 0xF9, 0xF8, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0x3C, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xF9,
  0xFC, 0x3E, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0x7C, 0x0F, 0xCF, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x87, 0x07, 0x1E,
  0x0F, 0x3E, 0x0F, 0x7E, 0x0F, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0x0C, 0x1E, 0x04, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x03,
  0xFF, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xB0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0x03, 0xE3,
  0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F,
  0x81, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C, 0x3E,
  0x07, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xEF, 0x07, 0xFB, 0xC0, 0x7E,
  0x78, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xCF, 0x03, 0xC7, 0x83,
  0xE3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x7E, 0x0F, 0xF8, 0x3F, 0x07, 0xFC, 0x1F, 0x83, 0xDE, 0x1F,
  0xC3, 0xEF, 0x0F, 0xE1, 0xE7, 0x8F, 0xF1, 0xF3, 0xC7, 0xF8, 0xF1, 0xE3,
  0xBC, 0x78, 0xF3, 0xDE, 0x7C, 0x79, 0xEF, 0x3C, 0x3D, 0xE7, 0xBE, 0x1E,
  0xF3, 0xDE, 0x0F, 0x71, 0xEF, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x77, 0x81,
  0xDC, 0x3B, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1,
  0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x00,
  0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x7C, 0x00, 0x3D,
  0xE0, 0x00, 0x77, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x03, 0xF8, 0x0F, 0xF0,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x08, 0x00, 0xBF, 0xC0, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x07, 0xFA, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 29, 10, 0, -29 },
  { 45, 14, 10, 16, 4, -29 },
  { 63, 22, 29, 21, 0, -29 },
  { 143, 19, 33, 19, 0, -31 },
  { 222, 26, 30, 29, 2, -30 },
  { 320, 22, 30, 22, 0, -30 },
  { 403, 6, 10, 9, 4, -29 },
  { 411, 14, 35, 12, 1, -29 },
  { 473, 14, 36, 12, -3, -30 },
  { 536, 15, 17, 18, 4, -31 },
  { 568, 17, 19, 20, 2, -24 },
  { 609, 9, 10, 10, -2, -5 },
  { 621, 10, 4, 12, 1, -13 },
  { 626, 6, 6, 10, 0, -6 },
  { 631, 20, 29, 15, -2, -29 },
  { 704, 18, 30, 19, 1, -30 },
  { 772, 13, 29, 19, 4, -29 },
  { 820, 20, 30, 19, -1, -30 },
  { 895, 19, 30, 19, 0, -30 },
  { 967, 19, 29, 19, 0, -29 },
  { 1036, 19, 29, 19, 0, -29 },
  { 1105, 19, 30, 19, 1, -30 },
  { 1177, 20, 29, 19, 1, -29 },
  { 1250, 19, 30, 19, 0, -30 },
  { 1322, 18, 30, 19, 0, -30 },
  { 1390, 10, 23, 10, 0, -23 },
  { 1419, 12, 28, 10, -2, -23 },
  { 1461, 17, 20, 20, 2, -25 },
  { 1504, 17, 12, 20, 2, -20 },
  { 1530, 17, 20, 20, 2, -25 },
  { 1573, 14, 30, 15, 2, -30 },
  { 1626, 27, 32, 28, 1, -29 },
  { 1734, 21, 29, 20, -3, -29 },
  { 1811, 21, 29, 21, 0, -29 },
  { 1888, 20, 30, 19, 2, -30 },
  { 1963, 22, 29, 22, 0, -29 },
  { 2043, 19, 29, 18, 0, -29 },
  { 2112, 19, 29, 17, 0, -29 },
  { 2181, 22, 30, 23, 2, -30 },
  { 2264, 24, 29, 23, 0, -29 },
  { 2351, 18, 29, 13, -2, -29 },
  { 2417, 17, 37, 10, -6, -29 },
  { 2496, 24, 29, 20, 0, -29 },
  { 2583, 14, 29, 17, 0, -29 },
  { 2634, 31, 29, 30, 0, -29 },
  { 2747, 26, 29, 25, 0, -29 },
  { 2842, 21, 30, 24, 2, -30 },
  { 2921, 21, 29, 20, 0, -29 },
  { 2998, 21, 37, 24, 2, -30 },
  { 3096, 20, 29, 20, 0, -29 },
  { 3169, 19, 30, 18, 0, -30 },
  { 3241, 17, 29, 17, 3, -29 },
  { 3303, 22, 29, 23, 2, -29 },
  { 3383, 19, 29, 20, 4, -29 },
  { 3452, 31, 29, 30, 3, -29 },
  { 3565, 24, 29, 19, -2, -29 },
  { 3652, 18, 29, 18, 4, -29 },
  { 3718, 21, 29, 17, -1, -29 },
  { 3795, 16, 36, 12, -1, -29 },
  { 3867, 8, 29, 15, 4, -29 },
  { 3896, 16, 36, 12, -3, -29 },
  { 3968, 19, 17, 19, 0, -29 },
  { 4009, 15, 2, 14, -4, 4 },
  { 4013, 7, 6, 12, 6, -31 },
  { 4019, 19, 23, 20, 1, -23 },
  { 4074, 19, 31, 20, 0, -31 },
  { 4148, 16, 23, 16, 1, -23 },
  { 4194, 21, 31, 20, 1, -31 },
  { 4276, 17, 23, 18, 1, -23 },
  { 4325, 22, 41, 12, -5, -31 },
  { 4438, 20, 33, 20, 0, -23 },
  { 4521, 19, 31, 20, 0, -31 },
  { 4595, 11, 31, 10, 0, -31 },
  { 4638, 16, 41, 10, -5, -31 },
  { 4720, 20, 31, 18, 0, -31 },
  { 4798, 11, 31, 10, 0, -31 },
  { 4841, 28, 23, 30, 0, -23 },
  { 4922, 19, 23, 20, 0, -23 },
  { 4977, 17, 23, 19, 1, -23 },
  { 5026, 21, 33, 20, -2, -23 },
  { 5113, 19, 33, 20, 1, -23 },
  { 5192, 16, 23, 14, 0, -23 },
  { 5238, 16, 23, 16, 0, -23 },
  { 5284, 12, 27, 12, 2, -27 },
  { 5325, 19, 22, 20, 1, -22 },
  { 5378, 17, 22, 17, 2, -22 },
  { 5425, 25, 22, 26, 3, -22 },
  { 5494, 21, 22, 17, -2, -22 },
  { 5552, 22, 32, 17, -3, -22 },
  { 5640, 17, 22, 15, -1, -22 },
  { 5687, 17, 35, 14, 0, -29 },
  { 5762, 4, 40, 17, 7, -31 },
  { 5782, 15, 35, 14, -2, -29 },
  { 5848, 17, 7, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC41PT7B_H_
