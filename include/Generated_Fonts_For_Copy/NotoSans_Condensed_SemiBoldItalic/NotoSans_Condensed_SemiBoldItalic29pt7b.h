#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x73, 0xB9,
  0xDC, 0xFC, 0x7E, 0x77, 0x3B, 0x9D, 0x8C, 0x01, 0xCE, 0x01, 0x8C, 0x01,
  0x8C, 0x03, 0x9C, 0x03, 0x18, 0x03, 0x18, 0x3F, 0xFF, 0x3F, 0xFE, 0x06,
  0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0xFF, 0xFC, 0xFF,
  0xF8, 0x18, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x73, 0x80, 0x73,
  0x80, 0x00, 0x40, 0x01, 0x00, 0x1F, 0x01, 0xFF, 0x0F, 0xF8, 0x7A, 0x41,
  0xD8, 0x07, 0x60, 0x1D, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x2F, 0x00, 0x9C, 0x86, 0xF1, 0x9F, 0x8F, 0xFE, 0x3F, 0xF0,
  0x1E, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x1E, 0x07, 0x0F, 0xC1, 0x87,
  0x70, 0xE1, 0x9C, 0x30, 0xE7, 0x1C, 0x39, 0xCE, 0x0C, 0x73, 0x03, 0x19,
  0xC0, 0xC6, 0x63, 0x33, 0xBB, 0xEF, 0xDD, 0xFF, 0xF6, 0x67, 0x73, 0xB9,
  0xC0, 0xCE, 0x70, 0x73, 0x1C, 0x38, 0xC6, 0x0E, 0x31, 0x87, 0x0C, 0xE1,
  0x83, 0x30, 0xE0, 0xFC, 0x70, 0x3E, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0xF0, 0x0F,
  0xE0, 0x07, 0xC0, 0x0F, 0x81, 0x3F, 0x8E, 0x3B, 0xCE, 0x71, 0xDC, 0x71,
  0xFC, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xFF, 0xF8, 0x7F, 0xB8, 0x3F,
  0x3C, 0x77, 0x77, 0xEE, 0xEC, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0xE0, 0xE0, 0x70, 0x70, 0x00, 0x0F, 0x01, 0xC2, 0x38, 0x77, 0x0F, 0xFE,
  0xFF, 0xC7, 0xF9, 0xF0, 0x77, 0x1E, 0xE0, 0x8E, 0x01, 0x00, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3C, 0xE3, 0x9C, 0x73, 0xCE,
  0x30, 0x7F, 0x7E, 0xFE, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xF1,
  0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x07, 0x70, 0x7F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xFF, 0x87,
  0xF0, 0x7E, 0x00, 0x03, 0x83, 0xC7, 0xE7, 0xE7, 0xF7, 0xB9, 0x9C, 0x1E,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0x8F, 0x04, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF,
  0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x18, 0xF0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE4, 0x0F, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1D, 0xC0, 0xCE, 0x0E, 0xF0, 0xE7, 0x06, 0x38, 0x71, 0xC7, 0x1E,
  0x30, 0xE7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0x81, 0xFF, 0x0F, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE4, 0x0F, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x77, 0xC3, 0xFF, 0x1F, 0xF9, 0xE1, 0xCF, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x3C, 0xE1, 0xE7, 0x9E, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0xE1,
  0xC3, 0x87, 0x9E, 0x0E, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x39, 0xE1,
  0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0x87, 0xBE, 0x1F, 0xF0,
  0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3C, 0xF1, 0xC3, 0x9E, 0x1C,
  0xE0, 0xE7, 0x0F, 0x38, 0x79, 0xC3, 0xCF, 0x3E, 0x7F, 0xE1, 0xF7, 0x02,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0,
  0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x1E, 0x3C, 0x78, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x03,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80,
  0x04, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00,
  0x0F, 0x9F, 0xF3, 0xFC, 0x87, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x83,
  0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0x1E, 0x07, 0x80,
  0xE0, 0xC0, 0x0C, 0x30, 0x01, 0xCE, 0x3F, 0x39, 0x8F, 0xE3, 0x73, 0x9C,
  0xEC, 0x63, 0x9D, 0x9C, 0x63, 0xF3, 0x0C, 0x6C, 0x63, 0x8D, 0x8C, 0x73,
  0xB1, 0x8C, 0x66, 0x3B, 0xDC, 0xC7, 0xDF, 0x18, 0x71, 0x83, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01,
  0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xEF,
  0x01, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xF0, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x1C, 0x78, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x83, 0x87, 0x87, 0x07, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x78, 0xE1, 0xE1,
  0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x3F, 0xF0,
  0x78, 0x41, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x41, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xF0, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x8F,
  0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0x81, 0xE7, 0x03,
  0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xE3, 0xE1, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x10, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x06,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0xFC, 0xF0, 0xFC, 0xF0, 0xFC, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38,
  0xF0, 0x38, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0x03,
  0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x78,
  0x3C, 0x3C, 0x1E, 0x1C, 0x0E, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x07, 0x80, 0x0F, 0xF0, 0xFF, 0x07, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0x07, 0x87, 0x87,
  0x83, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x73, 0xC0, 0x7B, 0xC0, 0x39,
  0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDC, 0x01,
  0xCE, 0x00, 0xE7, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0x78, 0x1C, 0x3C,
  0x0E, 0x1E, 0x0F, 0x07, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x36, 0x07,
  0xE1, 0xD8, 0x3F, 0x87, 0x60, 0xFC, 0x1D, 0x87, 0x70, 0x77, 0x1D, 0xC3,
  0xDC, 0xE7, 0x0E, 0x73, 0xBC, 0x39, 0xDC, 0xE0, 0xE7, 0x73, 0x83, 0x9F,
  0x8E, 0x1E, 0x7E, 0x78, 0x71, 0xF1, 0xC1, 0xC7, 0xC7, 0x07, 0x1E, 0x1C,
  0x1C, 0x78, 0x70, 0xE1, 0xE3, 0xC0, 0x07, 0x01, 0xC3, 0xE0, 0x70, 0xF8,
  0x3C, 0x3E, 0x0E, 0x0F, 0x83, 0x87, 0x70, 0xE1, 0xDC, 0x38, 0x77, 0x1E,
  0x1D, 0xC7, 0x07, 0x71, 0xC3, 0xCE, 0x70, 0xE3, 0x9C, 0x38, 0xEE, 0x0E,
  0x3B, 0x83, 0x87, 0xE1, 0xE1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x07, 0x07,
  0xC1, 0xC0, 0xF0, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0x1E, 0x1E, 0x0E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE0, 0xE1, 0xE3, 0xC3, 0xC7,
  0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFE,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E,
  0x1E, 0x0E, 0x3C, 0x0E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC3, 0x8F, 0x0E, 0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x07, 0x1C, 0x3C,
  0x71, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xE7, 0x03, 0x9E, 0x1E, 0x38,
  0x78, 0xE1, 0xC3, 0x87, 0x0F, 0x1C, 0x3C, 0xF0, 0x70, 0x03, 0xF0, 0x1F,
  0xF0, 0xFF, 0x87, 0x86, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x01, 0xE2, 0x07, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xF7,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80,
  0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x70, 0x73, 0x87, 0x9C,
  0x38, 0xE3, 0xC7, 0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x70,
  0x38, 0x1D, 0xC1, 0xE0, 0xF7, 0x07, 0x83, 0x9C, 0x1E, 0x1E, 0x70, 0xF8,
  0x71, 0xC3, 0xE1, 0xC7, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x73, 0xB9, 0xE1,
  0xCE, 0xE7, 0x07, 0x33, 0x9C, 0x1D, 0xCE, 0xE0, 0x77, 0x3B, 0x81, 0xF8,
  0xFE, 0x06, 0xE3, 0xF0, 0x3B, 0x0D, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC1,
  0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07,
  0x1E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0xF0, 0x3C, 0x00, 0xE0, 0x7E, 0x0F,
  0xE0, 0xEE, 0x1E, 0xE1, 0xCF, 0x38, 0x77, 0x87, 0x70, 0x7F, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x87, 0x1C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87,
  0xE0, 0xFC, 0x1F, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x7E,
  0x03, 0x70, 0x39, 0x83, 0x8E, 0x1C, 0x71, 0xC3, 0x8C, 0x0E, 0xE0, 0x7E,
  0x03, 0x80, 0xFF, 0xE0, 0xF3, 0x8E, 0x70, 0x0F, 0x38, 0xFD, 0xCF, 0xFE,
  0x79, 0xE7, 0x87, 0x38, 0x39, 0xC3, 0xDE, 0x1E, 0xE0, 0xE7, 0x07, 0x38,
  0x79, 0xC3, 0xCF, 0x3E, 0x7F, 0xE3, 0xFF, 0x0F, 0xB8, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7B, 0xC3, 0xBF, 0x1F, 0xF8,
  0xF1, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x0F, 0x78,
  0x73, 0xC3, 0x9E, 0x3C, 0xFF, 0xCE, 0xFC, 0x77, 0xC0, 0x07, 0xC3, 0xFC,
  0xFF, 0x1E, 0x27, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x09, 0xFE, 0x1F, 0xC1, 0xF8, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0xF3, 0x87, 0xEE, 0x3F, 0xF8, 0xF3,
  0xC7, 0x87, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0xCE, 0x0E, 0x38, 0x38, 0xE0,
  0xE3, 0x87, 0x8E, 0x1C, 0x3F, 0xF0, 0xFF, 0xC1, 0xF7, 0x00, 0x07, 0xC3,
  0xFC, 0xFF, 0x9C, 0x77, 0x8E, 0xE1, 0xFC, 0x7F, 0xFE, 0xFF, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE3, 0x1F, 0xE1, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0x9C, 0x3F, 0x71, 0xFF, 0xC7, 0x9E, 0x3C, 0x38,
  0xE0, 0xE3, 0x87, 0x9E, 0x1E, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x1C, 0x3C,
  0x71, 0xF1, 0xFF, 0x87, 0xFE, 0x0F, 0xB8, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x20, 0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7B, 0xC3, 0xBF, 0x1F, 0xF8, 0xF1,
  0xC7, 0x0E, 0x78, 0x73, 0x87, 0x9C, 0x3C, 0xE1, 0xCF, 0x0E, 0x78, 0x73,
  0x87, 0x9C, 0x3C, 0xE1, 0xCF, 0x0E, 0x70, 0xF0, 0x06, 0x0F, 0x0F, 0x0E,
  0x00, 0x00, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78,
  0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0xC0,
  0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE3, 0xC7, 0x0E, 0x1C, 0x70, 0x73, 0xC1, 0xDE, 0x0E, 0xF0, 0x3B,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7B, 0xC1, 0xC7, 0x07, 0x1C, 0x1C,
  0x78, 0xF1, 0xE3, 0x83, 0x80, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0x1C, 0xF1, 0xE1, 0xDF, 0x3F, 0x1F, 0xFF, 0xF1, 0xE7,
  0xC7, 0x1C, 0x38, 0x73, 0xC7, 0x87, 0x38, 0x78, 0xF3, 0x87, 0x0E, 0x38,
  0x70, 0xE7, 0x87, 0x0E, 0x70, 0xF0, 0xE7, 0x0E, 0x1E, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0xF0, 0xE1, 0xCE, 0x1E, 0x3C, 0x1C, 0xF0, 0xEF, 0xC7, 0xFE,
  0x3C, 0x71, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9E,
  0x1C, 0xE1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0x07, 0xC1, 0xFE,
  0x3F, 0xE3, 0x8F, 0x78, 0x77, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0E,
  0xE0, 0xEE, 0x1E, 0xE1, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x0E, 0x78, 0x3B,
  0xF0, 0xFF, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0xF0, 0xF3, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0xFF, 0xC7, 0xFE, 0x1C,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x38, 0xFD, 0xCF, 0xFE, 0x79, 0xE7, 0x87, 0x38, 0x39,
  0xC3, 0xDE, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x3C, 0x7F,
  0xE3, 0xFF, 0x0F, 0xB8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0x1C, 0xE3, 0xBC, 0x7F, 0x0F, 0x91, 0xE0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0x0F, 0xC3, 0xFC, 0xFF, 0x1C, 0x23, 0x80, 0x70, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xC8, 0x39, 0xFF, 0x3F, 0xC7, 0xF0,
  0x0E, 0x06, 0x07, 0x07, 0xF7, 0xF7, 0xF8, 0xE0, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xF4, 0x7E, 0x1F, 0x00, 0x3C, 0x39,
  0xC3, 0xCE, 0x1C, 0x70, 0xE7, 0x87, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x70,
  0xE7, 0x87, 0x38, 0x79, 0xC3, 0xCE, 0x3C, 0x7F, 0xE3, 0xFF, 0x0F, 0xB8,
  0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x39, 0xE7, 0x38, 0xEF,
  0x1D, 0xC3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xE1, 0xE1,
  0xF8, 0x78, 0xEE, 0x3E, 0x3B, 0x8F, 0x9E, 0xE7, 0xE7, 0x39, 0xF9, 0xCE,
  0x6C, 0xE3, 0xBB, 0x38, 0xEC, 0xDE, 0x3F, 0x37, 0x0F, 0xCD, 0xC3, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x1E, 0x1C,
  0x78, 0xF0, 0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x01, 0xFC, 0x07, 0x70, 0x39, 0xC1, 0xE7, 0x87, 0x0E,
  0x3C, 0x38, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C,
  0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0xFC, 0xFF, 0x8F, 0xF8,
  0x00, 0x30, 0x1E, 0x03, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0,
  0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x07, 0xE0, 0xF8, 0x10, 0x00, 0x7E,
  0x0F, 0xFF, 0xF9, 0xFF, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 11, 3, -21 },
  { 31, 16, 21, 15, 0, -21 },
  { 73, 14, 24, 13, 0, -22 },
  { 115, 18, 21, 21, 2, -21 },
  { 163, 16, 21, 16, 0, -21 },
  { 205, 4, 8, 7, 3, -21 },
  { 209, 9, 26, 8, 1, -21 },
  { 239, 9, 26, 8, -2, -21 },
  { 269, 11, 12, 13, 3, -22 },
  { 286, 12, 14, 14, 1, -17 },
  { 307, 6, 8, 7, -1, -4 },
  { 313, 8, 3, 8, 0, -9 },
  { 316, 4, 4, 7, 0, -4 },
  { 318, 14, 21, 11, -1, -21 },
  { 355, 12, 21, 13, 1, -21 },
  { 387, 9, 21, 13, 3, -21 },
  { 411, 14, 21, 13, -1, -21 },
  { 448, 13, 21, 13, 0, -21 },
  { 483, 13, 21, 13, 0, -21 },
  { 518, 13, 21, 13, 0, -21 },
  { 553, 13, 21, 13, 1, -21 },
  { 588, 14, 21, 13, 1, -21 },
  { 625, 14, 21, 13, 0, -21 },
  { 662, 13, 21, 13, 0, -21 },
  { 697, 7, 16, 7, 0, -16 },
  { 711, 9, 20, 7, -2, -16 },
  { 734, 13, 14, 14, 1, -17 },
  { 757, 12, 8, 14, 1, -14 },
  { 769, 13, 14, 14, 1, -17 },
  { 792, 10, 21, 10, 1, -21 },
  { 819, 19, 23, 20, 1, -21 },
  { 874, 15, 21, 14, -2, -21 },
  { 914, 15, 21, 15, 0, -21 },
  { 954, 15, 21, 14, 1, -21 },
  { 994, 15, 21, 16, 0, -21 },
  { 1034, 14, 21, 12, 0, -21 },
  { 1071, 14, 21, 12, 0, -21 },
  { 1108, 16, 21, 16, 1, -21 },
  { 1150, 17, 21, 16, 0, -21 },
  { 1195, 12, 21, 9, -1, -21 },
  { 1227, 12, 27, 7, -4, -21 },
  { 1268, 17, 21, 14, 0, -21 },
  { 1313, 10, 21, 12, 0, -21 },
  { 1340, 22, 21, 21, 0, -21 },
  { 1398, 18, 21, 17, 0, -21 },
  { 1446, 16, 21, 17, 1, -21 },
  { 1488, 15, 21, 14, 0, -21 },
  { 1528, 16, 26, 17, 1, -21 },
  { 1580, 14, 21, 14, 0, -21 },
  { 1617, 14, 21, 13, 0, -21 },
  { 1654, 12, 21, 12, 2, -21 },
  { 1686, 16, 21, 16, 1, -21 },
  { 1728, 13, 21, 14, 3, -21 },
  { 1763, 22, 21, 21, 2, -21 },
  { 1821, 18, 21, 13, -2, -21 },
  { 1869, 12, 21, 13, 3, -21 },
  { 1901, 15, 21, 12, -1, -21 },
  { 1941, 12, 26, 9, -1, -21 },
  { 1980, 6, 21, 11, 3, -21 },
  { 1996, 11, 26, 9, -2, -21 },
  { 2032, 13, 13, 13, 0, -21 },
  { 2054, 11, 1, 10, -3, 3 },
  { 2056, 5, 4, 8, 4, -22 },
  { 2059, 13, 16, 14, 1, -16 },
  { 2085, 13, 22, 14, 0, -22 },
  { 2121, 11, 16, 11, 1, -16 },
  { 2143, 14, 22, 14, 1, -22 },
  { 2182, 11, 16, 13, 1, -16 },
  { 2204, 15, 29, 8, -3, -22 },
  { 2259, 14, 23, 14, 0, -16 },
  { 2300, 13, 22, 14, 0, -22 },
  { 2336, 8, 22, 7, 0, -22 },
  { 2358, 12, 29, 7, -4, -22 },
  { 2402, 14, 22, 13, 0, -22 },
  { 2441, 8, 22, 7, 0, -22 },
  { 2463, 20, 16, 21, 0, -16 },
  { 2503, 13, 16, 14, 0, -16 },
  { 2529, 12, 16, 14, 1, -16 },
  { 2553, 14, 23, 14, -1, -16 },
  { 2594, 13, 23, 14, 1, -16 },
  { 2632, 11, 16, 10, 0, -16 },
  { 2654, 11, 16, 11, 0, -16 },
  { 2676, 9, 19, 9, 1, -19 },
  { 2698, 13, 16, 14, 1, -16 },
  { 2724, 11, 16, 12, 2, -16 },
  { 2746, 18, 16, 19, 2, -16 },
  { 2782, 14, 16, 12, -1, -16 },
  { 2810, 16, 23, 12, -2, -16 },
  { 2856, 12, 16, 10, -1, -16 },
  { 2880, 12, 26, 10, 0, -21 },
  { 2919, 2, 29, 12, 5, -22 },
  { 2927, 11, 26, 10, -2, -21 },
  { 2963, 13, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC29PT7B_H_
