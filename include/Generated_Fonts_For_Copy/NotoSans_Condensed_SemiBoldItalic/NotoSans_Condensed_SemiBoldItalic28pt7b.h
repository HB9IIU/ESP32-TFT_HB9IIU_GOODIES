#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x73, 0xBB, 0xF9,
  0xDC, 0xEE, 0x77, 0x33, 0x18, 0x01, 0x8C, 0x03, 0x38, 0x0E, 0x60, 0x18,
  0xC0, 0x33, 0x80, 0xE7, 0x0F, 0xFF, 0x9F, 0xFF, 0x0E, 0x70, 0x18, 0xC0,
  0x31, 0x80, 0xE7, 0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x70, 0x1C, 0xC0, 0x31,
  0x80, 0x67, 0x01, 0xCE, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0xFC,
  0x1F, 0xF1, 0xFF, 0x0E, 0xC8, 0x76, 0x03, 0xA0, 0x1D, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0x70, 0x1B, 0x90, 0xDC, 0x45, 0xE7, 0xFE,
  0x3F, 0xE0, 0x7C, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x1E, 0x07, 0x1F,
  0x07, 0x1D, 0xC3, 0x1C, 0xE3, 0x0E, 0x73, 0x86, 0x31, 0x83, 0x19, 0xC1,
  0x8C, 0xC0, 0xCE, 0xCF, 0x66, 0xEF, 0xFF, 0x6E, 0x7F, 0x77, 0x30, 0x33,
  0x18, 0x3B, 0x8C, 0x39, 0xCE, 0x18, 0xE7, 0x1C, 0x73, 0x0C, 0x3B, 0x8E,
  0x1F, 0x8E, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0xE0, 0x3D, 0xE0, 0x71, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x07, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x7E,
  0x39, 0xDC, 0xE7, 0x3D, 0xCE, 0x3F, 0x3C, 0x7E, 0x70, 0x78, 0xF0, 0xF1,
  0xF7, 0xE1, 0xFF, 0xE1, 0xF9, 0xE0, 0x77, 0xEE, 0xEE, 0xC0, 0x03, 0x83,
  0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81,
  0xC1, 0xC1, 0xC1, 0xC0, 0x07, 0x00, 0xE1, 0x98, 0x3B, 0x1F, 0xFE, 0x1F,
  0xC7, 0xC1, 0xD8, 0x7B, 0x86, 0x70, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0xE7, 0x1C, 0xE3, 0x8C, 0x00, 0x7F,
  0x7E, 0xFE, 0x7F, 0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0x77, 0x87,
  0x70, 0xF7, 0x0F, 0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C,
  0xE1, 0xCE, 0x3C, 0xE3, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x07, 0x87, 0x87,
  0xC7, 0xEF, 0x77, 0x79, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0x83, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFE,
  0x10, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x0F, 0xE0, 0x7C, 0x03,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x81, 0xE7, 0xFE,
  0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3F,
  0x01, 0xB8, 0x1B, 0x81, 0xDC, 0x0C, 0xE0, 0xC7, 0x0E, 0x38, 0xE3, 0x86,
  0x1C, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3F, 0xC1, 0xFF, 0x04, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x81, 0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xF0,
  0x7F, 0x0F, 0xB1, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x38, 0x7F, 0xC7,
  0xFE, 0xF9, 0xEF, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCF,
  0xF8, 0x7F, 0x03, 0xE0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0x87, 0x9E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71,
  0xC3, 0xDE, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x7B, 0xC7, 0x0E, 0x38, 0x73,
  0x83, 0x9C, 0x1C, 0xF0, 0xE3, 0xDF, 0x1F, 0xF0, 0x7F, 0x00, 0x07, 0xE0,
  0x7F, 0x87, 0xFC, 0x38, 0xE3, 0xC7, 0x9C, 0x3C, 0xE1, 0xE7, 0x0E, 0x38,
  0x71, 0xC7, 0x8F, 0xFC, 0x7E, 0xE0, 0xEE, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x87, 0x7C, 0x3F, 0xC1, 0xF8, 0x00, 0x1C, 0x3C, 0x70, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x1E, 0x38, 0x00, 0x0E, 0x0F, 0x0E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0x70,
  0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x9F,
  0xF3, 0xBC, 0x87, 0x01, 0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xC0,
  0xE0, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x03, 0x80, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x38, 0x06, 0x1C, 0x01, 0xCE, 0x1E,
  0x33, 0x1F, 0xCD, 0xCE, 0x63, 0x63, 0x18, 0xD9, 0xC6, 0x3E, 0x63, 0x9F,
  0x18, 0xE6, 0xCE, 0x31, 0xB3, 0x9C, 0xEC, 0xE7, 0x33, 0x1F, 0xF8, 0xC3,
  0x9C, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x40, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0xD8, 0x07, 0x70,
  0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x07,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F, 0x1E, 0x1C, 0x78, 0x71, 0xC3,
  0xC7, 0x0E, 0x1F, 0xF0, 0xFF, 0x03, 0xFF, 0x0E, 0x1C, 0x38, 0x78, 0xE1,
  0xE7, 0x87, 0x9C, 0x1C, 0x70, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x03,
  0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E,
  0x0F, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xE3, 0x83, 0xC7, 0x07,
  0x9E, 0x1E, 0x38, 0x3C, 0x71, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0xFE, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0xF8, 0x21, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE1,
  0xFB, 0xC3, 0xF7, 0x8F, 0xCF, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x78, 0x3C,
  0x78, 0x70, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C,
  0x78, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78, 0x70, 0x78, 0xF0, 0x70,
  0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x9E, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x0F, 0x0F, 0x0E,
  0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x1C, 0xE0, 0x1D,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x39, 0xC0, 0x39,
  0xC0, 0x79, 0xE0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0xF0,
  0xF0, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1F, 0xF7,
  0xFB, 0xFE, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0D, 0xC3, 0xF0, 0xFE, 0x1F,
  0x86, 0xE1, 0xCC, 0x77, 0x0E, 0x63, 0x38, 0x73, 0x39, 0xC3, 0x99, 0x9E,
  0x1C, 0xDC, 0xE1, 0xC6, 0xE7, 0x0E, 0x3E, 0x38, 0x71, 0xF1, 0xC3, 0x8F,
  0x1C, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x00, 0x0F, 0x03, 0x87, 0x81, 0xC3,
  0xE0, 0xE1, 0xF0, 0x71, 0xF8, 0x70, 0xFC, 0x38, 0x77, 0x1C, 0x3B, 0x8E,
  0x1D, 0xC7, 0x1C, 0xE7, 0x0E, 0x73, 0x87, 0x1D, 0xC3, 0x8E, 0xE1, 0xC7,
  0x71, 0xC3, 0xB0, 0xE0, 0xF8, 0x70, 0x7C, 0x38, 0x3E, 0x1C, 0x1F, 0x1C,
  0x0F, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF3, 0xC1, 0xE7,
  0x81, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x1E, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x70, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F, 0x1E,
  0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x0F, 0x1C, 0x38, 0xF3, 0xE3, 0xFF, 0x0F,
  0xF8, 0x3F, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF3, 0xC1,
  0xE7, 0x81, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x1E, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x70, 0xF0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x83, 0x8F, 0x0E, 0x3C, 0x78,
  0xF1, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x39,
  0xC0, 0xE7, 0x07, 0x9E, 0x1C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x3C,
  0x3C, 0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x3C, 0x21, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x83, 0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0xF7,
  0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xF3,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xC0,
  0xE3, 0x83, 0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xE0,
  0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x3D, 0xC0, 0xE7, 0x07, 0x9C,
  0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xCF, 0x07,
  0x38, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x70, 0x3B, 0x83, 0x83, 0xDC, 0x3C,
  0x1D, 0xE1, 0xE0, 0xEF, 0x0F, 0x0E, 0x78, 0xF8, 0x73, 0xC6, 0xC7, 0x9C,
  0x76, 0x38, 0xE3, 0xB1, 0xC7, 0x39, 0x9C, 0x39, 0xDC, 0xE1, 0xCC, 0xEE,
  0x0E, 0xE7, 0x70, 0x77, 0x3B, 0x83, 0xB1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x07,
  0x83, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x1C, 0x3C,
  0x1E, 0x1E, 0x1E, 0x07, 0x00, 0xF0, 0x7B, 0x83, 0x9C, 0x38, 0xE3, 0xC7,
  0x1C, 0x39, 0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0x8F, 0xFE, 0x3F,
  0xF0, 0x07, 0xE0, 0xFC, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0x87, 0xE0, 0xE7, 0x39,
  0xCE, 0x31, 0xCE, 0x73, 0x9C, 0xE3, 0x1C, 0xE7, 0x39, 0xCE, 0x70, 0x07,
  0xE0, 0xFC, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x3F, 0x07, 0xE0, 0x01, 0x80, 0x0E, 0x00,
  0xF0, 0x0F, 0x80, 0x6E, 0x07, 0x70, 0x73, 0x83, 0x8C, 0x38, 0x71, 0x83,
  0x9C, 0x0D, 0xC0, 0x70, 0x7F, 0xFF, 0xF0, 0xF3, 0x8C, 0x70, 0x0F, 0x38,
  0xFF, 0x8F, 0x7C, 0xF1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0,
  0xE7, 0x0F, 0x38, 0x71, 0xC7, 0x8F, 0x7C, 0x7E, 0xE1, 0xE7, 0x00, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x77, 0xC3, 0xFE,
  0x1E, 0x78, 0xE1, 0xCF, 0x0E, 0x70, 0x73, 0x87, 0x9C, 0x3D, 0xE1, 0xCE,
  0x0E, 0x70, 0xF3, 0xC7, 0x1E, 0x79, 0xDF, 0x8E, 0xF8, 0x00, 0x0F, 0xC7,
  0xF3, 0xCD, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0x1F, 0xC3, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0xF7, 0x07, 0xFC, 0x3D, 0xF1, 0xE3, 0xC7, 0x0F,
  0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xC3, 0x8F,
  0x0F, 0x7C, 0x3F, 0xF0, 0x7D, 0x80, 0x0F, 0xC3, 0xFC, 0xE3, 0xBC, 0x77,
  0x0E, 0xE3, 0xBF, 0xF7, 0xF8, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x18,
  0xFF, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x0E, 0x40, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xE0,
  0x0F, 0x80, 0x38, 0x00, 0x07, 0xDC, 0x3F, 0xE1, 0xEF, 0x8F, 0x1E, 0x38,
  0x78, 0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x1C,
  0x78, 0x7B, 0xE1, 0xFB, 0x83, 0xDE, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x08,
  0x38, 0x3F, 0xE0, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x77, 0xC3, 0xFE, 0x1E, 0x78, 0xE3, 0xCF,
  0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xE1, 0xCE, 0x1E, 0x70, 0xE3, 0x87,
  0x1C, 0x39, 0xE1, 0xCE, 0x1E, 0x00, 0x06, 0x0F, 0x0E, 0x04, 0x00, 0x02,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x02,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x11, 0xC3, 0x87, 0x1C, 0x1C,
  0xE0, 0x77, 0x83, 0xBC, 0x0E, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x1E,
  0xE0, 0x73, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xE0, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0x1D, 0xF3, 0xE3, 0xFE, 0xFC,
  0x79, 0xF3, 0x8E, 0x3C, 0x73, 0xC7, 0x8E, 0x70, 0xE1, 0xCE, 0x1C, 0x39,
  0xC3, 0x8F, 0x78, 0xF1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7,
  0x0E, 0x3D, 0xE3, 0x87, 0x38, 0x70, 0xE0, 0x1D, 0xF0, 0xFF, 0x87, 0x9E,
  0x38, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x87, 0x9C,
  0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x87, 0x80, 0x0F, 0xC3, 0xFC, 0xF7,
  0xBC, 0x77, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x71,
  0xEF, 0xF8, 0xFF, 0x0F, 0x80, 0x0E, 0xF8, 0x3F, 0xE0, 0xF3, 0xC3, 0x87,
  0x1E, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0x87,
  0x8F, 0x1C, 0x3F, 0xF1, 0xDF, 0x87, 0x7C, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xB8, 0xFF, 0x8F,
  0x7C, 0xF1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F,
  0x38, 0x71, 0xC7, 0x8F, 0x7C, 0x7E, 0xE1, 0xEE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xE3, 0xF8, 0x7F,
  0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x00, 0x1F, 0xE7, 0xF8, 0xE3, 0x1C, 0x03, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0E, 0x43, 0xCE, 0xF9, 0xFE,
  0x3F, 0x80, 0x0C, 0x1C, 0x1C, 0x7F, 0x7F, 0xB8, 0x38, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xF4, 0xFC, 0x7C, 0x38, 0x73, 0x87, 0x38,
  0x77, 0x87, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xEE, 0x1C, 0xE1,
  0xCE, 0x3C, 0xF7, 0xCF, 0xDC, 0x79, 0x80, 0xE1, 0xFC, 0x3B, 0x87, 0x71,
  0xCE, 0x39, 0xCE, 0x39, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x00, 0xE3, 0xC3, 0xF1, 0xE3, 0xF8, 0xF1, 0xDC, 0xF8,
  0xEE, 0x6C, 0xE7, 0x76, 0x73, 0xBB, 0x31, 0xD9, 0xB8, 0xFD, 0xDC, 0x6C,
  0xFC, 0x36, 0x7E, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x83, 0x87, 0x80,
  0x1E, 0x3C, 0x39, 0xE0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x70, 0x79, 0xC1, 0xC7,
  0x8E, 0x0E, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3,
  0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x7F, 0x8F, 0xF8, 0xFF, 0x80, 0x00, 0xE0, 0x7C, 0x0F,
  0x83, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0xF8, 0x3E,
  0x07, 0x01, 0xF0, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0xF0, 0x1F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xF0, 0x1E, 0x0F, 0xC1, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0xF3,
  0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 7, 11, 3, -20 },
  { 29, 15, 20, 14, 0, -20 },
  { 67, 13, 23, 13, 0, -21 },
  { 105, 17, 20, 20, 2, -20 },
  { 148, 15, 20, 15, 0, -20 },
  { 186, 4, 7, 6, 3, -20 },
  { 190, 9, 24, 8, 1, -20 },
  { 217, 9, 24, 8, -2, -20 },
  { 244, 11, 11, 12, 2, -21 },
  { 260, 12, 14, 14, 1, -17 },
  { 281, 6, 7, 7, -1, -3 },
  { 287, 8, 3, 8, 0, -9 },
  { 290, 4, 4, 7, 0, -4 },
  { 292, 14, 20, 10, -1, -20 },
  { 327, 12, 20, 13, 1, -20 },
  { 357, 9, 20, 13, 3, -20 },
  { 380, 14, 20, 13, -1, -20 },
  { 415, 13, 20, 13, 0, -20 },
  { 448, 13, 20, 13, 0, -20 },
  { 481, 13, 20, 13, 0, -20 },
  { 514, 12, 20, 13, 1, -20 },
  { 544, 13, 20, 13, 1, -20 },
  { 577, 13, 20, 13, 0, -20 },
  { 610, 13, 20, 13, 0, -20 },
  { 643, 7, 15, 7, 0, -15 },
  { 657, 8, 19, 7, -1, -15 },
  { 676, 12, 14, 14, 1, -17 },
  { 697, 12, 8, 14, 1, -14 },
  { 709, 12, 14, 14, 1, -17 },
  { 730, 10, 20, 10, 1, -20 },
  { 755, 18, 22, 19, 1, -20 },
  { 805, 14, 20, 14, -2, -20 },
  { 840, 14, 20, 14, 0, -20 },
  { 875, 14, 20, 13, 1, -20 },
  { 910, 15, 20, 15, 0, -20 },
  { 948, 13, 20, 12, 0, -20 },
  { 981, 13, 20, 12, 0, -20 },
  { 1014, 15, 20, 16, 1, -20 },
  { 1052, 16, 20, 16, 0, -20 },
  { 1092, 12, 20, 9, -1, -20 },
  { 1122, 12, 26, 7, -4, -20 },
  { 1161, 16, 20, 14, 0, -20 },
  { 1201, 10, 20, 11, 0, -20 },
  { 1226, 21, 20, 21, 0, -20 },
  { 1279, 17, 20, 17, 0, -20 },
  { 1322, 15, 20, 16, 1, -20 },
  { 1360, 14, 20, 14, 0, -20 },
  { 1395, 15, 25, 16, 1, -20 },
  { 1442, 14, 20, 14, 0, -20 },
  { 1477, 13, 20, 12, 0, -20 },
  { 1510, 12, 20, 12, 2, -20 },
  { 1540, 15, 20, 16, 1, -20 },
  { 1578, 14, 20, 14, 2, -20 },
  { 1613, 21, 20, 21, 2, -20 },
  { 1666, 17, 20, 13, -2, -20 },
  { 1709, 13, 20, 12, 2, -20 },
  { 1742, 14, 20, 12, -1, -20 },
  { 1777, 11, 24, 8, -1, -20 },
  { 1810, 5, 20, 10, 3, -20 },
  { 1823, 11, 24, 8, -2, -20 },
  { 1856, 13, 12, 13, 0, -20 },
  { 1876, 10, 2, 10, -3, 2 },
  { 1879, 5, 4, 8, 4, -21 },
  { 1882, 13, 15, 14, 1, -15 },
  { 1907, 13, 21, 14, 0, -21 },
  { 1942, 10, 15, 11, 1, -15 },
  { 1961, 14, 21, 14, 1, -21 },
  { 1998, 11, 15, 12, 1, -15 },
  { 2019, 14, 28, 8, -3, -21 },
  { 2068, 14, 22, 14, 0, -15 },
  { 2107, 13, 21, 14, 0, -21 },
  { 2142, 8, 21, 7, 0, -21 },
  { 2163, 12, 28, 7, -4, -21 },
  { 2205, 14, 21, 12, 0, -21 },
  { 2242, 8, 21, 7, 0, -21 },
  { 2263, 19, 15, 20, 0, -15 },
  { 2299, 13, 15, 14, 0, -15 },
  { 2324, 11, 15, 13, 1, -15 },
  { 2345, 14, 22, 14, -1, -15 },
  { 2384, 13, 22, 14, 1, -15 },
  { 2420, 11, 15, 9, 0, -15 },
  { 2441, 11, 15, 11, 0, -15 },
  { 2462, 8, 18, 9, 1, -18 },
  { 2480, 12, 15, 14, 1, -15 },
  { 2503, 11, 15, 12, 2, -15 },
  { 2524, 17, 15, 18, 2, -15 },
  { 2556, 14, 15, 12, -1, -15 },
  { 2583, 15, 22, 12, -2, -15 },
  { 2625, 12, 15, 10, -1, -15 },
  { 2648, 11, 24, 10, 0, -20 },
  { 2681, 2, 27, 12, 5, -21 },
  { 2688, 11, 24, 10, -2, -20 },
  { 2721, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC28PT7B_H_
