#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0x3D, 0xF7, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x80, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0C, 0x30, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x81, 0xFF,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC8, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70,
  0x06, 0x38, 0x03, 0x8E, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x1C,
  0x01, 0xC7, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFE, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0x6E, 0x1E, 0x62, 0x1E, 0x40, 0x1E, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x01, 0x3C, 0x01, 0x3C, 0x83, 0x3C, 0x63, 0x78, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7F, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x00, 0xFC, 0x07, 0x0F, 0xE0, 0x70, 0x77, 0x83, 0x87, 0x1C, 0x38,
  0x38, 0xE3, 0x81, 0xC7, 0x1C, 0x1C, 0x71, 0xC0, 0xE3, 0x8E, 0x07, 0x1C,
  0xE0, 0x38, 0xEE, 0x3D, 0xCE, 0x73, 0xFE, 0x77, 0x3F, 0xFF, 0x3B, 0x9D,
  0xF3, 0x9C, 0xE2, 0x39, 0xC7, 0x01, 0xCE, 0x38, 0x1C, 0x71, 0xC0, 0xE3,
  0x8E, 0x0E, 0x18, 0x70, 0xF1, 0xC7, 0x07, 0x06, 0x38, 0x70, 0x3B, 0x83,
  0x81, 0xFC, 0x38, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x0F, 0x78, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x07,
  0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF8,
  0xF3, 0xFE, 0x3C, 0xF3, 0xDE, 0x78, 0xF7, 0x9C, 0x1F, 0xCF, 0x07, 0xE3,
  0xC1, 0xF8, 0xF0, 0x7C, 0x3E, 0x3F, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0x8F, 0x80, 0x3D, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0xE0, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x0F, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xC7, 0x07, 0x30, 0x7F, 0xFD, 0xFF, 0xE1, 0xFF, 0x1F,
  0x81, 0xFC, 0x1E, 0x70, 0xF3, 0x83, 0x1E, 0x00, 0x40, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x1E, 0x38, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x0F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x1F, 0x3C, 0x78, 0x73, 0xC1, 0xCF, 0x07, 0x3C, 0x1D,
  0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E,
  0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xCF, 0x8F, 0xFC,
  0x1F, 0xE0, 0x3F, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x8F, 0xE3, 0xFD, 0xFF,
  0x9C, 0xF1, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x00, 0x30, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0x0F, 0x06,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x04, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x00, 0x70, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x06,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x80, 0xF8, 0xC1, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xDC, 0x01, 0xFC, 0x03, 0xBC, 0x07, 0x3C, 0x07,
  0x3C, 0x0E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x10, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x80, 0xF8, 0xC1, 0xF0, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x3C, 0x01, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x81,
  0xEF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0x8F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1F, 0x3E, 0x1F, 0xF8,
  0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x0E, 0x1E, 0x0F, 0x3C,
  0x0F, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x3E, 0xF8, 0x3C, 0x78,
  0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF8, 0x78,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xE0, 0x07, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xE7, 0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xDE,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x10, 0x7C, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x06, 0x0F, 0x1F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0,
  0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x03, 0x01,
  0xFE, 0x3F, 0xF3, 0xFF, 0x10, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0x70, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x3E, 0x0F, 0x81, 0xE0, 0x0E, 0x0F,
  0x00, 0x1C, 0x38, 0x00, 0x71, 0xC1, 0xF1, 0xCE, 0x1F, 0xE7, 0x38, 0xF7,
  0x8C, 0xC3, 0x8C, 0x77, 0x1C, 0x71, 0xDC, 0x61, 0xC7, 0x63, 0x87, 0x1F,
  0x8E, 0x38, 0x6E, 0x38, 0xE3, 0xB8, 0xC3, 0x8E, 0xE3, 0x1E, 0x73, 0x8E,
  0x79, 0xCE, 0x3F, 0x7E, 0x38, 0x79, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xE7, 0x01, 0xE3,
  0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C, 0x38, 0x3F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x0F, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xF7, 0xC0, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E,
  0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x07,
  0xC7, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x30, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xF1, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1E, 0x3E,
  0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xE1, 0xE1, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x04, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0x18, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x83, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC0, 0x78, 0xF8,
  0x0F, 0x1F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xFC,
  0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0x07, 0xFC, 0x3F,
  0xF0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x70, 0xF8,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x0E, 0x78,
  0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F,
  0xEF, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x83, 0xFC, 0x0E, 0xE0, 0xEF, 0x07, 0xB8, 0x3B, 0xC1, 0xEE,
  0x1C, 0xE0, 0x7B, 0x87, 0x78, 0x1C, 0xE3, 0xDE, 0x07, 0x38, 0xE7, 0x83,
  0xCE, 0x79, 0xE0, 0xF3, 0x9C, 0x70, 0x3C, 0xEF, 0x3C, 0x0E, 0x3B, 0x8F,
  0x07, 0x8F, 0xE3, 0xC1, 0xE3, 0xF0, 0xE0, 0x78, 0xFC, 0x38, 0x1C, 0x3E,
  0x1E, 0x07, 0x0F, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0x07, 0xC0, 0x78, 0x3E,
  0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x78,
  0x3B, 0x83, 0xC1, 0xDE, 0x1E, 0x0E, 0xF0, 0xE0, 0xF7, 0x8F, 0x07, 0x9C,
  0x78, 0x3C, 0xE3, 0xC1, 0xC7, 0x9C, 0x1E, 0x3C, 0xE0, 0xF0, 0xEF, 0x07,
  0x87, 0x78, 0x3C, 0x3F, 0xC1, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x3F,
  0x07, 0x81, 0xF8, 0x38, 0x0F, 0xC1, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0xC3, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0xF8,
  0x07, 0xBE, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0x9F,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x0F, 0x07, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xCF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0xC3, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0xF8,
  0x07, 0xBE, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0x9F,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x7C,
  0x00, 0x60, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x86, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x80, 0xF8, 0xF1, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF8, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0,
  0xF1, 0xE0, 0xF1, 0xE0, 0x73, 0xC0, 0x73, 0xC0, 0x77, 0x80, 0x77, 0x80,
  0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF0, 0x1C, 0x07, 0xF8, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xDE,
  0x0F, 0x81, 0xEF, 0x07, 0xC1, 0xE7, 0x87, 0xE0, 0xF3, 0xC3, 0xF0, 0x71,
  0xE1, 0xF8, 0x78, 0xF1, 0xDC, 0x3C, 0x78, 0xEE, 0x3C, 0x3C, 0xF7, 0x1E,
  0x1E, 0x73, 0x8E, 0x0F, 0x39, 0xCF, 0x07, 0xBC, 0xE7, 0x83, 0xDC, 0x77,
  0x81, 0xDE, 0x3B, 0xC0, 0xEE, 0x1D, 0xC0, 0x77, 0x0F, 0xE0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x03, 0xC3,
  0xE0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE3, 0x83,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0x77, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x1C,
  0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE3,
  0xC3, 0x87, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80,
  0x77, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x3C, 0x38, 0x38, 0xF0, 0x71, 0xC0,
  0xF7, 0x80, 0xFE, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0xE7, 0x8E, 0x1C,
  0x03, 0x81, 0x0F, 0xEE, 0x1F, 0xEE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3C, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xFF, 0x70, 0x7F, 0x70,
  0x3E, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x38, 0x0F, 0xFC, 0x0E, 0xFE, 0x1F, 0xFE,
  0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x7C, 0x78,
  0x7F, 0xF8, 0xFF, 0xF0, 0xE7, 0xE0, 0x01, 0xE0, 0x3F, 0xC3, 0xFC, 0x3F,
  0xE3, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x18, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x07, 0x1E, 0x0F, 0xEE, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0xC7, 0xC3, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3,
  0xC7, 0xC1, 0xFF, 0xE0, 0x7F, 0x70, 0x1F, 0x38, 0x00, 0x01, 0xC0, 0x1F,
  0xC0, 0xFF, 0x87, 0x9E, 0x3C, 0x3C, 0xE0, 0xE7, 0x83, 0x9E, 0x1E, 0x7F,
  0xF3, 0xFF, 0x8F, 0xF8, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x08, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xF2, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xC0, 0x83, 0xFB, 0x83, 0xFD, 0xC1, 0xFF, 0xE1, 0xF1, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF1, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xDE, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC1, 0x87, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x9C, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x01,
  0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x10, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0x0F, 0x0F, 0x07, 0x0F, 0x07, 0x8F,
  0x03, 0xCF, 0x01, 0xEF, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF0, 0x78, 0x00, 0x00, 0x38, 0x38, 0x1D, 0xF9, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xE1, 0xC7, 0x87, 0x87, 0x8E,
  0x0F, 0x0F, 0x3C, 0x1E, 0x1E, 0x78, 0x38, 0x3C, 0xF0, 0xF0, 0x71, 0xC1,
  0xE1, 0xE7, 0x83, 0xC3, 0xCF, 0x07, 0x07, 0x9E, 0x1E, 0x0F, 0x3C, 0x3C,
  0x1C, 0x70, 0x78, 0x79, 0xE0, 0xF0, 0xF3, 0xC1, 0xC1, 0xE0, 0x00, 0x38,
  0x1D, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xE1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xE0, 0x01, 0xE0,
  0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F,
  0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0x3E, 0x7C, 0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0xEF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1C, 0x0F, 0x0F, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1E, 0x0E,
  0x07, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x7C, 0x78, 0x1F, 0xFE, 0x0F, 0x7F,
  0x03, 0xDF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0xDC, 0x3F, 0xB8, 0xFF, 0xF3, 0xC3, 0xE7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x3E, 0x78, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFB, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x38, 0x77, 0xC3, 0xBC, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFE,
  0x7C, 0xE3, 0xC1, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x90, 0x7C, 0xFF, 0xC7, 0xFC,
  0x3F, 0xC0, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xF7, 0xFC, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xF8, 0x7E, 0x1F, 0x80, 0x1E, 0x1E, 0x38, 0x3C, 0xF0, 0x79,
  0xE0, 0xE3, 0xC1, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0,
  0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x7F, 0xB8,
  0x7F, 0x70, 0xFD, 0xE0, 0xF0, 0x7F, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF0,
  0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xDE, 0x0F, 0x78, 0x1D,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x7E, 0x3D, 0xE3, 0xF1, 0xEF, 0x1F,
  0x8E, 0x79, 0xDC, 0xF3, 0xCE, 0xE7, 0x9E, 0xE7, 0x78, 0xF7, 0x3B, 0xC7,
  0xB9, 0xDC, 0x3B, 0x8F, 0xE1, 0xDC, 0x6E, 0x0E, 0xC7, 0x70, 0x7E, 0x3F,
  0x83, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x00,
  0x07, 0x87, 0xC1, 0xE3, 0xC0, 0x78, 0xF0, 0x0E, 0x78, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0,
  0x7C, 0x3C, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0xF0,
  0x03, 0x9E, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x01, 0xF8, 0x07, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0x01, 0xF8,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x08, 0x02, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xD0, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 12, 9, 13, 3, -24 },
  { 45, 18, 24, 17, 0, -24 },
  { 99, 16, 28, 15, 0, -26 },
  { 155, 21, 25, 24, 2, -25 },
  { 221, 18, 25, 19, 0, -25 },
  { 278, 6, 9, 8, 3, -24 },
  { 285, 11, 29, 10, 1, -24 },
  { 325, 12, 30, 10, -3, -25 },
  { 370, 13, 14, 15, 3, -26 },
  { 393, 14, 16, 17, 2, -20 },
  { 421, 7, 9, 8, -2, -4 },
  { 429, 8, 4, 10, 1, -11 },
  { 433, 5, 5, 8, 0, -5 },
  { 437, 17, 24, 13, -2, -24 },
  { 488, 14, 25, 15, 1, -25 },
  { 532, 11, 24, 16, 3, -24 },
  { 565, 16, 25, 15, -1, -25 },
  { 615, 16, 25, 15, 0, -25 },
  { 665, 16, 24, 16, 0, -24 },
  { 713, 16, 24, 15, 0, -24 },
  { 761, 15, 25, 15, 1, -25 },
  { 808, 16, 24, 15, 1, -24 },
  { 856, 16, 25, 15, 0, -25 },
  { 906, 15, 25, 15, 0, -25 },
  { 953, 8, 19, 8, 0, -19 },
  { 972, 10, 24, 8, -2, -19 },
  { 1002, 15, 16, 17, 1, -20 },
  { 1032, 14, 10, 17, 2, -17 },
  { 1050, 14, 16, 17, 2, -20 },
  { 1078, 12, 25, 12, 1, -25 },
  { 1116, 22, 27, 24, 1, -24 },
  { 1191, 17, 24, 17, -2, -24 },
  { 1242, 17, 24, 17, 0, -24 },
  { 1293, 17, 25, 16, 1, -25 },
  { 1347, 18, 24, 19, 0, -24 },
  { 1401, 16, 24, 15, 0, -24 },
  { 1449, 16, 24, 14, 0, -24 },
  { 1497, 19, 25, 19, 1, -25 },
  { 1557, 20, 24, 19, 0, -24 },
  { 1617, 14, 24, 11, -1, -24 },
  { 1659, 15, 31, 9, -5, -24 },
  { 1718, 20, 24, 17, 0, -24 },
  { 1778, 12, 24, 14, 0, -24 },
  { 1814, 26, 24, 25, 0, -24 },
  { 1892, 21, 24, 20, 0, -24 },
  { 1955, 18, 25, 20, 1, -25 },
  { 2012, 17, 24, 17, 0, -24 },
  { 2063, 18, 31, 20, 1, -25 },
  { 2133, 17, 24, 17, 0, -24 },
  { 2184, 16, 25, 15, 0, -25 },
  { 2234, 14, 24, 14, 3, -24 },
  { 2276, 18, 24, 19, 2, -24 },
  { 2330, 16, 24, 16, 3, -24 },
  { 2378, 25, 24, 25, 3, -24 },
  { 2453, 20, 24, 16, -2, -24 },
  { 2513, 15, 24, 15, 3, -24 },
  { 2558, 17, 24, 14, -1, -24 },
  { 2609, 13, 29, 10, -1, -24 },
  { 2657, 7, 24, 13, 3, -24 },
  { 2678, 13, 29, 10, -2, -24 },
  { 2726, 15, 14, 16, 0, -24 },
  { 2753, 12, 2, 12, -3, 3 },
  { 2756, 6, 5, 10, 5, -26 },
  { 2760, 16, 19, 17, 1, -19 },
  { 2798, 16, 26, 17, 0, -26 },
  { 2850, 13, 19, 13, 1, -19 },
  { 2881, 17, 26, 17, 1, -26 },
  { 2937, 14, 19, 15, 1, -19 },
  { 2971, 18, 34, 10, -4, -26 },
  { 3048, 17, 27, 17, 0, -19 },
  { 3106, 15, 26, 17, 0, -26 },
  { 3155, 9, 26, 8, 0, -26 },
  { 3185, 13, 34, 8, -4, -26 },
  { 3241, 17, 26, 15, 0, -26 },
  { 3297, 9, 26, 8, 0, -26 },
  { 3327, 23, 19, 25, 0, -19 },
  { 3382, 15, 19, 17, 0, -19 },
  { 3418, 14, 19, 16, 1, -19 },
  { 3452, 18, 27, 17, -2, -19 },
  { 3513, 15, 27, 17, 1, -19 },
  { 3564, 13, 19, 11, 0, -19 },
  { 3595, 13, 19, 13, 0, -19 },
  { 3626, 10, 22, 10, 1, -22 },
  { 3654, 15, 18, 16, 1, -18 },
  { 3688, 14, 18, 14, 2, -18 },
  { 3720, 21, 18, 22, 2, -18 },
  { 3768, 18, 18, 14, -2, -18 },
  { 3809, 19, 26, 14, -3, -18 },
  { 3871, 14, 18, 12, -1, -18 },
  { 3903, 14, 29, 12, 0, -24 },
  { 3954, 3, 34, 14, 6, -26 },
  { 3967, 13, 29, 12, -2, -24 },
  { 4015, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC34PT7B_H_
