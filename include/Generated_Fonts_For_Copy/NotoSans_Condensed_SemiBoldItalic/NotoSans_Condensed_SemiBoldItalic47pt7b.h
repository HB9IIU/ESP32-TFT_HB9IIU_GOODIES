#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x0C, 0x00, 0x7E, 0x3E,
  0xFC, 0xFD, 0xF1, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1E, 0x7C,
  0x3C, 0xF8, 0xF9, 0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xB8, 0xC0, 0x7C, 0xE0, 0x03, 0xE3, 0x00, 0x0F, 0x8C, 0x00, 0x3F, 0x30,
  0x00, 0x7D, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0D, 0xF8, 0x00, 0x73, 0xE0, 0x01, 0x8F, 0x80, 0x06, 0x3E,
  0x10, 0x19, 0xF8, 0x70, 0xEF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x7F, 0x80, 0x1E, 0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xF0, 0x1F,
  0x03, 0xC7, 0x80, 0xF0, 0x3E, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x0F,
  0x0F, 0x07, 0x80, 0xF8, 0x78, 0x7C, 0x07, 0x83, 0xC3, 0xC0, 0x3C, 0x1E,
  0x3C, 0x01, 0xE1, 0xF1, 0xE0, 0x0F, 0x0F, 0x1E, 0x00, 0x78, 0x79, 0xF0,
  0xE3, 0xC7, 0xCF, 0x1F, 0xDE, 0x3C, 0xF1, 0xFE, 0xF3, 0xE7, 0x9F, 0xFF,
  0xFE, 0x79, 0xF3, 0xFF, 0xE7, 0xCF, 0x1E, 0xFE, 0x3C, 0xF8, 0xF3, 0xE3,
  0xE7, 0x87, 0x80, 0x1E, 0x3C, 0x3C, 0x01, 0xE3, 0xC1, 0xE0, 0x1F, 0x1E,
  0x0F, 0x00, 0xF0, 0xF0, 0xF8, 0x0F, 0x87, 0x87, 0x80, 0x78, 0x3C, 0x3C,
  0x07, 0x81, 0xE1, 0xE0, 0x7C, 0x0F, 0x1E, 0x03, 0xC0, 0x78, 0xF0, 0x3E,
  0x03, 0xCF, 0x01, 0xE0, 0x1F, 0xF8, 0x1E, 0x00, 0x7F, 0x81, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xC3, 0xFF,
  0x87, 0xE3, 0xF7, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF1, 0xF8,
  0x7E, 0xF8, 0xF8, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7E, 0x03, 0xFC, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFD, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xF8, 0x7F,
  0x00, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x20, 0xF0, 0x1E, 0x3C, 0x07, 0xEE,
  0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xDE, 0x03, 0xE7, 0xC1, 0xF8, 0xF0, 0x1C, 0x3E, 0x02,
  0x0F, 0x80, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x08, 0x7D, 0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7E,
  0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F,
  0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xEF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFE,
  0x3F, 0xFC, 0xFE, 0xF9, 0xF3, 0xF1, 0xC7, 0xC1, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x83, 0xF0, 0x1C, 0x0F, 0xC0, 0x40,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0E, 0x07, 0xE0, 0x10, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x80, 0x1F, 0xC3, 0xC1, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1E,
  0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x1E, 0x3E, 0x00, 0x78, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xE0,
  0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x3F, 0x01, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0xC0, 0x1F, 0x83, 0xE1, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x04, 0x00, 0xFD,
  0xFE, 0x03, 0xEF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x3F,
  0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x07, 0xC0,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xFC, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x80,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF1, 0xFC, 0x1F, 0x83, 0xF0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xF7, 0xF0, 0x3F, 0x8F, 0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x07, 0xF3, 0xE0, 0x7F, 0x3F, 0x0F, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xF7, 0xC0, 0x7C, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x08, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x87, 0xF0,
  0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0xC0, 0xFC,
  0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x80, 0x80, 0x00, 0x00, 0x70, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xC0, 0xFC,
  0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x0F,
  0x01, 0xF0, 0x3C, 0x3C, 0x0F, 0xFC, 0x78, 0x78, 0x3F, 0xF8, 0xF1, 0xE0,
  0xFF, 0xE1, 0xE3, 0xC3, 0xC3, 0xC3, 0xCF, 0x0F, 0x87, 0x87, 0x9E, 0x1E,
  0x0F, 0x0F, 0x3C, 0x78, 0x3C, 0x1E, 0xF0, 0xF0, 0x78, 0x3D, 0xE1, 0xE0,
  0xF0, 0x73, 0xC3, 0x81, 0xE1, 0xE7, 0x8F, 0x07, 0x83, 0xCE, 0x1E, 0x0F,
  0x07, 0x1C, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x7C, 0x38, 0xF0, 0xF0, 0xF8,
  0xF1, 0xE1, 0xFF, 0x7F, 0xC3, 0xC1, 0xFE, 0xFF, 0x03, 0x83, 0xF8, 0xFC,
  0x07, 0x81, 0xC0, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0,
  0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01,
  0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0x03, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x08, 0x0F,
  0xFB, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x8F, 0xF8, 0x0F, 0xC1, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0x80, 0xFE, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xE0, 0x70, 0x1F, 0xC0, 0x08, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xFE, 0x3E, 0x03, 0xFF, 0x3F, 0x03, 0xFF, 0x1F, 0x81, 0xFF, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E,
  0x07, 0xF0, 0x1F, 0x03, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x47, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x07,
  0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7B, 0xC0, 0x1E, 0xF8, 0x1F, 0x78, 0x07,
  0xFE, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x0F, 0xBC,
  0x07, 0x9F, 0x01, 0xF7, 0x81, 0xF7, 0xE0, 0x7C, 0xF0, 0x3C, 0xF8, 0x0F,
  0x9E, 0x0F, 0x9F, 0x01, 0xF3, 0xE1, 0xE3, 0xE0, 0x3E, 0x7C, 0x7C, 0xFC,
  0x0F, 0xCF, 0x8F, 0x9F, 0x01, 0xF1, 0xF3, 0xE3, 0xE0, 0x3E, 0x3E, 0x7C,
  0x7C, 0x07, 0xC7, 0xDF, 0x0F, 0x80, 0xF8, 0xFB, 0xE3, 0xF0, 0x3E, 0x1F,
  0x78, 0x7C, 0x07, 0xC3, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xC1, 0xF0, 0x1F,
  0x07, 0xF8, 0x3E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x0F, 0xE0,
  0x07, 0xC0, 0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x1F,
  0x01, 0xFF, 0x00, 0xF8, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x3E, 0x03,
  0xFE, 0x01, 0xF0, 0x1E, 0xF8, 0x1F, 0x01, 0xF7, 0xC0, 0xF8, 0x0F, 0xBE,
  0x07, 0xC0, 0x7D, 0xF0, 0x3E, 0x03, 0xE7, 0xC3, 0xF0, 0x3E, 0x3E, 0x1F,
  0x01, 0xF1, 0xF0, 0xF8, 0x0F, 0x8F, 0x87, 0xC0, 0x7C, 0x7C, 0x3E, 0x03,
  0xE1, 0xF3, 0xE0, 0x3E, 0x0F, 0x9F, 0x01, 0xF0, 0x7C, 0xF8, 0x0F, 0x83,
  0xE7, 0xC0, 0x7C, 0x0F, 0xBE, 0x03, 0xE0, 0x7D, 0xE0, 0x3E, 0x03, 0xFF,
  0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x03, 0xFE, 0x03,
  0xE0, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0xF8, 0x0F, 0x80,
  0x1F, 0xC0, 0x7C, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0xC0,
  0x7F, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE1,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC1, 0xC0, 0x7E, 0x01,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x20, 0x07, 0xE0, 0xE0, 0x3F,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F,
  0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x0F,
  0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x00, 0xF9, 0xF0,
  0x0F, 0xE0, 0x3F, 0x3E, 0x01, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x80, 0xF8,
  0xF8, 0x0F, 0xF0, 0x3F, 0x1F, 0x03, 0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0xC1,
  0xF8, 0x7C, 0x0F, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF0, 0x7B,
  0xE1, 0xF8, 0x3E, 0x1F, 0x7C, 0x3E, 0x07, 0xC3, 0xEF, 0x8F, 0xC0, 0xF8,
  0x79, 0xF1, 0xF0, 0x1F, 0x1F, 0x3E, 0x3E, 0x03, 0xE3, 0xC7, 0xCF, 0xC0,
  0x7C, 0xF8, 0xF9, 0xF0, 0x0F, 0x9F, 0x1F, 0x3E, 0x01, 0xF3, 0xC3, 0xEF,
  0x80, 0x3E, 0xF8, 0x7D, 0xF0, 0x07, 0xDE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1,
  0xEF, 0x80, 0x1F, 0xF0, 0x3D, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00,
  0xFC, 0xF8, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC,
  0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xF7, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0xF9, 0xF0, 0x3F, 0xE7, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFB, 0xE0, 0x3F, 0xCF, 0x80, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x3C, 0x01, 0xFB, 0xFC, 0x07, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFC, 0x3E, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xE3,
  0xF0, 0x7F, 0xFF, 0x81, 0xEF, 0xFE, 0x0F, 0x9F, 0xF0, 0x3C, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xF0, 0x21, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x04, 0x1F,
  0xC7, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x7C, 0x01, 0xFE, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F,
  0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xEF, 0x80, 0x1F, 0x8F, 0x80, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0x7E, 0x1F,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF9, 0xF8,
  0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x0C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x88, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x9F, 0x00, 0xFF, 0xDE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x8F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x0F, 0xF3,
  0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0xC0, 0x1F, 0x80, 0xF0, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0xF0, 0x0F, 0xDF, 0xE0, 0x7D, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x3F, 0x0F, 0xE0, 0xF8, 0x7E, 0x07,
  0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x80,
  0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x13, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x08, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0x80, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xCF,
  0xF1, 0xFE, 0x07, 0xDF, 0xF3, 0xFF, 0x07, 0xBF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0x0F, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0x1F, 0x81,
  0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x03,
  0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x3F, 0x03, 0xE0, 0x3E, 0x3E, 0x03,
  0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07,
  0xC0, 0x7C, 0x7E, 0x07, 0xC0, 0xFC, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x07,
  0xC0, 0xF8, 0x7C, 0x0F, 0xC0, 0xF8, 0xFC, 0x0F, 0x80, 0xF8, 0xF8, 0x0F,
  0x81, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x7F, 0x81, 0xE7, 0xFE, 0x0F, 0x7F,
  0xF0, 0x7F, 0xFF, 0x87, 0xF8, 0xFC, 0x3F, 0x83, 0xE1, 0xF8, 0x1F, 0x0F,
  0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F,
  0x7E, 0x01, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03,
  0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0x7C, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF3, 0xFC, 0x01, 0xF7,
  0xFC, 0x01, 0xEF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x3E, 0x03, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xE3, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x7F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF9,
  0xF0, 0x3F, 0xF7, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x87, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x3F, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFB,
  0xE0, 0x3F, 0xCF, 0x80, 0x7E, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC1, 0xF3, 0xF0, 0x7D, 0xF8, 0x1F, 0xFE, 0x07, 0xBF,
  0x83, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xCF, 0x87,
  0xE0, 0x41, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x80, 0x7E, 0x38,
  0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x13, 0xFF, 0x9F,
  0xFE, 0x7F, 0xFB, 0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x84, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xF0, 0x7E, 0x0F, 0xC7,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x7C, 0x0F, 0xF3, 0xC0, 0x7F, 0x1E, 0x00,
  0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0x0F, 0xE0, 0x7D, 0xF0,
  0x7F, 0x03, 0xEF, 0x83, 0xF8, 0x3E, 0x7C, 0x3F, 0xC1, 0xF3, 0xE1, 0xFE,
  0x1F, 0x1F, 0x1F, 0xF0, 0xF8, 0xF8, 0xF7, 0x87, 0xC7, 0xC7, 0xBC, 0x7C,
  0x3E, 0x79, 0xE3, 0xE1, 0xF3, 0xCF, 0x3E, 0x0F, 0xBE, 0x79, 0xF0, 0x7D,
  0xE3, 0xCF, 0x83, 0xEF, 0x1E, 0xF8, 0x1F, 0xF0, 0xF7, 0xC0, 0xF7, 0x87,
  0xBC, 0x07, 0xBC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x03, 0xE0,
  0x7C, 0x03, 0xF0, 0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF3,
  0xF0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xDF,
  0x80, 0x0F, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x02, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x07, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 35, 12, 0, -34 },
  { 58, 15, 13, 18, 5, -34 },
  { 83, 25, 34, 24, 0, -34 },
  { 190, 22, 39, 21, 0, -36 },
  { 298, 29, 34, 34, 3, -34 },
  { 422, 25, 34, 26, 0, -34 },
  { 529, 7, 13, 11, 5, -34 },
  { 541, 16, 41, 13, 1, -34 },
  { 623, 16, 41, 13, -4, -34 },
  { 705, 18, 19, 21, 4, -36 },
  { 748, 20, 23, 23, 2, -28 },
  { 806, 10, 12, 11, -2, -6 },
  { 821, 12, 5, 14, 1, -15 },
  { 829, 7, 8, 11, 0, -7 },
  { 836, 23, 34, 17, -2, -34 },
  { 934, 20, 34, 21, 1, -34 },
  { 1019, 15, 34, 22, 5, -34 },
  { 1083, 22, 34, 21, -1, -34 },
  { 1177, 22, 34, 21, 0, -34 },
  { 1271, 23, 34, 22, -1, -34 },
  { 1369, 22, 34, 21, 0, -34 },
  { 1463, 22, 34, 21, 1, -34 },
  { 1557, 22, 34, 21, 2, -34 },
  { 1651, 22, 34, 21, 0, -34 },
  { 1745, 20, 34, 21, 1, -34 },
  { 1830, 11, 27, 11, 0, -26 },
  { 1868, 13, 32, 11, -2, -26 },
  { 1920, 20, 22, 23, 2, -28 },
  { 1975, 20, 13, 23, 2, -23 },
  { 2008, 20, 22, 23, 2, -28 },
  { 2063, 17, 34, 17, 2, -34 },
  { 2136, 31, 38, 33, 1, -34 },
  { 2284, 23, 34, 23, -3, -34 },
  { 2382, 24, 34, 24, 0, -34 },
  { 2484, 23, 34, 22, 2, -34 },
  { 2582, 25, 34, 26, 0, -34 },
  { 2689, 22, 34, 20, 0, -34 },
  { 2783, 22, 34, 19, 0, -34 },
  { 2877, 25, 34, 27, 2, -34 },
  { 2984, 28, 34, 27, 0, -34 },
  { 3103, 20, 34, 15, -2, -34 },
  { 3188, 20, 44, 12, -7, -34 },
  { 3298, 27, 34, 23, 0, -34 },
  { 3413, 16, 34, 19, 0, -34 },
  { 3481, 35, 34, 35, 0, -34 },
  { 3630, 29, 34, 28, 0, -34 },
  { 3754, 25, 34, 28, 2, -34 },
  { 3861, 24, 34, 23, 0, -34 },
  { 3963, 25, 42, 28, 2, -34 },
  { 4095, 23, 34, 23, 0, -34 },
  { 4193, 22, 34, 20, 0, -34 },
  { 4287, 19, 34, 20, 4, -34 },
  { 4368, 25, 34, 26, 2, -34 },
  { 4475, 23, 34, 23, 4, -34 },
  { 4573, 35, 34, 35, 4, -34 },
  { 4722, 28, 34, 22, -3, -34 },
  { 4841, 21, 34, 21, 4, -34 },
  { 4931, 24, 34, 20, -2, -34 },
  { 5033, 18, 41, 14, -1, -34 },
  { 5126, 9, 34, 18, 5, -34 },
  { 5165, 18, 41, 14, -3, -34 },
  { 5258, 21, 20, 22, 0, -34 },
  { 5311, 16, 3, 16, -4, 4 },
  { 5317, 8, 8, 14, 7, -36 },
  { 5325, 22, 26, 23, 1, -26 },
  { 5397, 22, 36, 23, 0, -36 },
  { 5496, 18, 26, 18, 1, -26 },
  { 5555, 24, 36, 23, 1, -36 },
  { 5663, 19, 26, 21, 1, -26 },
  { 5725, 24, 47, 14, -5, -36 },
  { 5866, 24, 37, 23, -1, -26 },
  { 5977, 21, 36, 23, 0, -36 },
  { 6072, 13, 35, 11, 0, -35 },
  { 6129, 19, 46, 11, -6, -35 },
  { 6239, 23, 36, 21, 0, -36 },
  { 6343, 13, 36, 11, 0, -36 },
  { 6402, 32, 26, 34, 0, -26 },
  { 6506, 21, 26, 23, 0, -26 },
  { 6575, 20, 26, 22, 1, -26 },
  { 6640, 24, 37, 23, -2, -26 },
  { 6751, 22, 37, 23, 1, -26 },
  { 6853, 18, 26, 16, 0, -26 },
  { 6912, 18, 26, 18, 0, -26 },
  { 6971, 14, 31, 14, 2, -31 },
  { 7026, 21, 25, 23, 2, -25 },
  { 7092, 19, 25, 19, 3, -25 },
  { 7152, 29, 25, 30, 3, -25 },
  { 7243, 24, 25, 20, -2, -25 },
  { 7318, 26, 36, 20, -4, -25 },
  { 7435, 19, 25, 17, -1, -25 },
  { 7495, 18, 41, 16, 1, -34 },
  { 7588, 4, 47, 20, 8, -36 },
  { 7612, 18, 41, 16, -3, -34 },
  { 7705, 20, 7, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC47PT7B_H_
