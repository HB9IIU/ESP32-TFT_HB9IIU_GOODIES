#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x77, 0xF3, 0xB9, 0xDC,
  0xEC, 0x66, 0x33, 0x38, 0x01, 0x9C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x07,
  0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x98, 0x0C, 0x60, 0x33, 0x81, 0xCC, 0x3F,
  0xFE, 0xFF, 0xF8, 0x66, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x81, 0xCC, 0x06,
  0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x0F, 0xF0, 0xFF, 0x0F, 0xD8,
  0x74, 0x03, 0x20, 0x1D, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x1B, 0x80, 0x9C, 0x45, 0xE7, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x07, 0xC1, 0xC3, 0xF0, 0xE0, 0xCC,
  0x30, 0x73, 0x1C, 0x18, 0xC6, 0x06, 0x33, 0x01, 0x9D, 0xC0, 0xE6, 0x67,
  0x39, 0xBB, 0xE7, 0xED, 0xD9, 0xF6, 0x67, 0x13, 0xB9, 0x80, 0xCC, 0x60,
  0x73, 0x18, 0x18, 0xC6, 0x0E, 0x33, 0x87, 0x0C, 0xC1, 0x83, 0xF0, 0xE0,
  0x78, 0x00, 0x80, 0x0F, 0x80, 0x7F, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xEE, 0x03, 0xB8, 0x0F, 0xC0, 0x3E, 0x01, 0xF1, 0xCE, 0xE7, 0x73, 0x9D,
  0xC7, 0xEE, 0x1F, 0xB8, 0x7C, 0xE1, 0xE3, 0xCF, 0xC7, 0xFF, 0x0F, 0x9E,
  0x7E, 0xEE, 0xEC, 0xC0, 0x07, 0x87, 0x03, 0x83, 0x81, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC1, 0xC1, 0xC0, 0x04, 0x00, 0xE0,
  0x18, 0x33, 0x07, 0xEF, 0xFF, 0xC3, 0xF8, 0xF0, 0x7B, 0x0E, 0x70, 0x8E,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x39, 0xDC, 0xEE,
  0x73, 0x00, 0x7E, 0xFF, 0xF8, 0x6F, 0xFE, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x8E, 0x73, 0x8E, 0x71, 0xDC, 0x3B,
  0x87, 0x70, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C,
  0xE7, 0x9F, 0xE3, 0xF8, 0x3E, 0x00, 0x07, 0x1F, 0x3F, 0x7E, 0xFE, 0x4E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70,
  0x70, 0x00, 0x80, 0x3F, 0x83, 0xFE, 0x1C, 0xF0, 0x43, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0x80, 0x01, 0x00,
  0xFE, 0x1F, 0xF0, 0xCF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0,
  0xF8, 0x0F, 0x81, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x81, 0xCE,
  0xFC, 0xFF, 0x8F, 0xE0, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x7E, 0x0E, 0xE0, 0xCE, 0x18, 0xE3, 0x9C, 0x31, 0xC6, 0x1C, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x90, 0x78, 0xFF,
  0xC7, 0xFC, 0x3F, 0x80, 0x00, 0xE0, 0x3F, 0x0F, 0xF0, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x77, 0x87, 0xFC, 0xF9, 0xCF, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x78, 0x7F, 0x03, 0xE0, 0x3F, 0xF9,
  0xFF, 0x8F, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x00, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x38, 0xE1,
  0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x9E, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x7F,
  0x87, 0x9E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x9E, 0x1F, 0xF0,
  0x7E, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xEF, 0x3C, 0x73, 0x87, 0x38,
  0x73, 0x87, 0x38, 0xF3, 0x8F, 0x3F, 0xF3, 0xFE, 0x1E, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x8C, 0xF8, 0xFF, 0x0F, 0xC0, 0x0C, 0x73, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x06, 0x1C, 0x38, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x1C, 0x38, 0xE1, 0xC3,
  0x00, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x3E, 0x0F, 0x87, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x06, 0x0F, 0xE7, 0xF8, 0x8F, 0x01, 0xC0, 0x70,
  0x38, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x3C, 0x0F, 0x03, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0x80, 0xC3,
  0x80, 0x31, 0x80, 0x19, 0x87, 0xCD, 0xC7, 0xE6, 0xC6, 0x33, 0x67, 0x39,
  0xF3, 0x18, 0xF1, 0x8C, 0x79, 0xCE, 0x7C, 0xE7, 0x36, 0x73, 0xBB, 0x3E,
  0xF9, 0x8E, 0x78, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x04, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0E,
  0xE0, 0x3B, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE3, 0xC3, 0x8E, 0x0F, 0x78, 0x3D, 0xC0, 0xFF, 0x03, 0xC0,
  0x0F, 0xF0, 0x3F, 0xE0, 0xE7, 0xC7, 0x8F, 0x1C, 0x3C, 0x70, 0xE1, 0xC3,
  0x87, 0x3C, 0x3F, 0xE0, 0xFF, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x71, 0xC1,
  0xC7, 0x07, 0x1C, 0x3C, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x40,
  0x1F, 0xC3, 0xFE, 0x3E, 0x21, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC7, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0,
  0x73, 0x83, 0xCE, 0x0F, 0x38, 0x39, 0xE1, 0xE7, 0x0F, 0x1C, 0x7C, 0x7F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFE, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0x83, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0x83, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x07, 0xFC, 0x3F,
  0xF0, 0xF8, 0xE1, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE1, 0xF3, 0xC7, 0xE7, 0x8F, 0xCF, 0x03, 0x9E, 0x0F, 0x3C, 0x1C, 0x78,
  0x38, 0x70, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x0E, 0x07, 0x0E,
  0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78,
  0x38, 0x70, 0x38, 0x70, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x70, 0x0F,
  0xE1, 0xFC, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x1F, 0xE3,
  0xF8, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x09, 0xE0, 0xFC,
  0x0F, 0x80, 0x20, 0x00, 0x0E, 0x1F, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x78,
  0x1C, 0xF0, 0x1C, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3B, 0xC0, 0x39, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x71, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xF0, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0x7F, 0xBF, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE,
  0x3B, 0x8E, 0xE3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xBB, 0x9C, 0x33, 0xB9,
  0xC7, 0x1B, 0x38, 0x71, 0xF3, 0x87, 0x1E, 0x38, 0x71, 0xE3, 0x86, 0x1C,
  0x38, 0xE1, 0xC7, 0x00, 0x0F, 0x03, 0x87, 0x81, 0x83, 0xC1, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x38, 0x33, 0x9C, 0x39, 0xCE, 0x1C,
  0xE7, 0x0E, 0x73, 0x87, 0x1B, 0x83, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF0, 0x70, 0x78, 0x30, 0x3C, 0x38, 0x1E, 0x00, 0x00, 0x80, 0x1F,
  0xC0, 0xFF, 0x87, 0xCF, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70,
  0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xEF, 0x07, 0xBC,
  0x1C, 0xF0, 0xF1, 0xFF, 0x87, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0xEF, 0x87, 0x8F, 0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x78,
  0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x87,
  0xCF, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF1,
  0xFF, 0x87, 0xFC, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0x9E, 0x1C, 0x71, 0xC3, 0x8E, 0x1C,
  0x70, 0xE3, 0x8F, 0x3C, 0xF1, 0xFF, 0x0F, 0xF0, 0x77, 0x83, 0x9C, 0x38,
  0xE1, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x38, 0x3C, 0x00, 0x80, 0x3F,
  0xC3, 0xFC, 0x3C, 0xE1, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x83,
  0xC7, 0xFC, 0x3F, 0xE1, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x1E, 0x38,
  0x38, 0x70, 0x71, 0xE0, 0xE3, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38,
  0x38, 0x78, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xF0, 0x3F, 0x83,
  0xDC, 0x1C, 0xE1, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x73, 0x83,
  0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x70, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0xEE,
  0x1F, 0x0E, 0xE1, 0xF1, 0xCE, 0x1F, 0x1C, 0xE3, 0xF1, 0xCE, 0x37, 0x38,
  0xE7, 0x73, 0x8E, 0x77, 0x70, 0xE6, 0x77, 0x0E, 0xE7, 0x70, 0xEC, 0x7E,
  0x0F, 0xC6, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07,
  0x80, 0xF0, 0x78, 0x00, 0x07, 0x07, 0x83, 0x87, 0x01, 0xE7, 0x80, 0x73,
  0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x77, 0x80, 0x79, 0xC0,
  0x38, 0xE0, 0x38, 0x70, 0x3C, 0x38, 0x3C, 0x1E, 0x00, 0xF0, 0x77, 0x0E,
  0x71, 0xE7, 0x1C, 0x73, 0xC7, 0x38, 0x77, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x00,
  0x07, 0xE0, 0xF8, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF8, 0x3F, 0x00, 0xE7, 0x39, 0xCE, 0x31,
  0x8E, 0x73, 0x9C, 0xE7, 0x18, 0xC7, 0x39, 0xCE, 0x07, 0xE0, 0xF8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC1, 0xF8, 0x3F, 0x00, 0x01, 0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0E, 0xC0,
  0xCE, 0x1C, 0xE3, 0x86, 0x38, 0x67, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xC0,
  0xE7, 0x9C, 0x63, 0x80, 0x0E, 0x71, 0xF7, 0x3F, 0xF7, 0x8E, 0x70, 0xE7,
  0x0E, 0xF0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xF7, 0xCF,
  0xD8, 0x79, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x70, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0x79, 0xCF, 0xFC, 0xEF, 0x80, 0x07,
  0x87, 0xF3, 0xF9, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xF3, 0x1F, 0xC7, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x39, 0xC3, 0xEE, 0x3F, 0xF3, 0xC7, 0x1C, 0x38,
  0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x1E, 0x3D,
  0xF1, 0xFB, 0x07, 0x98, 0x00, 0x07, 0x83, 0xF8, 0xF7, 0x3C, 0x77, 0x0C,
  0xE3, 0xBB, 0xF7, 0xF8, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x10, 0xFE,
  0x0F, 0xC0, 0x00, 0x38, 0x03, 0xF0, 0x0F, 0x80, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x07, 0xB8, 0x7D, 0xC7, 0xFE, 0x78, 0xE3, 0x87, 0x1C, 0x39,
  0xE1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xBE, 0x3F,
  0xE0, 0xF7, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x21, 0xE1, 0xFE, 0x0F, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0xE1,
  0xFF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xEE, 0x1C, 0xE1, 0xC0, 0x0E, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70,
  0xE3, 0x87, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0xF8, 0x3C, 0x00,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xE3,
  0x8E, 0x1C, 0xE0, 0xEF, 0x0E, 0x70, 0x77, 0x03, 0xF0, 0x1F, 0x81, 0xFE,
  0x0F, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0x00, 0x0F,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x1D, 0xE3, 0x83, 0x7E,
  0xF8, 0x7F, 0xFF, 0x8E, 0x3C, 0xF3, 0xC7, 0x0E, 0x70, 0xE3, 0x8E, 0x1C,
  0x71, 0xC7, 0x0E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x8E, 0x38, 0x71,
  0xC7, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x71, 0xC0, 0x1C, 0xE1, 0xBF, 0x1F,
  0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x78, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xEE, 0x1C, 0xE1, 0xC0, 0x07, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xEF,
  0x78, 0xFE, 0x0F, 0x80, 0x0E, 0x70, 0x6F, 0xC3, 0x7E, 0x1C, 0x71, 0xE3,
  0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x71, 0xE3,
  0xDE, 0x3B, 0xF1, 0xDF, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x0F, 0x31, 0xFF, 0x3F, 0xF3, 0x8E, 0x70, 0xE7, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xF7, 0xCF, 0xF8,
  0x7B, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1D,
  0xC7, 0xF1, 0xBC, 0x78, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0xFC, 0xE1, 0x38,
  0x0E, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0xCF, 0x3F, 0xCF,
  0xE0, 0x0C, 0x1C, 0x1C, 0x3F, 0x7F, 0xFF, 0x38, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE4, 0xFC, 0x7C, 0x38, 0x73, 0x87, 0x38, 0x77,
  0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x3C, 0xF7, 0x8F, 0xD8, 0x7B, 0x80, 0xC1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE,
  0x39, 0xCE, 0x39, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x00, 0xE3, 0xC3, 0xF1, 0xE3, 0xB8, 0xF1, 0xDC, 0xF9, 0xCC,
  0x7C, 0xE6, 0x7E, 0x63, 0x37, 0x71, 0x9B, 0xB8, 0xDD, 0xF8, 0x6C, 0xFC,
  0x3E, 0x6C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x80, 0x1C,
  0x3C, 0x71, 0xE0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x0E,
  0x1E, 0x00, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x81, 0xF0, 0x30, 0x0F, 0x80, 0x70, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7C,
  0x07, 0x0F, 0x83, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78,
  0x3C, 0x0E, 0x00, 0x30, 0x17, 0xE3, 0xFF, 0xF8, 0x7E, 0x80, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 11, 3, -19 },
  { 28, 14, 19, 14, 0, -19 },
  { 62, 13, 23, 12, 0, -21 },
  { 100, 18, 20, 19, 1, -20 },
  { 145, 14, 20, 15, 0, -20 },
  { 180, 4, 7, 6, 3, -19 },
  { 184, 9, 23, 8, 1, -19 },
  { 210, 9, 24, 8, -2, -20 },
  { 237, 11, 11, 12, 2, -21 },
  { 253, 12, 13, 13, 1, -16 },
  { 273, 5, 7, 6, -1, -3 },
  { 278, 7, 3, 8, 0, -9 },
  { 281, 4, 4, 6, 0, -4 },
  { 283, 13, 19, 10, -1, -19 },
  { 314, 11, 20, 12, 1, -20 },
  { 342, 8, 19, 12, 3, -19 },
  { 361, 13, 20, 12, -1, -20 },
  { 394, 12, 20, 12, 0, -20 },
  { 424, 12, 19, 12, 0, -19 },
  { 453, 13, 19, 12, 0, -19 },
  { 484, 12, 20, 12, 1, -20 },
  { 514, 13, 19, 12, 1, -19 },
  { 545, 13, 20, 12, 0, -20 },
  { 578, 12, 20, 12, 0, -20 },
  { 608, 6, 15, 7, 0, -15 },
  { 620, 7, 19, 7, -1, -15 },
  { 637, 12, 13, 13, 1, -16 },
  { 657, 12, 7, 13, 1, -13 },
  { 668, 12, 13, 13, 1, -16 },
  { 688, 10, 20, 10, 1, -20 },
  { 713, 17, 21, 19, 1, -19 },
  { 758, 14, 19, 13, -2, -19 },
  { 792, 14, 19, 14, 0, -19 },
  { 826, 13, 20, 13, 1, -20 },
  { 859, 14, 19, 15, 0, -19 },
  { 893, 13, 19, 12, 0, -19 },
  { 924, 13, 19, 11, 0, -19 },
  { 955, 15, 20, 15, 1, -20 },
  { 993, 16, 19, 15, 0, -19 },
  { 1031, 11, 19, 9, -1, -19 },
  { 1058, 12, 25, 7, -4, -19 },
  { 1096, 16, 19, 13, 0, -19 },
  { 1134, 9, 19, 11, 0, -19 },
  { 1156, 20, 19, 20, 0, -19 },
  { 1204, 17, 19, 16, 0, -19 },
  { 1245, 14, 20, 16, 1, -20 },
  { 1280, 14, 19, 13, 0, -19 },
  { 1314, 14, 25, 16, 1, -20 },
  { 1358, 13, 19, 13, 0, -19 },
  { 1389, 13, 20, 12, 0, -20 },
  { 1422, 11, 19, 11, 2, -19 },
  { 1449, 15, 19, 15, 1, -19 },
  { 1485, 13, 19, 13, 2, -19 },
  { 1516, 20, 19, 20, 2, -19 },
  { 1564, 17, 19, 12, -2, -19 },
  { 1605, 12, 19, 12, 2, -19 },
  { 1634, 14, 19, 11, -1, -19 },
  { 1668, 11, 23, 8, -1, -19 },
  { 1700, 5, 19, 10, 3, -19 },
  { 1712, 11, 23, 8, -2, -19 },
  { 1744, 12, 11, 12, 0, -19 },
  { 1761, 9, 2, 9, -2, 2 },
  { 1764, 5, 5, 8, 4, -21 },
  { 1768, 12, 15, 13, 1, -15 },
  { 1791, 12, 21, 13, 0, -21 },
  { 1823, 10, 15, 10, 1, -15 },
  { 1842, 13, 21, 13, 1, -21 },
  { 1877, 11, 15, 12, 1, -15 },
  { 1898, 14, 27, 8, -3, -21 },
  { 1946, 13, 21, 13, 0, -15 },
  { 1981, 12, 21, 13, 0, -21 },
  { 2013, 7, 20, 6, 0, -20 },
  { 2031, 10, 26, 6, -3, -20 },
  { 2064, 13, 21, 12, 0, -21 },
  { 2099, 8, 21, 6, 0, -21 },
  { 2120, 19, 15, 20, 0, -15 },
  { 2156, 12, 15, 13, 0, -15 },
  { 2179, 11, 15, 13, 1, -15 },
  { 2200, 13, 21, 13, -1, -15 },
  { 2235, 12, 21, 13, 1, -15 },
  { 2267, 10, 15, 9, 0, -15 },
  { 2286, 10, 15, 10, 0, -15 },
  { 2305, 8, 18, 8, 1, -18 },
  { 2323, 12, 15, 13, 1, -15 },
  { 2346, 11, 15, 11, 2, -15 },
  { 2367, 17, 15, 17, 2, -15 },
  { 2399, 14, 15, 11, -1, -15 },
  { 2426, 15, 21, 11, -2, -15 },
  { 2466, 11, 15, 10, -1, -15 },
  { 2487, 11, 23, 9, 0, -19 },
  { 2519, 3, 27, 11, 4, -21 },
  { 2530, 10, 23, 9, -1, -19 },
  { 2559, 12, 5, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC27PT7B_H_
