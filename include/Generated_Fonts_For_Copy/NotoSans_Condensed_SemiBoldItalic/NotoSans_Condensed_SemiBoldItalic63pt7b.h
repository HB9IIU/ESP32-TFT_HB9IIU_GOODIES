#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC3, 0xF9,
  0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xEE, 0xFC, 0x03, 0xF8, 0xE1,
  0xC0, 0x7F, 0x1E, 0x04, 0x07, 0xF1, 0xC0, 0x00, 0x7F, 0x1C, 0x00, 0x07,
  0xF1, 0xC0, 0x00, 0x7F, 0x1C, 0x00, 0x07, 0xF3, 0x80, 0x00, 0x7F, 0xB8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0E, 0xFF, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x0C, 0x7F, 0x80, 0x01,
  0xC7, 0xF8, 0x00, 0x1C, 0x7F, 0x00, 0x01, 0xC7, 0xF0, 0xC0, 0x1C, 0x7F,
  0x0F, 0x03, 0x8F, 0xF0, 0xFC, 0x39, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x1F, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC3, 0xF0,
  0x00, 0x7C, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x00, 0x7C,
  0x1F, 0x8F, 0xC0, 0xE0, 0xFC, 0x1F, 0x8F, 0x87, 0xF8, 0xFC, 0x1F, 0x1F,
  0x8F, 0xFE, 0x7C, 0x3F, 0x1F, 0x1F, 0xFE, 0x7C, 0x3E, 0x3F, 0x3F, 0xFF,
  0x7E, 0xFE, 0x7E, 0x3F, 0xFF, 0x7F, 0xFC, 0x7C, 0x7E, 0x3F, 0x7F, 0xF8,
  0xFC, 0x7C, 0x1F, 0x3F, 0xF0, 0xF8, 0xFC, 0x1F, 0x1F, 0xE1, 0xF8, 0xF8,
  0x1F, 0x03, 0x83, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x3E,
  0x00, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF,
  0xFC, 0x0F, 0xE0, 0xFF, 0x7F, 0x83, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0x7F, 0x3F, 0x83, 0xF8, 0x1F, 0xEF, 0xE1,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x3F, 0xFE,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xC3, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x60,
  0x3F, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0x3E, 0x02, 0xFF,
  0xFC, 0x7E, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xCF, 0x80, 0x7F, 0x8F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1E, 0x07, 0xF0, 0x04, 0x07, 0xC0, 0x04, 0x07, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x06, 0x1F, 0xDF, 0xEF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x07,
  0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xDF, 0xC7, 0xF9, 0xFC, 0x3F, 0x1F,
  0xC3, 0xC3, 0xF8, 0x18, 0x3F, 0x81, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3C, 0x03, 0xFE, 0x00, 0x70, 0x03, 0xFC,
  0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x01,
  0xFF, 0x00, 0x60, 0x07, 0xF8, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x82, 0x00, 0x07, 0xFC, 0x1E, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0xE0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xE3, 0xF8, 0x00,
  0x1F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x70, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x08, 0x00,
  0x0F, 0xF0, 0x60, 0x01, 0xFF, 0x03, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0xCF, 0xF8, 0x03, 0xF9, 0xFF, 0xC0, 0x3F, 0xBF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x03, 0xFE, 0x3F,
  0x80, 0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xC0, 0x3F,
  0xE3, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x04,
  0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x80, 0xFF, 0x04, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0x80, 0xF8, 0x3E, 0x01, 0xFF, 0xF0,
  0x7C, 0x3F, 0x01, 0xFF, 0xF8, 0x3E, 0x1F, 0x01, 0xFF, 0xFC, 0x1F, 0x1F,
  0x81, 0xFC, 0x7E, 0x0F, 0x8F, 0x81, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0x1F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF9, 0xF0, 0x7C, 0x07, 0xC0, 0xFD, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0xF8,
  0x3F, 0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0x3E, 0x0F, 0x80,
  0xF8, 0x0F, 0xBF, 0x07, 0xC0, 0x7C, 0x0F, 0x9F, 0x07, 0xE0, 0x7E, 0x07,
  0xCF, 0x83, 0xF0, 0x3F, 0x03, 0xE7, 0xC1, 0xF8, 0x1F, 0x03, 0xE3, 0xE0,
  0xFC, 0x1F, 0x81, 0xF1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x0F,
  0xE1, 0xF8, 0x7C, 0x0F, 0xDF, 0xFB, 0xF8, 0x3E, 0x07, 0xFF, 0x7F, 0xF8,
  0x1F, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xE0,
  0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x01, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x01, 0xFF, 0x00, 0x30,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x3F, 0xF0, 0x1E, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC,
  0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x80, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xF1, 0xFC, 0x01, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF,
  0xFC, 0x7F, 0x80, 0x7F, 0xFE, 0x3F, 0xC0, 0x3F, 0xFE, 0x1F, 0xE0, 0x1F,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xE7, 0xE0,
  0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0x80,
  0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x7E, 0x07,
  0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF0, 0x7E, 0x3F, 0x80, 0x1F, 0x87, 0xE1, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x8F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x7E, 0x7F, 0x0F,
  0xE0, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF7, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xEF, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x7E, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xBF,
  0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0xFE, 0x03, 0xF8,
  0x01, 0xF9, 0xFC, 0x07, 0xF0, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x0F, 0xE3,
  0xF0, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x83, 0xF8, 0x03, 0xF8,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0xFC, 0x00, 0xFE,
  0x03, 0xF9, 0xF8, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x03, 0xF0, 0x0F, 0xEF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F,
  0x80, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0x0F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xFC,
  0x07, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x80, 0x7F,
  0x81, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xFC, 0x07,
  0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x08, 0x00, 0x1F, 0xE0,
  0x1C, 0x00, 0x7F, 0xC0, 0x3F, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x1F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0xE0, 0x0F,
  0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xFE, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x00,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x9F, 0x81, 0xFC, 0x03,
  0xF0, 0x3F, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF8, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x00, 0xFC,
  0x7E, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x1F, 0x9F, 0xC0, 0x07, 0xF3,
  0xF8, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x00, 0x1F, 0xCF,
  0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7E,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xDF, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xBF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFE, 0x1F, 0xC0, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF,
  0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0xF0, 0x0F,
  0xFF, 0xDF, 0x80, 0x3F, 0xFC, 0xFC, 0x01, 0xFF, 0xC7, 0xE0, 0x07, 0xF8,
  0x3E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x07, 0xF1, 0xFF,
  0x00, 0x3F, 0x9F, 0xFC, 0x01, 0xFD, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x1F, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xEF, 0xFF,
  0xC0, 0x3F, 0x7F, 0xFC, 0x03, 0xF1, 0xFF, 0xC0, 0x1F, 0x87, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFE,
  0x7C, 0x0F, 0xF8, 0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x40, 0xFF, 0x80, 0xC0, 0x7F, 0xEF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x7F, 0x00, 0x1F,
  0xF1, 0xFC, 0x00, 0x7F, 0xF3, 0xF8, 0x01, 0xFF, 0xF7, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xC0, 0x07, 0xFF,
  0x9F, 0x80, 0x0F, 0xFE, 0x3F, 0x00, 0x07, 0xF8, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF9, 0xFC, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0x03, 0xFC, 0x07, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x82, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x7F, 0x00, 0x1F, 0xFE, 0x7E, 0x00, 0x3F, 0xFE, 0x7E, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0x80, 0x07, 0xFF, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x03, 0xFC, 0x00, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x07, 0xF1, 0xFF, 0x00, 0x3F, 0x9F,
  0xFC, 0x01, 0xFD, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xBF, 0xE0, 0x3F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x01, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3F, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xE7, 0xFF, 0x87,
  0xFF, 0x00, 0xFD, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xE7, 0xF8, 0x1F,
  0xF0, 0x7F, 0xF0, 0x7F, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC3,
  0xFE, 0x00, 0x7E, 0x3F, 0xF8, 0x03, 0xF3, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF,
  0x01, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF3, 0xFC, 0x01,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x3F, 0x1F, 0xFC, 0x00, 0x3F,
  0x3F, 0xFC, 0x00, 0x3F, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xF1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0x00, 0x0F, 0xE7,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x0F, 0xC0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xCF, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x06, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x7F, 0x01, 0xF8, 0xFF, 0x01, 0xF9, 0xFE, 0x01, 0xFB, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF0, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x80, 0x0F, 0xF0, 0xC0, 0x1F, 0xF0, 0xFE, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF9, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0xFC,
  0x07, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x03,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07,
  0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F,
  0xE0, 0x1F, 0x9F, 0xC0, 0xFF, 0xC0, 0x7F, 0x3F, 0x81, 0xFF, 0x80, 0xFE,
  0x7F, 0x03, 0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xFE, 0x07, 0xF1, 0xF8, 0x1F,
  0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0xF8, 0x3F, 0x87, 0xE0, 0xFD, 0xF0, 0x7F,
  0x0F, 0xC1, 0xF3, 0xE1, 0xFC, 0x1F, 0x87, 0xE7, 0xC3, 0xF8, 0x3F, 0x0F,
  0x8F, 0x87, 0xE0, 0x7E, 0x3F, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x7E, 0x3F,
  0x01, 0xF8, 0xF8, 0xFC, 0xFE, 0x03, 0xF3, 0xF1, 0xF9, 0xFC, 0x07, 0xE7,
  0xC3, 0xF3, 0xF0, 0x0F, 0xDF, 0x87, 0xEF, 0xE0, 0x1F, 0xBF, 0x0F, 0xDF,
  0x80, 0x3F, 0x7C, 0x1F, 0xBF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF9, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x80, 0x03, 0xFF, 0x20, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 46, 16, 0, -45 },
  { 105, 21, 16, 25, 6, -45 },
  { 147, 34, 45, 32, 0, -45 },
  { 339, 28, 52, 29, 1, -48 },
  { 521, 40, 47, 45, 3, -46 },
  { 756, 34, 47, 34, 0, -46 },
  { 956, 10, 16, 14, 6, -45 },
  { 976, 21, 55, 18, 1, -45 },
  { 1121, 21, 56, 18, -5, -46 },
  { 1268, 24, 26, 28, 6, -48 },
  { 1346, 26, 30, 31, 3, -37 },
  { 1444, 13, 16, 15, -3, -8 },
  { 1470, 16, 6, 18, 1, -20 },
  { 1482, 9, 10, 15, 0, -9 },
  { 1494, 31, 45, 23, -3, -45 },
  { 1669, 27, 47, 29, 2, -46 },
  { 1828, 20, 45, 29, 6, -45 },
  { 1941, 31, 46, 29, -2, -46 },
  { 2120, 29, 47, 29, 0, -46 },
  { 2291, 30, 45, 29, -1, -45 },
  { 2460, 29, 46, 29, 0, -45 },
  { 2627, 28, 47, 29, 2, -46 },
  { 2792, 30, 45, 29, 2, -45 },
  { 2961, 29, 47, 29, 0, -46 },
  { 3132, 27, 47, 29, 1, -46 },
  { 3291, 15, 36, 15, 0, -35 },
  { 3359, 18, 43, 15, -3, -35 },
  { 3456, 26, 31, 31, 3, -38 },
  { 3557, 26, 18, 31, 3, -31 },
  { 3616, 26, 31, 31, 3, -38 },
  { 3717, 23, 47, 22, 2, -46 },
  { 3853, 41, 50, 44, 2, -45 },
  { 4110, 31, 45, 31, -4, -45 },
  { 4285, 32, 45, 32, 0, -45 },
  { 4465, 31, 47, 30, 3, -46 },
  { 4648, 34, 45, 35, 0, -45 },
  { 4840, 30, 45, 27, 0, -45 },
  { 5009, 30, 45, 26, 0, -45 },
  { 5178, 33, 47, 36, 3, -46 },
  { 5372, 37, 45, 36, 0, -45 },
  { 5581, 27, 45, 20, -3, -45 },
  { 5733, 28, 58, 16, -10, -45 },
  { 5936, 35, 45, 31, 1, -45 },
  { 6133, 22, 45, 26, 0, -45 },
  { 6257, 47, 45, 46, 1, -45 },
  { 6522, 39, 45, 38, 0, -45 },
  { 6742, 33, 47, 37, 3, -46 },
  { 6936, 32, 45, 31, 0, -45 },
  { 7116, 33, 57, 37, 3, -46 },
  { 7352, 30, 45, 31, 1, -45 },
  { 7521, 31, 47, 27, -1, -46 },
  { 7704, 26, 45, 26, 5, -45 },
  { 7851, 34, 46, 35, 3, -45 },
  { 8047, 30, 45, 30, 6, -45 },
  { 8216, 47, 45, 47, 5, -45 },
  { 8481, 38, 45, 29, -4, -45 },
  { 8695, 28, 45, 28, 6, -45 },
  { 8853, 32, 45, 26, -2, -45 },
  { 9033, 25, 55, 18, -2, -45 },
  { 9205, 13, 45, 24, 6, -45 },
  { 9279, 24, 55, 18, -4, -45 },
  { 9444, 29, 27, 29, 0, -45 },
  { 9542, 23, 5, 21, -6, 5 },
  { 9557, 11, 10, 18, 9, -48 },
  { 9571, 29, 36, 31, 2, -35 },
  { 9702, 29, 49, 31, 0, -48 },
  { 9880, 24, 36, 24, 2, -35 },
  { 9988, 31, 49, 31, 2, -48 },
  { 10178, 25, 36, 28, 2, -35 },
  { 10291, 32, 63, 18, -7, -48 },
  { 10543, 32, 50, 31, -1, -35 },
  { 10743, 29, 48, 31, 0, -48 },
  { 10917, 17, 47, 15, 0, -47 },
  { 11017, 25, 62, 15, -8, -47 },
  { 11211, 31, 48, 28, 0, -48 },
  { 11397, 18, 48, 15, 0, -48 },
  { 11505, 43, 35, 45, 0, -35 },
  { 11694, 29, 35, 31, 0, -35 },
  { 11821, 26, 36, 30, 2, -35 },
  { 11938, 32, 50, 31, -3, -35 },
  { 12138, 29, 50, 31, 2, -35 },
  { 12320, 24, 35, 21, 0, -35 },
  { 12425, 24, 36, 24, 0, -35 },
  { 12533, 19, 43, 19, 2, -42 },
  { 12636, 28, 35, 30, 2, -34 },
  { 12759, 25, 34, 26, 4, -34 },
  { 12866, 39, 34, 40, 4, -34 },
  { 13032, 32, 34, 27, -3, -34 },
  { 13168, 34, 49, 26, -5, -34 },
  { 13377, 26, 34, 23, -2, -34 },
  { 13488, 25, 55, 21, 1, -45 },
  { 13660, 6, 63, 27, 10, -48 },
  { 13708, 24, 55, 21, -3, -45 },
  { 13873, 26, 10, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC63PT7B_H_
