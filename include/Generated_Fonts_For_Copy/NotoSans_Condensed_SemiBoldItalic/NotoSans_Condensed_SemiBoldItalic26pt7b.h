#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3,
  0x00, 0x00, 0x10, 0x71, 0xE3, 0x80, 0x77, 0xE7, 0xE7, 0xE6, 0xCE, 0xCE,
  0xCC, 0x03, 0x98, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x06, 0x30, 0x19, 0xC3,
  0xFF, 0xCF, 0xFF, 0x0C, 0x60, 0x33, 0x01, 0xCC, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC3, 0x18, 0x0C, 0xE0, 0x33, 0x01, 0x8C, 0x06, 0x70, 0x00, 0x00,
  0x80, 0x08, 0x03, 0xC0, 0xFF, 0x1F, 0xF1, 0xD2, 0x39, 0x03, 0xB0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x4E, 0x04, 0xC4, 0x5C, 0xFF,
  0xCF, 0xF8, 0x3E, 0x00, 0x80, 0x08, 0x01, 0x80, 0x0E, 0x06, 0x0F, 0x87,
  0x0F, 0xC3, 0x0E, 0x63, 0x06, 0x31, 0x83, 0x39, 0x81, 0x9D, 0xC1, 0xCC,
  0xC0, 0xE6, 0xCF, 0x36, 0x6F, 0xDF, 0x6E, 0x66, 0x76, 0x30, 0x33, 0x38,
  0x39, 0x9C, 0x19, 0xCC, 0x18, 0xE6, 0x1C, 0x77, 0x0C, 0x1F, 0x0E, 0x0F,
  0x00, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0x9C, 0x0C, 0x70, 0x33, 0x80,
  0xCE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF1, 0xDE, 0xEE, 0x73, 0xBB,
  0x87, 0xCE, 0x1F, 0x38, 0x78, 0xF3, 0xE1, 0xFF, 0xC3, 0xE7, 0x80, 0x7E,
  0xEE, 0xEC, 0xC0, 0x03, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x07,
  0x03, 0x83, 0x83, 0x80, 0x06, 0x01, 0x84, 0x61, 0xD8, 0xFF, 0xC7, 0xF1,
  0xE0, 0xF8, 0x77, 0x08, 0xE0, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x39,
  0xDC, 0xEE, 0x70, 0x7F, 0xFC, 0x27, 0xFE, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x1C, 0x73, 0x8E, 0xE1, 0xDC, 0x3B,
  0x87, 0xE0, 0xFC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC7, 0x38, 0xE7, 0x3C,
  0xEF, 0x1F, 0xC1, 0xF0, 0x00, 0x07, 0x0F, 0x1E, 0x7E, 0xFE, 0xEE, 0x4E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x18, 0xF0, 0x83, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7F, 0xE3, 0xFE, 0x3F, 0xF0, 0x03, 0x81, 0xFE, 0x1F, 0xF0,
  0x87, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xF0, 0x1F, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xC7, 0x8F, 0xF8, 0xFE, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7E, 0x06, 0xE0, 0xCC,
  0x1D, 0xC3, 0x9C, 0x31, 0xC6, 0x1C, 0xE3, 0x8F, 0xFE, 0xFF, 0xE0, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0xB0, 0x3F, 0x83, 0xFC, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC8, 0x3C, 0xEF, 0x8F, 0xF0, 0xFE, 0x00, 0x01, 0xE0,
  0xFC, 0x3F, 0x8E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xB8, 0x7F, 0x9F, 0xFB,
  0xC7, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C, 0xF7, 0x8F, 0xE1, 0xF8,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF4, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xDE, 0x0F, 0xC0, 0xF0, 0x3F, 0x87, 0x9C,
  0x71, 0xCE, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x03,
  0x80, 0xFE, 0x1F, 0xE1, 0xCF, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x38,
  0xE3, 0x9E, 0x3F, 0xE1, 0xEE, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x8F,
  0x0F, 0xE0, 0xFC, 0x00, 0x1C, 0xF3, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x3C, 0xF3, 0x80, 0x0E, 0x3C, 0x78, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0x8E, 0x1C, 0x70, 0xE0, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xE1,
  0xF0, 0xF8, 0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x70, 0x02,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x18, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x70, 0x08, 0x00, 0x0E, 0x3F, 0xDF, 0xE4, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x00, 0x00, 0x00, 0x40, 0xF0,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x01, 0xC3, 0x81, 0x80, 0x61,
  0x80, 0x31, 0x87, 0x8C, 0xC7, 0xE6, 0xC6, 0x63, 0x66, 0x31, 0xF3, 0x19,
  0xF3, 0x9C, 0xD9, 0x8C, 0x6C, 0xC6, 0x36, 0x67, 0x33, 0x3F, 0xF1, 0x8E,
  0x70, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x08, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xDC, 0x0E, 0xE0,
  0x67, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0xF0,
  0xE7, 0x07, 0x38, 0x3B, 0x81, 0xFC, 0x0E, 0x0F, 0x80, 0x7F, 0x83, 0xFE,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF8, 0x71, 0xE3, 0x87, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x7F, 0xE3, 0xFE,
  0x3F, 0xC0, 0x01, 0xE0, 0x3F, 0xC3, 0xFC, 0x3C, 0x23, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x3F,
  0xC0, 0xFF, 0x87, 0x9E, 0x1C, 0x3C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x3C,
  0x3C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x79, 0xC1, 0xC7, 0x0F, 0x1C,
  0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x87, 0xF8, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0x82,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC7, 0xEF, 0x1F,
  0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCF, 0x07, 0x3C, 0x38, 0x7D, 0xE1, 0xFF,
  0x81, 0xFC, 0x00, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0x71, 0xC1,
  0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1,
  0xC1, 0xC3, 0x83, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0xE3, 0x83, 0x80, 0x0F, 0xE1, 0xFC, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE1, 0x7C,
  0x3F, 0x07, 0xC0, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE3, 0xC1, 0xC7,
  0x03, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xDC, 0x03, 0xB8, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xE0, 0xE1,
  0xC3, 0x83, 0x80, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x7F, 0xBF, 0xFF,
  0xE0, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x07, 0xE1, 0xF0, 0x7E, 0x1F, 0x06, 0xC1, 0xB0, 0xFC, 0x3B, 0x8D, 0xC3,
  0xB9, 0xDC, 0x3B, 0x99, 0xC3, 0xBB, 0xB8, 0x33, 0xB3, 0x87, 0x3F, 0x38,
  0x73, 0xE3, 0x87, 0x3E, 0x30, 0x73, 0xC7, 0x06, 0x3C, 0x70, 0xE1, 0x87,
  0x00, 0x0F, 0x07, 0x0F, 0x07, 0x0F, 0x07, 0x1F, 0x07, 0x1F, 0x06, 0x1F,
  0x8E, 0x1F, 0x8E, 0x1B, 0x8E, 0x39, 0x8E, 0x39, 0xDC, 0x39, 0xDC, 0x39,
  0xDC, 0x31, 0xDC, 0x70, 0xD8, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0x60,
  0x78, 0xE0, 0x70, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0x8E, 0x3C, 0x3C,
  0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x3C, 0x38, 0x7B, 0xE1, 0xFF, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x87, 0x38, 0x71, 0xCF, 0x8F, 0xF8, 0x7F, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x1F, 0xC0,
  0xFF, 0x87, 0x8E, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x3F,
  0xC0, 0xFF, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x3C, 0x38,
  0x7B, 0xE1, 0xFF, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFC, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x8E, 0x38, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xB8, 0x38, 0xE1,
  0xC7, 0x0E, 0x38, 0x71, 0xC3, 0x87, 0x38, 0x38, 0x03, 0xC0, 0xFF, 0x1F,
  0xF1, 0xC2, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC8, 0x3C, 0xFF, 0x8F, 0xF0, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xFF, 0xC1, 0xFE, 0x03,
  0xF0, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0xE1,
  0x87, 0x0C, 0x38, 0x63, 0x83, 0x1C, 0x19, 0xC0, 0xCE, 0x06, 0xE0, 0x37,
  0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x60, 0xFE,
  0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x1E, 0x1C, 0xE1, 0xE1, 0xCE, 0x1E, 0x38,
  0xE3, 0xE3, 0x8E, 0x36, 0x38, 0xE7, 0x67, 0x0E, 0x66, 0x70, 0xEE, 0x66,
  0x0E, 0xE6, 0xE0, 0xEC, 0x6E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x00, 0x0E, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0x71, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8, 0x0F,
  0x70, 0x1C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x80, 0xE0, 0x7E, 0x0E,
  0x71, 0xE7, 0x1C, 0x73, 0x87, 0x38, 0x77, 0x07, 0x70, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x7F, 0xC7, 0xFE, 0x3F, 0xF0, 0x07, 0xC1, 0xF0,
  0x7C, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x1F,
  0x0F, 0xC0, 0xC6, 0x39, 0xCE, 0x73, 0x8C, 0x63, 0x9C, 0xE7, 0x38, 0xC6,
  0x31, 0xCE, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x1F, 0x0F, 0xC0, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x0F, 0xC0, 0xCC, 0x1C, 0xC1, 0x8E, 0x38, 0xE7, 0x06, 0xE0, 0x70,
  0xFF, 0xFF, 0xC0, 0xEE, 0x73, 0x1F, 0x73, 0xF6, 0x3D, 0xE7, 0x0E, 0x70,
  0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x78, 0xFF,
  0x87, 0xB8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1D,
  0xE1, 0xFF, 0x1E, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x30, 0x77, 0x0F, 0x70,
  0xE7, 0x0E, 0x71, 0xE7, 0xBC, 0xFF, 0x8E, 0xF0, 0x0F, 0xCF, 0xE3, 0x89,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC8, 0xFE,
  0x1F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x7D, 0x87, 0xFC, 0x39, 0xE3, 0x87, 0x1C, 0x39, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x3C, 0x3F, 0xE0, 0xF7, 0x00, 0x0F,
  0x8F, 0xF3, 0x9D, 0xC7, 0x71, 0xF8, 0xEF, 0xF3, 0xF0, 0xE0, 0x38, 0x0E,
  0x03, 0x84, 0xFF, 0x1F, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x17, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x0F, 0xB8, 0xFD, 0x87, 0x3C, 0x70, 0xE3, 0x87, 0x38, 0x71, 0xC3, 0x8E,
  0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xE7, 0x87, 0xFC, 0x1E, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x86, 0x3C, 0x3F, 0xC1, 0xFC, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1D, 0xE1, 0xFF, 0x1E, 0xF3, 0xC7,
  0x38, 0x73, 0x86, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0x1C,
  0xE1, 0xCE, 0x1C, 0x04, 0x1C, 0x38, 0x60, 0x00, 0x07, 0x0E, 0x18, 0x70,
  0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x00, 0x00, 0x80, 0x70,
  0x1C, 0x06, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0x82, 0xE0, 0xF8, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x71, 0xE3, 0x9C, 0x19, 0xE1, 0xCE, 0x0E, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0x1C, 0x38,
  0x71, 0xC3, 0x80, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70,
  0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x00, 0x1B, 0xE7, 0x86,
  0xFB, 0xF1, 0xEF, 0x9C, 0xF1, 0xC7, 0x38, 0xF1, 0xCE, 0x38, 0x73, 0x8E,
  0x39, 0xC3, 0x8E, 0x70, 0xE3, 0x9C, 0x70, 0xE7, 0x1C, 0x39, 0xC7, 0x1C,
  0xE1, 0xC7, 0x38, 0x71, 0xC0, 0x19, 0xE1, 0xBF, 0x1E, 0xF3, 0xC7, 0x38,
  0x73, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0x1C, 0xE1,
  0xCE, 0x1C, 0x1F, 0x87, 0xF8, 0xE7, 0x38, 0x77, 0x0F, 0xC1, 0xF8, 0x77,
  0x0E, 0xE1, 0xDC, 0x3B, 0x8E, 0x7B, 0xC7, 0xF0, 0x7C, 0x00, 0x0C, 0xF0,
  0x6F, 0xC3, 0xCE, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38,
  0x71, 0xC3, 0x8E, 0x3C, 0x7B, 0xC7, 0xFC, 0x3B, 0xC1, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0x73, 0xF6, 0x39, 0xE7,
  0x0E, 0x70, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E,
  0x78, 0xFF, 0x87, 0xB8, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x1B, 0xC6, 0xE1, 0xF8, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x1F, 0xCF, 0xF3, 0x88, 0xE0,
  0x38, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x01, 0xC0, 0x73, 0x3C, 0xFE, 0x3F,
  0x00, 0x0C, 0x18, 0x18, 0x7F, 0xFE, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70,
  0xE0, 0xE0, 0xE0, 0xE4, 0xF8, 0x78, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0xE3, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x73, 0x8E, 0x73, 0xCF, 0xF8,
  0xF7, 0x00, 0xE0, 0xEC, 0x39, 0x87, 0x31, 0xC6, 0x38, 0xC6, 0x19, 0xC3,
  0x30, 0x7E, 0x0D, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0xC3, 0x87,
  0xC7, 0x8E, 0xC7, 0x8E, 0xC7, 0x8C, 0xCF, 0x9C, 0xCD, 0x9C, 0xDD, 0xB8,
  0xD9, 0xB8, 0xD9, 0xB0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0,
  0xE1, 0xC0, 0x1C, 0x78, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x80, 0xFC, 0x0E, 0xE0, 0xF3, 0x87, 0x1C, 0x70,
  0xE0, 0x0C, 0x1C, 0x30, 0xE0, 0xE3, 0x83, 0x8C, 0x0E, 0x70, 0x39, 0xC0,
  0xEE, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x00,
  0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x20, 0x78, 0x1F,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x81, 0xF0, 0x38,
  0x0F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x08, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0x7C, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x78, 0x3C, 0x0E, 0x00, 0x7C, 0x3F, 0xFF, 0x3F, 0xC0,
  0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 14, 19, 13, 0, -19 },
  { 59, 12, 22, 12, 0, -20 },
  { 92, 17, 19, 19, 1, -19 },
  { 133, 14, 19, 14, 0, -19 },
  { 167, 4, 7, 6, 3, -19 },
  { 171, 8, 23, 7, 1, -19 },
  { 194, 9, 23, 7, -2, -19 },
  { 220, 10, 11, 11, 2, -20 },
  { 234, 11, 12, 13, 1, -15 },
  { 251, 5, 6, 6, -1, -3 },
  { 255, 7, 2, 8, 0, -8 },
  { 257, 4, 4, 6, 0, -4 },
  { 259, 13, 19, 10, -1, -19 },
  { 290, 11, 19, 12, 1, -19 },
  { 317, 8, 19, 12, 3, -19 },
  { 336, 13, 19, 12, -1, -19 },
  { 367, 12, 19, 12, 0, -19 },
  { 396, 12, 19, 12, 0, -19 },
  { 425, 12, 19, 12, 0, -19 },
  { 454, 11, 19, 12, 1, -19 },
  { 481, 12, 19, 12, 1, -19 },
  { 510, 12, 19, 12, 0, -19 },
  { 539, 12, 19, 12, 0, -19 },
  { 568, 6, 14, 6, 0, -14 },
  { 579, 7, 17, 6, -1, -14 },
  { 594, 11, 13, 13, 1, -16 },
  { 612, 11, 8, 13, 1, -13 },
  { 623, 11, 13, 13, 1, -16 },
  { 641, 9, 19, 9, 1, -19 },
  { 663, 17, 21, 18, 1, -19 },
  { 708, 13, 19, 13, -2, -19 },
  { 739, 13, 19, 13, 0, -19 },
  { 770, 13, 19, 12, 1, -19 },
  { 801, 14, 19, 14, 0, -19 },
  { 835, 12, 19, 11, 0, -19 },
  { 864, 12, 19, 11, 0, -19 },
  { 893, 14, 19, 15, 1, -19 },
  { 927, 15, 19, 15, 0, -19 },
  { 963, 11, 19, 8, -1, -19 },
  { 990, 11, 24, 7, -4, -19 },
  { 1023, 15, 19, 13, 0, -19 },
  { 1059, 9, 19, 11, 0, -19 },
  { 1081, 20, 19, 19, 0, -19 },
  { 1129, 16, 19, 16, 0, -19 },
  { 1167, 14, 19, 15, 1, -19 },
  { 1201, 13, 19, 13, 0, -19 },
  { 1232, 14, 23, 15, 1, -19 },
  { 1273, 13, 19, 13, 0, -19 },
  { 1304, 12, 19, 11, 0, -19 },
  { 1333, 11, 19, 11, 2, -19 },
  { 1360, 14, 19, 14, 1, -19 },
  { 1394, 13, 19, 13, 2, -19 },
  { 1425, 20, 19, 19, 2, -19 },
  { 1473, 15, 19, 12, -1, -19 },
  { 1509, 12, 19, 11, 2, -19 },
  { 1538, 13, 19, 11, -1, -19 },
  { 1569, 10, 23, 8, -1, -19 },
  { 1598, 5, 19, 10, 3, -19 },
  { 1610, 10, 23, 8, -2, -19 },
  { 1639, 12, 11, 12, 0, -19 },
  { 1656, 9, 2, 9, -2, 2 },
  { 1659, 4, 4, 7, 4, -20 },
  { 1661, 12, 14, 13, 1, -14 },
  { 1682, 12, 20, 13, 0, -20 },
  { 1712, 10, 14, 10, 1, -14 },
  { 1730, 13, 20, 13, 1, -20 },
  { 1763, 10, 14, 12, 1, -14 },
  { 1781, 13, 26, 7, -3, -20 },
  { 1824, 13, 20, 13, 0, -14 },
  { 1857, 12, 20, 13, 0, -20 },
  { 1887, 7, 20, 6, 0, -20 },
  { 1905, 10, 26, 6, -3, -20 },
  { 1938, 13, 20, 12, 0, -20 },
  { 1971, 7, 20, 6, 0, -20 },
  { 1989, 18, 14, 19, 0, -14 },
  { 2021, 12, 14, 13, 0, -14 },
  { 2042, 11, 14, 12, 1, -14 },
  { 2062, 13, 20, 13, -1, -14 },
  { 2095, 12, 20, 13, 1, -14 },
  { 2125, 10, 14, 9, 0, -14 },
  { 2143, 10, 14, 10, 0, -14 },
  { 2161, 8, 17, 8, 1, -17 },
  { 2178, 11, 14, 13, 1, -14 },
  { 2198, 11, 14, 11, 1, -14 },
  { 2218, 16, 14, 17, 2, -14 },
  { 2246, 13, 14, 11, -1, -14 },
  { 2269, 14, 20, 11, -2, -14 },
  { 2304, 11, 14, 9, -1, -14 },
  { 2324, 11, 23, 9, 0, -19 },
  { 2356, 3, 26, 11, 4, -20 },
  { 2366, 10, 23, 9, -1, -19 },
  { 2395, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC26PT7B_H_
