#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x80,
  0x0C, 0x00, 0x00, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7E,
  0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFD, 0xCF, 0x01, 0xFC, 0xE1, 0x00, 0xFC,
  0x60, 0x00, 0x7E, 0x30, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0x9C, 0x00, 0x0F,
  0xCC, 0x00, 0x07, 0xF6, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0C, 0xFC, 0x00, 0x06, 0x7E,
  0x00, 0x07, 0x1F, 0x00, 0x03, 0x8F, 0x80, 0x01, 0xCF, 0xC1, 0x80, 0xC7,
  0xE0, 0xF0, 0x67, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x3C, 0x03,
  0xFF, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x01,
  0xF0, 0xF0, 0x1F, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0xF8, 0x3C, 0x0F, 0x80,
  0x7C, 0x3E, 0x07, 0x80, 0x3C, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x87, 0xC0,
  0x1F, 0x07, 0xC3, 0xC0, 0x0F, 0x83, 0xE3, 0xE0, 0x07, 0xC1, 0xE1, 0xE0,
  0x03, 0xE1, 0xF1, 0xF0, 0x01, 0xE0, 0xF9, 0xF0, 0xFC, 0xF0, 0x78, 0xF1,
  0xFF, 0x7C, 0x7C, 0xF9, 0xFF, 0xFE, 0x7C, 0x78, 0xFF, 0xFF, 0xFE, 0x7C,
  0xF9, 0xF7, 0xFE, 0x7C, 0xF8, 0x7B, 0xFE, 0x3C, 0x7C, 0x3C, 0xFE, 0x3E,
  0x3C, 0x1E, 0x00, 0x1E, 0x3E, 0x0F, 0x00, 0x1F, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x07, 0xC0, 0x0F, 0x87, 0x83, 0xE0, 0x0F, 0x87, 0xC1, 0xF0, 0x07,
  0x83, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0xF8, 0x07, 0xC0, 0xF8, 0x7C, 0x03,
  0xE0, 0x7C, 0x3C, 0x03, 0xE0, 0x3E, 0x3E, 0x01, 0xE0, 0x1F, 0x1E, 0x01,
  0xF0, 0x0F, 0xFF, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x3F, 0x07, 0xFF, 0x83, 0xF0, 0xFF, 0xF8, 0x3E, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0xEF, 0xC7, 0xE0, 0x7E, 0xFC, 0x7E,
  0x07, 0xFF, 0x87, 0xE0, 0x3F, 0xF0, 0xFE, 0x03, 0xFF, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x07, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0xF0, 0x1F, 0xFE,
  0x3F, 0x80, 0xFF, 0xC1, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87,
  0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x06, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0xEF,
  0x80, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFB, 0xC0, 0x3F, 0x3E, 0x07,
  0xE3, 0xE0, 0x3E, 0x3F, 0x01, 0xC1, 0xF8, 0x08, 0x1E, 0x00, 0x01, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7C, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFE,
  0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x1F, 0x03, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xBE, 0x7F,
  0xBF, 0x1F, 0x9F, 0x87, 0x0F, 0xC1, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x0F, 0xF0, 0x0F, 0x01, 0xFC,
  0x01, 0x80, 0x3F, 0x00, 0x40, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x04,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xE0, 0x7F, 0x01,
  0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x80, 0x07, 0xF0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xDF,
  0x80, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x38, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC1, 0x00, 0x1F, 0xE0, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x1F, 0xBF,
  0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F,
  0x8F, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7F, 0x07,
  0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x03, 0xFF, 0x7E, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x80, 0x7F, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3C, 0x1F, 0xC2,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x07, 0xF0, 0x3C, 0x3C, 0x07, 0xFF, 0x0F, 0x1F, 0x03, 0xFF,
  0xC3, 0xC7, 0x81, 0xFF, 0xF0, 0xF3, 0xE0, 0xF8, 0x78, 0x3C, 0xF0, 0x7C,
  0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x83, 0xDF, 0x0F, 0x83, 0xE0, 0xF7, 0x83,
  0xC0, 0xF0, 0x7D, 0xE1, 0xF0, 0x3C, 0x1F, 0xF8, 0x7C, 0x1F, 0x07, 0xBE,
  0x1E, 0x07, 0xC1, 0xEF, 0x07, 0x81, 0xE0, 0x7B, 0xC3, 0xE0, 0xF8, 0x3C,
  0xF0, 0xF8, 0x3E, 0x0F, 0x3C, 0x3E, 0x0F, 0x87, 0xCF, 0x0F, 0x87, 0xE1,
  0xE3, 0xC3, 0xE3, 0xF8, 0xF0, 0xF0, 0x7F, 0xFF, 0xFC, 0x3C, 0x1F, 0xF7,
  0xFE, 0x0F, 0x03, 0xF8, 0xFF, 0x03, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x01,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0,
  0x3F, 0x07, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xC3, 0xC0, 0x3F, 0xC0, 0x10, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x80, 0x7F, 0xC0, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8,
  0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x01,
  0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xF0, 0x0F, 0xF8,
  0x01, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF0, 0xFC, 0x07, 0xFF,
  0x87, 0xE0, 0x3F, 0xFC, 0x3F, 0x01, 0xFF, 0xC3, 0xF8, 0x0F, 0xFE, 0x1F,
  0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7E,
  0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x07, 0xEF, 0x80, 0x7D, 0xF8,
  0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x07, 0xCF,
  0x81, 0xFB, 0xF0, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0xCF, 0x83, 0xF3,
  0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC7, 0xE3, 0xF0, 0x0F,
  0x87, 0xC7, 0xC7, 0xE0, 0x0F, 0x87, 0xCF, 0xC7, 0xE0, 0x1F, 0x87, 0xCF,
  0x87, 0xE0, 0x1F, 0x87, 0xDF, 0x87, 0xE0, 0x1F, 0x87, 0xDF, 0x07, 0xC0,
  0x1F, 0x07, 0xDF, 0x0F, 0xC0, 0x3F, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0x07,
  0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xFC, 0x0F,
  0x80, 0x3E, 0x07, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xF0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x03, 0xE0,
  0x1F, 0xF0, 0x03, 0xF0, 0x0F, 0xFC, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0xFC,
  0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x7D, 0xF8, 0x0F, 0xC0, 0x3E, 0x7C, 0x07,
  0xC0, 0x1F, 0x3E, 0x07, 0xE0, 0x1F, 0x9F, 0x83, 0xF0, 0x0F, 0xCF, 0xC1,
  0xF8, 0x07, 0xE7, 0xE0, 0xFC, 0x03, 0xE1, 0xF0, 0x7C, 0x01, 0xF0, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x7E, 0x0F,
  0x8F, 0xC0, 0x3E, 0x07, 0xC7, 0xC0, 0x3F, 0x03, 0xF7, 0xE0, 0x1F, 0x81,
  0xFB, 0xF0, 0x0F, 0xC0, 0xFD, 0xF8, 0x07, 0xE0, 0x3E, 0xF8, 0x03, 0xE0,
  0x1F, 0x7C, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xC0, 0x3F,
  0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x07,
  0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x07,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x0F, 0xF0, 0x1F, 0x87, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7E, 0x1F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07,
  0xE0, 0x7F, 0x01, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xF3, 0xF0, 0x1F, 0xE0, 0x18, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x82, 0x00, 0x1F, 0xC1,
  0x80, 0x1F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFE, 0x00,
  0xFC, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x7E,
  0x03, 0xFE, 0x03, 0xF0, 0x7C, 0x03, 0xFE, 0x03, 0xF0, 0x7C, 0x07, 0xFE,
  0x03, 0xF0, 0x7C, 0x07, 0xFE, 0x07, 0xE0, 0x7C, 0x07, 0xFE, 0x07, 0xE0,
  0x7C, 0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x1F,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x3E, 0x1F,
  0x80, 0x7C, 0x3E, 0x3E, 0x3F, 0x00, 0x7C, 0x3E, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x3E,
  0x7E, 0x00, 0x7C, 0xF8, 0x3E, 0xFC, 0x00, 0x7C, 0xF8, 0x3E, 0xFC, 0x00,
  0x7D, 0xF0, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x3D, 0xF8, 0x00, 0x7F, 0xE0, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x7E, 0x01, 0xF1, 0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0x3F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x7F, 0x0F, 0x80, 0x7F,
  0xCF, 0xC0, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x8F, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x1F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFD, 0xF0, 0x0F, 0xFE, 0xF8, 0x07, 0xFE, 0x7C, 0x01, 0xFC,
  0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x83, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7D, 0xFF, 0xC0, 0xF8,
  0xFF, 0x80, 0xF8, 0x7F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x0C, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x02, 0x0F, 0xE0, 0x60, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF9, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xC0, 0x0F, 0xFC, 0xF8, 0x00, 0x7F,
  0x1F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC,
  0x1F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x30, 0xFF, 0x0F, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x11,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xE0, 0x07, 0xFC, 0xFC, 0x01,
  0xFF, 0xDF, 0x00, 0x7F, 0xFB, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFC, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFE, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x60, 0x07, 0xF0, 0x0F, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF1, 0xF8, 0x03, 0xF7, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x00, 0x38, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x0F, 0xC0, 0x1F, 0x3F, 0xE1, 0xFF, 0x00, 0xFB, 0xFF, 0x9F, 0xFC, 0x07,
  0xFF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xE1, 0xF8, 0x03, 0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xDF, 0xFF, 0x07, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7E, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07,
  0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x7F, 0xC0, 0x0F, 0xBF, 0xF8,
  0x03, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xC0,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xF7, 0xFF, 0x80, 0x7C, 0xFF, 0x80, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC1, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0x7F,
  0xCF, 0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0x8F, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x7F,
  0x03, 0xEF, 0xF0, 0x3E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x0C, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x80, 0x3F, 0x8C, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x50, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0E, 0x00, 0x0F,
  0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7E, 0x1F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xEF, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0x3E, 0x03, 0xF8, 0x78, 0x00, 0x80,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC,
  0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x01, 0xFB, 0xF0,
  0x3F, 0xC0, 0xFC, 0xFC, 0x0F, 0xF0, 0x3F, 0x3F, 0x07, 0xFC, 0x0F, 0x8F,
  0xC1, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0xC1, 0xF0, 0xFC, 0x3F, 0xF0, 0xFC,
  0x3F, 0x0F, 0x7C, 0x3F, 0x0F, 0xC7, 0xDF, 0x0F, 0x83, 0xF1, 0xF7, 0xC7,
  0xE0, 0xFC, 0x79, 0xF1, 0xF0, 0x3F, 0x3E, 0x7C, 0xFC, 0x0F, 0xCF, 0x9F,
  0x3F, 0x03, 0xF7, 0xC7, 0xCF, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0x78,
  0x7D, 0xF0, 0x0F, 0xBE, 0x1F, 0xFC, 0x03, 0xEF, 0x87, 0xFE, 0x00, 0xFB,
  0xC1, 0xEF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x0D, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x02, 0x7F,
  0xC0, 0x05, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x40, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 39, 13, 0, -38 },
  { 75, 18, 14, 21, 5, -38 },
  { 107, 28, 38, 27, 0, -38 },
  { 240, 25, 43, 24, 0, -40 },
  { 375, 33, 38, 38, 3, -38 },
  { 532, 28, 39, 29, 0, -38 },
  { 669, 9, 14, 12, 5, -38 },
  { 685, 18, 46, 15, 1, -38 },
  { 789, 18, 46, 15, -4, -38 },
  { 893, 20, 22, 23, 5, -41 },
  { 948, 23, 25, 26, 2, -31 },
  { 1020, 12, 13, 13, -3, -6 },
  { 1040, 13, 6, 15, 1, -17 },
  { 1050, 8, 8, 13, 0, -7 },
  { 1058, 27, 38, 20, -3, -38 },
  { 1187, 23, 39, 24, 1, -38 },
  { 1300, 17, 38, 24, 5, -38 },
  { 1381, 26, 38, 24, -2, -38 },
  { 1505, 24, 39, 24, 0, -38 },
  { 1622, 25, 38, 24, -1, -38 },
  { 1741, 25, 39, 24, 0, -38 },
  { 1863, 23, 39, 24, 2, -38 },
  { 1976, 25, 38, 24, 2, -38 },
  { 2095, 25, 39, 24, 0, -38 },
  { 2217, 23, 39, 24, 1, -38 },
  { 2330, 12, 30, 13, 0, -29 },
  { 2375, 15, 36, 13, -3, -29 },
  { 2443, 23, 26, 26, 2, -32 },
  { 2518, 23, 15, 26, 2, -26 },
  { 2562, 23, 26, 26, 2, -32 },
  { 2637, 19, 39, 19, 2, -38 },
  { 2730, 34, 42, 37, 2, -38 },
  { 2909, 26, 38, 26, -3, -38 },
  { 3033, 27, 38, 27, 0, -38 },
  { 3162, 26, 39, 25, 2, -38 },
  { 3289, 28, 38, 29, 0, -38 },
  { 3422, 25, 38, 23, 0, -38 },
  { 3541, 25, 38, 22, 0, -38 },
  { 3660, 29, 39, 30, 2, -38 },
  { 3802, 31, 38, 30, 0, -38 },
  { 3950, 22, 38, 17, -2, -38 },
  { 4055, 23, 49, 13, -8, -38 },
  { 4196, 30, 38, 26, 0, -38 },
  { 4339, 18, 38, 22, 0, -38 },
  { 4425, 40, 38, 39, 0, -38 },
  { 4615, 33, 38, 32, 0, -38 },
  { 4772, 28, 39, 31, 2, -38 },
  { 4909, 27, 38, 26, 0, -38 },
  { 5038, 28, 47, 31, 2, -38 },
  { 5203, 26, 38, 26, 0, -38 },
  { 5327, 25, 39, 23, 0, -38 },
  { 5449, 22, 38, 22, 4, -38 },
  { 5554, 29, 39, 29, 2, -38 },
  { 5696, 25, 38, 26, 5, -38 },
  { 5815, 40, 38, 39, 4, -38 },
  { 6005, 31, 38, 24, -3, -38 },
  { 6153, 23, 38, 23, 5, -38 },
  { 6263, 27, 38, 22, -2, -38 },
  { 6392, 21, 46, 16, -2, -38 },
  { 6513, 11, 38, 20, 5, -38 },
  { 6566, 21, 46, 16, -4, -38 },
  { 6687, 24, 23, 24, 0, -38 },
  { 6756, 19, 3, 18, -5, 5 },
  { 6764, 9, 9, 15, 8, -41 },
  { 6775, 25, 30, 26, 1, -29 },
  { 6869, 24, 41, 26, 0, -40 },
  { 6992, 20, 30, 20, 2, -29 },
  { 7067, 27, 41, 26, 1, -40 },
  { 7206, 21, 30, 24, 2, -29 },
  { 7285, 27, 54, 15, -6, -41 },
  { 7468, 27, 42, 26, -1, -29 },
  { 7610, 24, 40, 26, 0, -40 },
  { 7730, 14, 40, 12, 0, -40 },
  { 7800, 21, 53, 13, -7, -40 },
  { 7940, 26, 40, 23, 0, -40 },
  { 8070, 15, 40, 12, 0, -40 },
  { 8145, 37, 29, 38, 0, -29 },
  { 8280, 24, 29, 26, 0, -29 },
  { 8367, 22, 30, 25, 2, -29 },
  { 8450, 26, 42, 26, -2, -29 },
  { 8587, 25, 42, 26, 1, -29 },
  { 8719, 20, 29, 18, 0, -29 },
  { 8792, 20, 30, 20, 0, -29 },
  { 8867, 16, 36, 16, 2, -35 },
  { 8939, 23, 30, 26, 2, -29 },
  { 9026, 22, 29, 22, 3, -29 },
  { 9106, 34, 29, 34, 3, -29 },
  { 9230, 27, 29, 22, -2, -29 },
  { 9328, 29, 42, 22, -4, -29 },
  { 9481, 22, 29, 19, -2, -29 },
  { 9561, 20, 46, 18, 1, -38 },
  { 9676, 5, 52, 22, 9, -40 },
  { 9709, 20, 46, 18, -3, -38 },
  { 9824, 23, 8, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC53PT7B_H_
