#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0xFC, 0x1F,
  0x01, 0xE0, 0x00, 0x7C, 0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00,
  0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0x81,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x38, 0x70,
  0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x80, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0xCC, 0x0F, 0x30, 0x03, 0xC8,
  0x00, 0xF6, 0x00, 0x3D, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x02, 0x78, 0x01,
  0x9E, 0x00, 0x67, 0x84, 0x19, 0xE1, 0xE7, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x03, 0xFE, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xC0, 0x3C, 0x1F, 0xC0, 0x78, 0x3F, 0xE0, 0x70,
  0x38, 0xE0, 0xF0, 0x78, 0xE0, 0xE0, 0x70, 0xE1, 0xC0, 0x70, 0xE3, 0xC0,
  0x71, 0xE3, 0x80, 0xF1, 0xE7, 0x80, 0xF1, 0xC7, 0x00, 0xE1, 0xCE, 0x18,
  0xE3, 0xDE, 0x7E, 0xE3, 0x9C, 0xFF, 0xFF, 0xBD, 0xEF, 0x7F, 0x39, 0xC7,
  0x7E, 0x73, 0xC7, 0x08, 0xF3, 0x87, 0x00, 0xE3, 0x87, 0x01, 0xE7, 0x8F,
  0x01, 0xC7, 0x8F, 0x03, 0xC7, 0x0E, 0x07, 0x87, 0x0E, 0x07, 0x07, 0x1E,
  0x0F, 0x07, 0x1C, 0x0E, 0x07, 0xFC, 0x1E, 0x03, 0xF8, 0x3C, 0x03, 0xF0,
  0x00, 0x08, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0xF1, 0xFF, 0x0F, 0x3E, 0xF9, 0xF3, 0xC7, 0x9E, 0x7C, 0x7F, 0xE7,
  0x87, 0xFC, 0xF8, 0x3F, 0x8F, 0x83, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0,
  0xFC, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xF7, 0xC1, 0xFC, 0x7C, 0x7D, 0xE7,
  0x9E, 0x73, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x03, 0x0E, 0x07,
  0x1C, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFE, 0x1F, 0x80, 0x7F,
  0x81, 0xE7, 0x07, 0xCF, 0x03, 0x1F, 0x04, 0x18, 0x00, 0x20, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xDF, 0x0F, 0x0F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F,
  0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF8, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0xFE, 0x3F, 0xE7, 0xDE, 0xFB, 0xC7, 0x3C, 0x63, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xCF,
  0xC0, 0xC1, 0xF0, 0x20, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xF0, 0x79, 0xF8, 0x20, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF9, 0x00, 0xF8, 0xF3, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xDF, 0x01,
  0xEF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1, 0xF0, 0x70, 0xF0,
  0x70, 0x78, 0x78, 0x3C, 0x38, 0x3E, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x88, 0x07, 0xC3, 0xEF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0x08, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFC, 0xF8, 0xF8,
  0x7C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E, 0x07, 0x9F, 0x07, 0xCF, 0x03, 0xE7,
  0x81, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7D, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x1F,
  0xFE, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x07,
  0x83, 0xC3, 0xE0, 0xF8, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0x7C, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0,
  0x78, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0x7C, 0x7C,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x30, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xF8, 0x78, 0x7C, 0x7C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0xFC, 0xFD, 0xFC, 0x3F, 0xFE, 0x1F, 0xEF, 0x07, 0xEF, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0xE3, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x07, 0xC3, 0xE3, 0xF0,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0x01, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x3F, 0xC3, 0xFF, 0x87, 0xFF,
  0x1C, 0x7C, 0x40, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x38, 0x00,
  0x38, 0x3C, 0x00, 0x0E, 0x3C, 0x1F, 0x87, 0x1C, 0x3F, 0xE3, 0x9E, 0x3F,
  0xF1, 0xCE, 0x1C, 0x78, 0xE7, 0x1C, 0x38, 0x77, 0x0E, 0x1C, 0x3B, 0x8E,
  0x0E, 0x3D, 0xC7, 0x0F, 0x1C, 0xE3, 0x87, 0x0E, 0xE3, 0xC3, 0x87, 0x71,
  0xE3, 0xC7, 0x38, 0xF1, 0xE3, 0x9C, 0x79, 0xF3, 0x8E, 0x1F, 0xFF, 0xC7,
  0x0F, 0xCF, 0xC3, 0xC3, 0xC3, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x7C, 0x0F,
  0x0F, 0x83, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xF7, 0x83, 0xE0, 0x21,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x20, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xC3, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07,
  0xC3, 0xC0, 0x7C, 0x3C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xF3, 0xE0,
  0xFC, 0x04, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0xFC, 0xF8, 0x3F,
  0xCF, 0x83, 0xFC, 0xF0, 0x7F, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF8, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0xC0, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x3C,
  0x0F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1E,
  0x01, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x02, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xE7, 0xC0, 0x0F,
  0x9E, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x81, 0xEE, 0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xE0, 0x7B, 0x81, 0xFF,
  0x03, 0xDC, 0x0E, 0xF0, 0x1E, 0xE0, 0xF7, 0x81, 0xE7, 0x07, 0x3C, 0x0F,
  0x3C, 0x79, 0xE0, 0x79, 0xE3, 0x9F, 0x03, 0xCF, 0x3C, 0xF0, 0x1E, 0x79,
  0xC7, 0x81, 0xE3, 0xDE, 0x3C, 0x0F, 0x1E, 0xE1, 0xE0, 0x78, 0xFF, 0x1F,
  0x03, 0xC7, 0xF8, 0xF0, 0x3E, 0x3F, 0x87, 0x81, 0xE1, 0xFC, 0x3C, 0x0F,
  0x0F, 0xC3, 0xE0, 0x78, 0x7E, 0x1F, 0x03, 0xC3, 0xE0, 0xF0, 0x3E, 0x0F,
  0x07, 0x80, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x07, 0xF0, 0x1E, 0x07,
  0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3C, 0x0F,
  0x78, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x78, 0x0F,
  0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0xF8, 0x1E,
  0x3C, 0xF0, 0x1E, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C,
  0x1E, 0xF0, 0x3C, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x78,
  0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x00,
  0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xE0,
  0xF8, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00,
  0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87,
  0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xEF, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x00, 0x3C, 0xF0,
  0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x0F,
  0x83, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x87, 0xE1, 0xF3, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xE0, 0x40, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x08, 0x07, 0xC3,
  0x03, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07,
  0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x1F, 0x01, 0xEF, 0x81, 0xF0, 0x1E, 0xF8, 0x1F, 0x03, 0xEF,
  0x83, 0xF0, 0x3C, 0xF8, 0x3F, 0x07, 0xCF, 0x07, 0xF0, 0x78, 0xF0, 0x77,
  0x07, 0x8F, 0x07, 0x70, 0xF8, 0xF0, 0xF7, 0x0F, 0x0F, 0x0E, 0x71, 0xF0,
  0xF1, 0xE7, 0x1E, 0x0F, 0x1E, 0x71, 0xE0, 0xF3, 0xC7, 0x3C, 0x0F, 0x3C,
  0x73, 0xC0, 0xF3, 0x87, 0x7C, 0x0F, 0x78, 0x77, 0x80, 0xF7, 0x87, 0x78,
  0x0F, 0x70, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3C,
  0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80,
  0x0F, 0x9F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xBC, 0x07,
  0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xE3, 0xE1, 0xF1, 0xE0, 0x79,
  0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x00, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0x70, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x87,
  0x03, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0x71, 0xE0, 0x39, 0xE0, 0x1F, 0xE0,
  0x0F, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xE7, 0x9E, 0x3C, 0x70,
  0x01, 0xE3, 0x83, 0xFB, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF1, 0xF9, 0xF0,
  0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0x9F,
  0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7E, 0xFE, 0x1F, 0xEF, 0x0F, 0xF7, 0x03, 0xE3, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x9E, 0x03, 0xDF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0x87, 0x87, 0xC1, 0xE1, 0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x03, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x3E, 0x1F, 0x9F, 0x07, 0x7F, 0xC3, 0xDF, 0xE0,
  0xF3, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xF0,
  0x87, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x20, 0xF9,
  0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x01, 0xE7, 0x80, 0xFE, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xF1, 0xF8, 0x7C, 0x3E, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x0F,
  0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x07, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x9F, 0x81, 0xFF, 0xF0, 0x3F,
  0xDC, 0x03, 0xF3, 0x80, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xFD, 0xF1,
  0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x1F, 0x78, 0x7C, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x61, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0xFE, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x0F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F,
  0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0xBF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0,
  0x1F, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x20,
  0x3E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x9E, 0x07, 0xBF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F,
  0x07, 0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF9, 0xF0, 0x78,
  0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x83,
  0xC0, 0x00, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0x40, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF8, 0x00, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x83, 0xE1,
  0xE0, 0xF8, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x78, 0x07,
  0x9F, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE0, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x80, 0x0F, 0x1E, 0x0F, 0x03, 0xDF, 0xCF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0x8F, 0xC3, 0xC7, 0xC1, 0xF0, 0xF1, 0xF0,
  0x78, 0x3C, 0x78, 0x3E, 0x0F, 0x1E, 0x0F, 0x07, 0xC7, 0x83, 0xC1, 0xE3,
  0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x3C, 0x1F, 0x07, 0x8F, 0x07, 0x83,
  0xE7, 0xC1, 0xE0, 0xF1, 0xF0, 0x78, 0x3C, 0x78, 0x3E, 0x0F, 0x1E, 0x0F,
  0x03, 0xC7, 0x83, 0xC1, 0xF3, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x00,
  0x0F, 0x1E, 0x07, 0xBF, 0x83, 0xFF, 0xE1, 0xDF, 0xF0, 0xF8, 0x78, 0xFC,
  0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC0, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x3E, 0x1F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0x7C, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x03, 0xC7, 0x80, 0x7B, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x07,
  0x83, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xF3, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xCF, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE3, 0x83, 0xF9, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1,
  0xF1, 0xF9, 0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x1F, 0x3C, 0x0F,
  0x9E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0,
  0xF8, 0xF8, 0x7C, 0x7E, 0xFE, 0x1F, 0xEF, 0x0F, 0xFF, 0x03, 0xE7, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x1E, 0x1E, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFE, 0x83, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xE0, 0x87, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x81, 0xF1, 0xC7, 0xE3, 0xFF, 0x87, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0xF3, 0xFE,
  0x7F, 0xE7, 0xFE, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x90,
  0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F,
  0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0,
  0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0xFE, 0x3F, 0xEE, 0x0F, 0xF7, 0x03,
  0xE3, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0x78, 0xF0, 0xF8, 0x70, 0xF0, 0x70, 0xF0, 0x71, 0xE0, 0x79, 0xE0,
  0x7B, 0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x77, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x3E, 0x0F, 0xF0,
  0x7E, 0x1F, 0xF0, 0x7E, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x3C, 0xF0,
  0xFC, 0x3C, 0xF1, 0xFC, 0x7C, 0xF1, 0xDC, 0x78, 0xF1, 0xDC, 0x78, 0xF3,
  0xDC, 0xF0, 0xF3, 0x9C, 0xF0, 0xF7, 0x9C, 0xF0, 0xF7, 0x1D, 0xE0, 0xF7,
  0x1D, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0x81, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80,
  0x3C, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xBC,
  0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1,
  0xE0, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xF0, 0x7C,
  0x0F, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x78,
  0x00, 0xFC, 0x02, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0x80,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x00,
  0x7E, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 12, 10, 15, 4, -27 },
  { 54, 20, 27, 20, 0, -27 },
  { 122, 18, 31, 17, 0, -29 },
  { 192, 24, 28, 27, 2, -28 },
  { 276, 20, 28, 21, 0, -28 },
  { 346, 6, 10, 9, 4, -27 },
  { 354, 12, 33, 11, 1, -27 },
  { 404, 13, 34, 11, -3, -28 },
  { 460, 15, 16, 17, 3, -29 },
  { 490, 16, 19, 19, 2, -23 },
  { 528, 8, 10, 9, -2, -5 },
  { 538, 9, 4, 11, 1, -12 },
  { 543, 6, 5, 9, 0, -5 },
  { 547, 19, 27, 14, -2, -27 },
  { 612, 16, 28, 17, 1, -28 },
  { 668, 12, 27, 17, 4, -27 },
  { 709, 18, 28, 17, -1, -28 },
  { 772, 17, 28, 17, 0, -28 },
  { 832, 17, 27, 17, 0, -27 },
  { 890, 18, 27, 17, 0, -27 },
  { 951, 17, 28, 17, 1, -28 },
  { 1011, 18, 27, 17, 1, -27 },
  { 1072, 18, 28, 17, 0, -28 },
  { 1135, 17, 28, 17, 0, -28 },
  { 1195, 9, 21, 9, 0, -21 },
  { 1219, 11, 26, 9, -2, -21 },
  { 1255, 16, 18, 19, 2, -23 },
  { 1291, 16, 11, 19, 2, -19 },
  { 1313, 16, 18, 19, 2, -23 },
  { 1349, 14, 28, 14, 1, -28 },
  { 1398, 25, 30, 26, 1, -27 },
  { 1492, 18, 27, 19, -2, -27 },
  { 1553, 19, 27, 19, 0, -27 },
  { 1618, 18, 28, 18, 2, -28 },
  { 1681, 20, 27, 21, 0, -27 },
  { 1749, 18, 27, 16, 0, -27 },
  { 1810, 18, 27, 16, 0, -27 },
  { 1871, 20, 28, 21, 2, -28 },
  { 1941, 22, 27, 22, 0, -27 },
  { 2016, 17, 27, 12, -2, -27 },
  { 2074, 17, 35, 10, -6, -27 },
  { 2149, 22, 27, 18, 0, -27 },
  { 2224, 13, 27, 16, 0, -27 },
  { 2268, 29, 27, 28, 0, -27 },
  { 2366, 24, 27, 23, 0, -27 },
  { 2447, 20, 28, 22, 2, -28 },
  { 2517, 19, 27, 18, 0, -27 },
  { 2582, 20, 34, 22, 2, -28 },
  { 2667, 19, 27, 19, 0, -27 },
  { 2732, 18, 28, 17, 0, -28 },
  { 2795, 16, 27, 16, 3, -27 },
  { 2849, 20, 27, 21, 2, -27 },
  { 2917, 19, 27, 18, 3, -27 },
  { 2982, 28, 27, 28, 3, -27 },
  { 3077, 22, 27, 18, -2, -27 },
  { 3152, 17, 27, 17, 3, -27 },
  { 3210, 19, 27, 16, -1, -27 },
  { 3275, 15, 33, 11, -1, -27 },
  { 3337, 7, 27, 14, 4, -27 },
  { 3361, 15, 33, 11, -3, -27 },
  { 3423, 17, 16, 18, 0, -27 },
  { 3457, 14, 3, 13, -4, 3 },
  { 3463, 6, 6, 11, 6, -29 },
  { 3468, 17, 21, 19, 1, -21 },
  { 3513, 18, 29, 19, 0, -29 },
  { 3579, 15, 21, 15, 1, -21 },
  { 3619, 19, 29, 19, 1, -29 },
  { 3688, 15, 21, 17, 1, -21 },
  { 3728, 19, 38, 11, -4, -29 },
  { 3819, 18, 30, 19, 0, -21 },
  { 3887, 17, 29, 19, 0, -29 },
  { 3949, 10, 29, 9, 0, -29 },
  { 3986, 15, 38, 9, -5, -29 },
  { 4058, 19, 29, 17, 0, -29 },
  { 4127, 11, 29, 9, 0, -29 },
  { 4167, 26, 21, 27, 0, -21 },
  { 4236, 17, 21, 19, 0, -21 },
  { 4281, 16, 21, 18, 1, -21 },
  { 4323, 19, 30, 19, -2, -21 },
  { 4395, 17, 30, 19, 1, -21 },
  { 4459, 15, 21, 13, 0, -21 },
  { 4499, 15, 21, 14, 0, -21 },
  { 4539, 12, 25, 12, 1, -25 },
  { 4577, 17, 21, 18, 1, -21 },
  { 4622, 16, 21, 16, 2, -21 },
  { 4664, 24, 21, 24, 2, -21 },
  { 4727, 20, 21, 16, -2, -21 },
  { 4780, 21, 30, 16, -3, -21 },
  { 4859, 16, 21, 14, -1, -21 },
  { 4901, 15, 33, 13, 0, -27 },
  { 4963, 4, 38, 16, 6, -29 },
  { 4982, 14, 33, 13, -2, -27 },
  { 5040, 16, 6, 19, 2, -16 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC38PT7B_H_
