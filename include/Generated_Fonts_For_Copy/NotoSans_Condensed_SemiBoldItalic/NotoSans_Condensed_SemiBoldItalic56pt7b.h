#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x1F,
  0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x1E,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x87, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFD, 0xF0, 0x0F, 0xE7, 0x1C, 0x03, 0xF1, 0x81, 0x01, 0xF8, 0xE0,
  0x00, 0x7E, 0x38, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xF3, 0x00, 0x01, 0xFC,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x77, 0xF8, 0x00, 0x1C,
  0xFE, 0x00, 0x07, 0x3F, 0x80, 0x01, 0xCF, 0xE0, 0x00, 0x63, 0xF8, 0x40,
  0x38, 0xFC, 0x1C, 0x0E, 0x7F, 0x07, 0xC3, 0xBF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x3F, 0x3E, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x3E, 0x1F, 0x01, 0xF0,
  0x0F, 0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0xF8, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x3E, 0x0F,
  0x87, 0xC0, 0x07, 0xC1, 0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x3E, 0x0E, 0x1F,
  0x07, 0xCF, 0x87, 0xF3, 0xE1, 0xF1, 0xF1, 0xFF, 0x7C, 0x3E, 0x7C, 0x7F,
  0xFF, 0x8F, 0x9F, 0x1F, 0xFF, 0xFF, 0xE3, 0xE7, 0xE7, 0xDF, 0xFC, 0xF8,
  0xF8, 0xFB, 0xFF, 0x1F, 0x3E, 0x0F, 0x3F, 0xC7, 0xC7, 0xC1, 0xE0, 0x81,
  0xF8, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC1, 0xF0,
  0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xC0,
  0xF8, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x01, 0xF9, 0xF0, 0x0F, 0x80, 0x1F, 0xFE, 0x01, 0xF0, 0x03, 0xFF, 0x80,
  0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0xFE, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x03, 0xF0,
  0x7F, 0xFC, 0x1F, 0x83, 0xFB, 0xF0, 0x7E, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0x7F, 0x1F, 0xC0, 0xFD, 0xF8, 0x7E, 0x03,
  0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0x80, 0x7F,
  0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xC7, 0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC,
  0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x10, 0x3E, 0x01, 0xE1,
  0xF0, 0x0F, 0xCF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xBF, 0x01, 0xFC, 0xF8, 0x1F, 0xC7, 0xE0, 0x7C, 0x3F, 0x00,
  0xC0, 0xFC, 0x02, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x0E, 0x3F,
  0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x3F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFE,
  0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80,
  0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0xFE,
  0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF,
  0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F,
  0xBF, 0x3F, 0x9F, 0x8F, 0x8F, 0xC3, 0x0F, 0xE1, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0x87, 0xF8, 0x03, 0xC0, 0x7F, 0x00, 0x70, 0x07, 0xE0,
  0x04, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x07, 0xF8, 0x03,
  0x00, 0xFF, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x08, 0x00, 0x7F, 0x83, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7F,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x80, 0x03, 0xF8, 0x30, 0x01, 0xFE, 0x0F, 0x81,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x04, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0x00,
  0x3F, 0x1F, 0xE0, 0x1F, 0xBF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xF1, 0xFE, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8,
  0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xE3, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0x81,
  0xFE, 0x1F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFE, 0xFC, 0x07, 0xF8, 0xFC, 0x00, 0xC1, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x80, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x14, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x02, 0x00, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0x07, 0xF0, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x0C, 0x01, 0xF0, 0xF8, 0x07, 0xFE,
  0x0F, 0x0F, 0x81, 0xFF, 0xF0, 0xF1, 0xF0, 0x3F, 0xFE, 0x0F, 0x1F, 0x07,
  0xF3, 0xE0, 0xF3, 0xE0, 0xFC, 0x3E, 0x0F, 0x3E, 0x0F, 0x83, 0xE0, 0xF3,
  0xC1, 0xF0, 0x3C, 0x0F, 0x7C, 0x1F, 0x07, 0xC1, 0xF7, 0xC3, 0xE0, 0x7C,
  0x1F, 0x78, 0x3E, 0x07, 0xC1, 0xF7, 0x83, 0xC0, 0x78, 0x1E, 0xF8, 0x7C,
  0x0F, 0x81, 0xEF, 0x87, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x0F, 0x83, 0xCF,
  0x07, 0xC1, 0xF0, 0x3C, 0xF0, 0x7C, 0x1F, 0x07, 0xCF, 0x07, 0xC3, 0xF0,
  0x78, 0xF0, 0x7C, 0x3F, 0x0F, 0x8F, 0x07, 0xC7, 0xF9, 0xF0, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0x03, 0xFE, 0x7F, 0xC0, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F,
  0x80, 0xF0, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00,
  0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x0F, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xC7, 0xC0, 0x1F, 0xE0, 0x08, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x03, 0xFE, 0x1F, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0x7F,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x7E, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00,
  0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F,
  0x80, 0x7F, 0xC0, 0x0C, 0x03, 0xFC, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0xFC, 0x7F, 0x00, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0x87, 0xF0, 0x1F, 0xFE,
  0x1F, 0xC0, 0x7F, 0xF8, 0x7E, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x03, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x00,
  0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x00, 0xFD, 0xF0, 0x07, 0xDF,
  0x80, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0xF9, 0xF8, 0x07,
  0xE7, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x1F, 0xBF, 0x80, 0x7E, 0x7C,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x1F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE3, 0xE1, 0xF8, 0x03, 0xF1,
  0xF9, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x7C, 0x3F, 0x80, 0x7E, 0x1F, 0xBF,
  0x0F, 0xC0, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0xFC,
  0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xFC, 0x1F, 0xC0, 0x3F,
  0x03, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xF0,
  0x00, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x0F,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xF0,
  0x0F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x03,
  0xF0, 0x07, 0xDF, 0x80, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x3F, 0x7E,
  0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x00, 0xFC, 0xF8, 0x0F, 0xC0, 0x1F,
  0x1F, 0x81, 0xF8, 0x07, 0xE3, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x0F, 0xC0,
  0x1F, 0x8F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x87,
  0xE0, 0x1F, 0x83, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x3F, 0x00, 0x7E, 0x07,
  0xC7, 0xE0, 0x0F, 0xC0, 0xFC, 0xFC, 0x01, 0xF8, 0x1F, 0x9F, 0x80, 0x7E,
  0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x7E, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7E, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xBF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xCF, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x07, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xE0, 0x0F, 0xF0, 0x0C, 0x03, 0xFC, 0x00,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x7F,
  0x81, 0xC0, 0x1F, 0xE0, 0x3F, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xC0,
  0x0F, 0xEF, 0xC0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x03, 0xF3,
  0xF0, 0x07, 0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFF, 0x80,
  0x7E, 0x1F, 0x80, 0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x07,
  0xE0, 0x7F, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0xF8, 0x1F, 0x81, 0xF8, 0x3F,
  0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0x7E, 0x0F, 0x9F, 0x07,
  0xE0, 0x3F, 0x0F, 0xCF, 0x83, 0xF0, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x0F,
  0xC7, 0xE3, 0xE1, 0xF8, 0x07, 0xE3, 0xE1, 0xF1, 0xFC, 0x03, 0xF1, 0xF0,
  0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x3E, 0x7E,
  0x00, 0x7E, 0xFC, 0x1F, 0x3F, 0x00, 0x3F, 0x7C, 0x0F, 0xBF, 0x80, 0x1F,
  0xBE, 0x07, 0xDF, 0x80, 0x0F, 0xFF, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x03,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F,
  0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F,
  0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x7F, 0xE7, 0xE0, 0x7F, 0xFB, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE,
  0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01,
  0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xE1, 0xF8,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0x7E, 0x07, 0xFF, 0x3E, 0x01, 0xFF, 0x1F, 0x00, 0x7F, 0x0F, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x78, 0x00, 0xFE, 0x7F,
  0x80, 0x3F, 0x3F, 0xF0, 0x0F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xDF, 0xE0, 0x7F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x7D, 0xFF, 0xE0, 0x3F, 0x3F, 0xF0, 0x0F, 0x87, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0x80, 0x83, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0x07, 0xF8, 0x38, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3C, 0x1F, 0x80,
  0x0F, 0xF1, 0xF8, 0x01, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFB,
  0xE0, 0x03, 0xFF, 0x3E, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xC7, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x07, 0xF9,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0x07,
  0xFD, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x08, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x23, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x3F,
  0xF3, 0xF0, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x01,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFC, 0x00, 0x7F, 0xCF, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x0C, 0x00, 0x7F, 0x00, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xDF, 0xFC,
  0x07, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F,
  0xE0, 0xFF, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x02, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x81,
  0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x10, 0xF8, 0x03, 0xE0, 0x07, 0xC7, 0xFC, 0x1F, 0xF0, 0x0F, 0x9F, 0xFC,
  0x7F, 0xF0, 0x1F, 0x7F, 0xF9, 0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x1F,
  0x83, 0xF8, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0xFF, 0x00, 0xF9, 0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x3E, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x83,
  0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07,
  0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x00,
  0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F,
  0x00, 0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF1, 0xFE, 0x00,
  0x1F, 0x1F, 0xF8, 0x00, 0xF9, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0x00, 0x3F,
  0xF7, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFD, 0xFF,
  0xC0, 0x07, 0xEF, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF0, 0x20, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xC7, 0xC0, 0x7F, 0xF7, 0xE0, 0x7F, 0xFB, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0x80, 0x7E,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFE, 0x00,
  0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0x7E, 0x01, 0xFF, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x04, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x8F, 0xC0, 0xF9, 0xFE, 0x07, 0xCF,
  0xF0, 0x3E, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xF8, 0xF8, 0x3F, 0x00, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x80, 0x1F, 0xC7, 0x01, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x82, 0x1F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xE0,
  0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0x7C,
  0x07, 0xFE, 0x3E, 0x01, 0xFE, 0x1F, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x9F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x07,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x0F, 0xF8, 0x1F, 0xCF,
  0xC0, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xF8, 0x1F, 0x8F, 0xC1, 0xFF, 0x83,
  0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x3E,
  0xF8, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x7C, 0xF8, 0xFC, 0x0F,
  0xC7, 0xCF, 0x8F, 0xC0, 0xFC, 0xF8, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F, 0x9F,
  0x80, 0xFC, 0xF8, 0xF9, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0,
  0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x5F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF8, 0x01,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 41, 14, 0, -40 },
  { 83, 19, 14, 22, 5, -40 },
  { 117, 30, 40, 29, 0, -40 },
  { 267, 26, 46, 25, 0, -43 },
  { 417, 35, 42, 40, 3, -41 },
  { 601, 30, 42, 31, 0, -41 },
  { 759, 8, 14, 13, 6, -40 },
  { 773, 19, 49, 16, 1, -40 },
  { 890, 18, 50, 16, -4, -41 },
  { 1003, 21, 23, 25, 5, -43 },
  { 1064, 23, 27, 27, 3, -33 },
  { 1142, 12, 14, 13, -3, -7 },
  { 1163, 14, 6, 16, 1, -18 },
  { 1174, 8, 9, 13, 0, -8 },
  { 1183, 28, 40, 21, -3, -40 },
  { 1323, 23, 42, 25, 2, -41 },
  { 1444, 17, 40, 26, 6, -40 },
  { 1529, 27, 41, 25, -2, -41 },
  { 1668, 26, 42, 25, 0, -41 },
  { 1805, 27, 40, 26, -1, -40 },
  { 1940, 26, 41, 25, 0, -40 },
  { 2074, 25, 42, 25, 2, -41 },
  { 2206, 26, 40, 25, 2, -40 },
  { 2336, 26, 42, 25, 0, -41 },
  { 2473, 24, 42, 25, 1, -41 },
  { 2599, 13, 32, 14, 0, -31 },
  { 2651, 16, 38, 14, -3, -31 },
  { 2727, 24, 26, 27, 2, -33 },
  { 2805, 23, 16, 27, 3, -28 },
  { 2851, 23, 26, 27, 3, -33 },
  { 2926, 20, 42, 20, 2, -41 },
  { 3031, 36, 45, 39, 2, -40 },
  { 3234, 27, 40, 28, -3, -40 },
  { 3369, 28, 40, 28, 0, -40 },
  { 3509, 28, 42, 27, 2, -41 },
  { 3656, 30, 40, 31, 0, -40 },
  { 3806, 26, 40, 24, 0, -40 },
  { 3936, 26, 40, 23, 0, -40 },
  { 4066, 30, 42, 32, 2, -41 },
  { 4224, 33, 40, 32, 0, -40 },
  { 4389, 23, 40, 18, -2, -40 },
  { 4504, 25, 51, 14, -9, -40 },
  { 4664, 32, 40, 27, 0, -40 },
  { 4824, 19, 40, 23, 0, -40 },
  { 4919, 42, 40, 41, 0, -40 },
  { 5129, 35, 40, 34, 0, -40 },
  { 5304, 30, 42, 33, 2, -41 },
  { 5462, 28, 40, 27, 0, -40 },
  { 5602, 30, 51, 33, 2, -41 },
  { 5794, 28, 40, 28, 0, -40 },
  { 5934, 27, 42, 24, -1, -41 },
  { 6076, 24, 40, 24, 4, -40 },
  { 6196, 30, 41, 31, 3, -40 },
  { 6350, 27, 40, 27, 5, -40 },
  { 6485, 41, 40, 42, 5, -40 },
  { 6690, 33, 40, 26, -3, -40 },
  { 6855, 25, 40, 25, 5, -40 },
  { 6980, 29, 40, 23, -2, -40 },
  { 7125, 22, 49, 16, -2, -40 },
  { 7260, 11, 40, 21, 6, -40 },
  { 7315, 22, 49, 16, -4, -40 },
  { 7450, 25, 24, 26, 0, -40 },
  { 7525, 20, 4, 19, -5, 5 },
  { 7535, 10, 9, 16, 8, -43 },
  { 7547, 25, 32, 27, 2, -31 },
  { 7647, 26, 44, 27, 0, -43 },
  { 7790, 21, 32, 22, 2, -31 },
  { 7874, 28, 44, 27, 2, -43 },
  { 8028, 22, 32, 25, 2, -31 },
  { 8116, 29, 56, 16, -6, -43 },
  { 8319, 28, 44, 27, -1, -31 },
  { 8473, 25, 43, 27, 0, -43 },
  { 8608, 15, 42, 13, 0, -42 },
  { 8687, 22, 55, 13, -7, -42 },
  { 8839, 27, 43, 25, 0, -43 },
  { 8985, 16, 43, 13, 0, -43 },
  { 9071, 39, 31, 40, 0, -31 },
  { 9223, 25, 31, 27, 0, -31 },
  { 9320, 23, 32, 27, 2, -31 },
  { 9412, 29, 44, 27, -3, -31 },
  { 9572, 25, 44, 27, 2, -31 },
  { 9710, 21, 31, 19, 0, -31 },
  { 9792, 21, 32, 21, 0, -31 },
  { 9876, 17, 38, 17, 2, -37 },
  { 9957, 25, 31, 27, 2, -30 },
  { 10054, 23, 30, 23, 3, -30 },
  { 10141, 36, 30, 36, 3, -30 },
  { 10276, 29, 30, 24, -3, -30 },
  { 10385, 31, 43, 23, -5, -30 },
  { 10552, 23, 30, 20, -2, -30 },
  { 10639, 22, 49, 19, 1, -40 },
  { 10774, 5, 56, 24, 9, -43 },
  { 10809, 21, 49, 19, -3, -40 },
  { 10938, 24, 9, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC56PT7B_H_
