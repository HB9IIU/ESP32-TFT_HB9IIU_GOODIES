#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x0F, 0x00, 0x20, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF9, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF3, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x70, 0xF0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x01, 0xE1,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x87,
  0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x0F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xCC, 0x60, 0x3C, 0x61, 0x03, 0xE3, 0x00, 0x1F, 0x30, 0x00,
  0xF9, 0x80, 0x07, 0xEC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x37, 0xE0, 0x01, 0x9F, 0x00, 0x0C, 0xF8, 0x00, 0x67, 0xC2, 0x07, 0x3E,
  0x18, 0x33, 0xF0, 0xF9, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x1E, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x01, 0xE7, 0x80, 0xF0,
  0x1F, 0x1C, 0x0F, 0x00, 0xF0, 0xE0, 0x78, 0x07, 0x8F, 0x07, 0x80, 0x78,
  0x78, 0x3C, 0x03, 0xC3, 0xC3, 0xC0, 0x1E, 0x1E, 0x3C, 0x00, 0xF0, 0xF1,
  0xE0, 0x07, 0x87, 0x9E, 0x00, 0x78, 0x78, 0xF1, 0xC3, 0xC3, 0xCF, 0x1F,
  0x9F, 0x3C, 0xF1, 0xFE, 0x79, 0xE7, 0x9F, 0xFB, 0xFE, 0x79, 0xE3, 0xDF,
  0xF3, 0xCF, 0x1E, 0x7E, 0x3C, 0xF0, 0xF0, 0x43, 0xE7, 0x87, 0x80, 0x1E,
  0x3C, 0x3C, 0x01, 0xE3, 0xC1, 0xE0, 0x0F, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0xF0, 0x0F, 0x87, 0x87, 0x80, 0x78, 0x3C, 0x3C, 0x07, 0x81, 0xE3, 0xC0,
  0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0x79, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xE0,
  0x0F, 0xF0, 0x1E, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF9, 0xF0, 0x01, 0xF1, 0xF0,
  0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0x0F, 0xFE, 0x3F, 0x1F, 0x3E, 0x3E, 0x3E, 0x3F, 0x3E, 0x7E, 0x1F, 0x7C,
  0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0xF8, 0xFC, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF9, 0xF8, 0x1F, 0xF0, 0xFC, 0x3E, 0x7C, 0xF9,
  0xF3, 0xCF, 0x9F, 0x3C, 0x78, 0xF3, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x3C, 0x07, 0x1E, 0x03, 0xEF,
  0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xC1, 0xF8, 0x01,
  0xFE, 0x03, 0xFF, 0x03, 0xF3, 0xC1, 0xF1, 0xF0, 0x78, 0xF8, 0x08, 0x38,
  0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x8F, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0x88, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E,
  0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0x3F, 0x7C, 0xF9,
  0xF1, 0xC7, 0xC2, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xF0, 0xFC, 0x06, 0x03, 0xE0,
  0x20, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xC1, 0xFC,
  0x0C, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE1, 0x00, 0x3F, 0x0E, 0x07, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xF0,
  0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF2, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0E, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x20,
  0x0F, 0xE1, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0xC0, 0x1F, 0x3F, 0x80, 0xFB, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xF8, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F,
  0x87, 0xE0, 0x7E, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x3F, 0x03, 0xF0,
  0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7,
  0xC0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC7,
  0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x7F, 0x3F,
  0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFB, 0xE0, 0xFE, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x08, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x3F, 0x8F, 0xC3, 0xF0, 0x78, 0x08,
  0x00, 0x00, 0x60, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0xF8, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x18, 0x3F, 0x10, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0xF0,
  0x3C, 0x3C, 0x1F, 0xF8, 0xF1, 0xE0, 0xFF, 0xE3, 0xC7, 0x87, 0xEF, 0x0F,
  0x3C, 0x3E, 0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0xF3, 0x87, 0x83, 0xC3, 0xDE,
  0x1E, 0x0E, 0x0E, 0x78, 0x70, 0x78, 0x39, 0xE3, 0xC1, 0xE1, 0xE7, 0x8F,
  0x07, 0x87, 0x9C, 0x3C, 0x3C, 0x1C, 0x70, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3,
  0xC3, 0x8F, 0x0F, 0x1F, 0x1E, 0x3C, 0x3C, 0xFC, 0xF0, 0xF0, 0xFF, 0x7F,
  0x83, 0xC1, 0xF8, 0xFE, 0x07, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x0C, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F,
  0x1F, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0xC0, 0x7E,
  0x01, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x40, 0x7F,
  0x8F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x04, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x0F,
  0xFC, 0x7C, 0x0F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x1F,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xE0, 0x7F, 0x87, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x6F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8,
  0x1F, 0x7C, 0x07, 0xBE, 0x07, 0xBE, 0x03, 0xEF, 0x83, 0xEF, 0x80, 0xFB,
  0xE0, 0xF3, 0xE0, 0x3E, 0x78, 0x7C, 0xF8, 0x0F, 0x1E, 0x1E, 0x7C, 0x07,
  0xC7, 0x8F, 0x9F, 0x01, 0xF1, 0xE3, 0xC7, 0xC0, 0x7C, 0x79, 0xF1, 0xF0,
  0x1F, 0x1E, 0x78, 0x7C, 0x07, 0x87, 0xBE, 0x3E, 0x03, 0xE1, 0xEF, 0x0F,
  0x80, 0xF8, 0x7B, 0xC3, 0xE0, 0x3E, 0x1F, 0xF0, 0xF8, 0x0F, 0x87, 0xF8,
  0x3E, 0x03, 0xC1, 0xFE, 0x1F, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0x7C, 0x1F,
  0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xFC,
  0x01, 0xE0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x3E,
  0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x3C, 0x07, 0xFE, 0x07, 0xC0, 0x7F,
  0xE0, 0x7C, 0x07, 0xDE, 0x07, 0xC0, 0x79, 0xF0, 0x7C, 0x0F, 0x9F, 0x07,
  0x80, 0xF9, 0xF0, 0xF8, 0x0F, 0x8F, 0x0F, 0x80, 0xF8, 0xF8, 0xF8, 0x0F,
  0x0F, 0x8F, 0x81, 0xF0, 0xF9, 0xF0, 0x1F, 0x0F, 0x9F, 0x01, 0xF0, 0x79,
  0xF0, 0x1F, 0x07, 0xDF, 0x01, 0xE0, 0x7D, 0xE0, 0x3E, 0x07, 0xDE, 0x03,
  0xE0, 0x3F, 0xE0, 0x3E, 0x03, 0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0x3C, 0x03,
  0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0xC0,
  0x78, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x3F,
  0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC7, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE1, 0xFC, 0x0F,
  0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xF8, 0xF8, 0x3F, 0x80, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x20, 0x07, 0xE1,
  0x80, 0x7E, 0x0F, 0x8F, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E,
  0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00,
  0x78, 0x7C, 0x01, 0xE3, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x79,
  0xF0, 0x01, 0xE7, 0xC0, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xFC, 0x01, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x03,
  0xEF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x3F, 0x81,
  0xF9, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x7C, 0x1F, 0xF0,
  0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x07, 0xBC, 0x3F, 0x0F, 0x87, 0x9E,
  0x1F, 0x07, 0xC3, 0xCF, 0x0F, 0x83, 0xE3, 0xE7, 0x8F, 0x81, 0xF1, 0xE3,
  0xC7, 0xC0, 0xF9, 0xF1, 0xE7, 0xC0, 0x7C, 0xF1, 0xF3, 0xE0, 0x3E, 0x78,
  0xF9, 0xF0, 0x1F, 0x7C, 0x7D, 0xF0, 0x0F, 0xBC, 0x3E, 0xF8, 0x07, 0xDE,
  0x1F, 0x78, 0x03, 0xDE, 0x0F, 0xFC, 0x01, 0xEF, 0x07, 0xBE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xFF, 0x80,
  0x7E, 0xFC, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C,
  0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x78, 0x3C, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x07, 0xC3, 0xC0, 0x78,
  0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xF7, 0xC0, 0x0F, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF9, 0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0xE7, 0xC1, 0xFF, 0xBC, 0x0F, 0xFD, 0xE0, 0xFF, 0xFF, 0x0F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xBC, 0x07, 0xF9, 0xE0, 0x1F,
  0x8F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x3C, 0x01, 0xF3, 0xF8, 0x0F, 0xBF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x8F, 0xC1, 0xFF, 0xFE, 0x0F,
  0x7F, 0xE0, 0xFB, 0xFE, 0x07, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFC, 0x08, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x87, 0xE1, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xF3, 0xE0, 0x3F, 0xF7,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0x81, 0xF8,
  0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC,
  0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x87, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xF7, 0x80, 0x3F, 0xCF,
  0x00, 0x3F, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xC7, 0xC7, 0xE0, 0xF1, 0xF0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07,
  0xDF, 0x83, 0xE7, 0xC3, 0xF9, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x06, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFE, 0x7C, 0x07, 0xFE, 0xF0, 0x0F, 0xFD, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF1, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x30, 0x0F, 0xC0, 0x7E, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x38, 0x07, 0xCF, 0xE0, 0x7F,
  0xFF, 0x07, 0xBF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F,
  0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0xE0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x00,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x10, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x0F, 0x3F, 0xC7, 0xF8, 0x1E, 0xFF, 0x9F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xC3, 0xF0,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x3F, 0x03,
  0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF8, 0x1E, 0x1F, 0x03, 0xE0,
  0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x3E,
  0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0xFE, 0x07, 0xBF, 0xF0, 0x7B, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFE, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03,
  0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F,
  0xFF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x3E,
  0x3E, 0x0F, 0xC7, 0xC3, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC7, 0xF0, 0x07, 0xBF, 0xF0,
  0x0F, 0x7F, 0xE0, 0x1F, 0xEF, 0xC0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xFC, 0x7E, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x3F, 0xC0,
  0x3E, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xE7, 0xC0, 0xFF, 0xBC, 0x0F, 0xFD, 0xE0, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07,
  0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x83, 0xCF, 0xC1, 0xEF, 0xE0, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xC8, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xE1, 0xF8, 0xF0, 0xF8, 0x08, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x10, 0x0F, 0x8C, 0x0F,
  0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x87, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F,
  0xE1, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0x81, 0xFF, 0x3C, 0x07,
  0xF3, 0xE0, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8,
  0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E,
  0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0x81, 0xFF,
  0x83, 0xF8, 0x3E, 0xF8, 0x3F, 0x83, 0xEF, 0x87, 0xF8, 0x7C, 0xF8, 0x7F,
  0x07, 0xCF, 0x87, 0xF0, 0x7C, 0xF0, 0xF7, 0x0F, 0x8F, 0x0F, 0xF0, 0xF8,
  0xF1, 0xEF, 0x1F, 0x0F, 0x1E, 0xF1, 0xF0, 0xF1, 0xEF, 0x1E, 0x0F, 0x3C,
  0xF3, 0xE0, 0xF3, 0xCF, 0x3E, 0x0F, 0x78, 0xF3, 0xC0, 0xF7, 0x8F, 0x7C,
  0x0F, 0x78, 0xF7, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x07,
  0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xA0, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 33, 11, 0, -32 },
  { 55, 15, 11, 18, 4, -32 },
  { 76, 24, 32, 23, 0, -32 },
  { 172, 21, 37, 20, 0, -34 },
  { 270, 29, 33, 32, 2, -33 },
  { 390, 24, 33, 25, 0, -33 },
  { 489, 7, 11, 10, 4, -32 },
  { 499, 15, 39, 13, 1, -32 },
  { 573, 15, 40, 13, -3, -33 },
  { 648, 17, 18, 20, 4, -34 },
  { 687, 19, 22, 22, 2, -27 },
  { 740, 9, 11, 11, -2, -5 },
  { 753, 11, 4, 13, 1, -14 },
  { 759, 7, 7, 11, 0, -6 },
  { 766, 22, 32, 17, -2, -32 },
  { 854, 19, 33, 20, 1, -33 },
  { 933, 14, 32, 21, 5, -32 },
  { 989, 21, 33, 20, -1, -33 },
  { 1076, 21, 33, 20, 0, -33 },
  { 1163, 22, 32, 21, -1, -32 },
  { 1251, 21, 32, 20, 0, -32 },
  { 1335, 21, 33, 20, 1, -33 },
  { 1422, 21, 32, 20, 2, -32 },
  { 1506, 21, 33, 20, 0, -33 },
  { 1593, 19, 33, 20, 1, -33 },
  { 1672, 10, 26, 11, 0, -25 },
  { 1705, 13, 31, 11, -2, -25 },
  { 1756, 19, 22, 22, 2, -27 },
  { 1809, 19, 13, 22, 2, -22 },
  { 1840, 19, 22, 22, 2, -27 },
  { 1893, 16, 33, 16, 2, -33 },
  { 1959, 30, 36, 31, 1, -32 },
  { 2094, 22, 32, 22, -3, -32 },
  { 2182, 23, 32, 23, 0, -32 },
  { 2274, 22, 33, 21, 2, -33 },
  { 2365, 24, 32, 25, 0, -32 },
  { 2461, 21, 32, 19, 0, -32 },
  { 2545, 21, 32, 19, 0, -32 },
  { 2629, 24, 33, 25, 2, -33 },
  { 2728, 27, 32, 26, 0, -32 },
  { 2836, 19, 32, 14, -2, -32 },
  { 2912, 20, 41, 11, -7, -32 },
  { 3015, 26, 32, 22, 0, -32 },
  { 3119, 15, 32, 18, 0, -32 },
  { 3179, 34, 32, 33, 0, -32 },
  { 3315, 28, 32, 27, 0, -32 },
  { 3427, 24, 33, 26, 2, -33 },
  { 3526, 23, 32, 22, 0, -32 },
  { 3618, 24, 41, 26, 2, -33 },
  { 3741, 22, 32, 22, 0, -32 },
  { 3829, 21, 33, 20, 0, -33 },
  { 3916, 18, 32, 19, 4, -32 },
  { 3988, 24, 32, 25, 2, -32 },
  { 4084, 22, 32, 22, 4, -32 },
  { 4172, 33, 32, 33, 4, -32 },
  { 4304, 27, 32, 21, -3, -32 },
  { 4412, 20, 32, 20, 4, -32 },
  { 4492, 24, 32, 19, -2, -32 },
  { 4588, 17, 39, 13, -1, -32 },
  { 4671, 9, 32, 17, 5, -32 },
  { 4707, 18, 39, 13, -3, -32 },
  { 4795, 20, 19, 21, 0, -32 },
  { 4843, 16, 3, 15, -4, 4 },
  { 4849, 7, 7, 13, 7, -34 },
  { 4856, 21, 25, 22, 1, -25 },
  { 4922, 21, 34, 22, 0, -34 },
  { 5012, 17, 25, 17, 1, -25 },
  { 5066, 23, 34, 22, 1, -34 },
  { 5164, 18, 25, 20, 1, -25 },
  { 5221, 23, 45, 13, -5, -34 },
  { 5351, 23, 36, 22, -1, -25 },
  { 5455, 20, 34, 22, 0, -34 },
  { 5540, 12, 34, 11, 0, -34 },
  { 5591, 18, 45, 11, -6, -34 },
  { 5693, 22, 34, 20, 0, -34 },
  { 5787, 13, 34, 11, 0, -34 },
  { 5843, 31, 25, 32, 0, -25 },
  { 5940, 20, 25, 22, 0, -25 },
  { 6003, 19, 25, 21, 1, -25 },
  { 6063, 23, 36, 22, -2, -25 },
  { 6167, 21, 36, 22, 1, -25 },
  { 6262, 17, 25, 15, 0, -25 },
  { 6316, 17, 25, 17, 0, -25 },
  { 6370, 13, 30, 14, 2, -30 },
  { 6419, 21, 24, 22, 1, -24 },
  { 6482, 18, 24, 19, 3, -24 },
  { 6536, 28, 24, 29, 3, -24 },
  { 6620, 23, 24, 19, -2, -24 },
  { 6689, 25, 35, 19, -4, -24 },
  { 6799, 18, 24, 16, -1, -24 },
  { 6853, 17, 39, 15, 1, -32 },
  { 6936, 5, 44, 19, 7, -34 },
  { 6964, 17, 39, 15, -2, -32 },
  { 7047, 19, 7, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC45PT7B_H_
