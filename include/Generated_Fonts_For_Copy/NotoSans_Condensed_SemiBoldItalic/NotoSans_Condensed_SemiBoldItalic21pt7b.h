#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC0, 0x00, 0x63, 0x8E,
  0x00, 0x6E, 0xDD, 0xB6, 0x6C, 0xC0, 0x06, 0x60, 0xD8, 0x33, 0x06, 0x63,
  0xFE, 0x7F, 0xC6, 0x60, 0xC8, 0x13, 0x1F, 0xFB, 0xFF, 0x13, 0x06, 0x60,
  0xCC, 0x1B, 0x00, 0x02, 0x00, 0x80, 0xFC, 0x7E, 0x34, 0x8D, 0x03, 0xC0,
  0xF0, 0x1F, 0x03, 0xC0, 0xB8, 0x2C, 0xCB, 0x3F, 0xC7, 0xE0, 0x40, 0x10,
  0x00, 0x3C, 0x33, 0xE3, 0x1B, 0x18, 0x99, 0x8C, 0xC8, 0x66, 0xC3, 0x2D,
  0xFB, 0x6F, 0x76, 0xC8, 0x26, 0x43, 0x26, 0x33, 0x31, 0x99, 0x98, 0xF9,
  0xC3, 0x80, 0x0F, 0x81, 0xF0, 0x66, 0x0C, 0xC1, 0x98, 0x36, 0x07, 0x81,
  0xE3, 0x7E, 0x6C, 0xDB, 0x9F, 0x71, 0xCE, 0x39, 0xFF, 0x1F, 0x70, 0x6D,
  0xEC, 0x06, 0x18, 0x70, 0xC3, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x1C, 0x18, 0x30, 0x60, 0xE0, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x1C, 0x31, 0xC0, 0x1C, 0x18, 0xD8,
  0xFF, 0x1F, 0x38, 0xEC, 0x4E, 0x08, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF,
  0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x33, 0x76, 0xEC, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x1F, 0x1F, 0x8C, 0xCE,
  0x76, 0x3F, 0x1B, 0x8D, 0x86, 0xC3, 0x63, 0xB1, 0x98, 0xCC, 0xC7, 0xE1,
  0xE0, 0x0E, 0x38, 0xF7, 0x65, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x83,
  0x06, 0x1C, 0x00, 0x07, 0x83, 0xF8, 0x23, 0x00, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0x8F, 0xE1, 0x1C, 0x07, 0x01, 0x80, 0xE1, 0xF0, 0x78, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x87, 0x3F, 0x8F, 0xC0, 0x01, 0xC0, 0xE0, 0x78, 0x16,
  0x0F, 0x86, 0xC1, 0x30, 0xCC, 0x63, 0x31, 0xCF, 0xFB, 0xFE, 0x06, 0x03,
  0x80, 0xE0, 0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x30, 0x0C, 0x03, 0xF0, 0xFC,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x87, 0x3F, 0x8F, 0xC0, 0x0F, 0x8F, 0xCE,
  0x06, 0x06, 0x03, 0x63, 0xF9, 0xEE, 0xE7, 0x63, 0xB1, 0xD8, 0xCC, 0xE7,
  0xE1, 0xE0, 0x7F, 0xDF, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x0F, 0x87, 0xF3,
  0x9C, 0xC7, 0x39, 0x8E, 0xE1, 0xF0, 0x78, 0x77, 0x18, 0xCE, 0x3B, 0x8E,
  0xE3, 0x1F, 0xC7, 0xE0, 0x0F, 0x0F, 0xCE, 0x66, 0x37, 0x1B, 0x8D, 0xCE,
  0xEF, 0x3F, 0x8D, 0x80, 0xC0, 0xE0, 0xE7, 0xE3, 0xE0, 0x11, 0xCE, 0x20,
  0x00, 0x00, 0x03, 0x39, 0xC0, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0x1C, 0x63, 0x8C, 0x00, 0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x80, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x3C, 0x78, 0xF0, 0x60,
  0x20, 0x00, 0x3C, 0xFD, 0x18, 0x30, 0x61, 0x86, 0x18, 0x70, 0xC0, 0x00,
  0x0C, 0x1C, 0x30, 0x00, 0x07, 0xE0, 0x73, 0x86, 0x06, 0x60, 0x36, 0x3C,
  0xB3, 0x67, 0x33, 0x39, 0x13, 0xD9, 0x9C, 0xCC, 0xE6, 0x6D, 0x3F, 0xCC,
  0xCC, 0x60, 0x01, 0x82, 0x0F, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x6C,
  0x1B, 0x0E, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCF, 0xF3, 0xFD, 0xC3, 0x60,
  0xF8, 0x3C, 0x0C, 0x1F, 0x83, 0xF8, 0x63, 0x8C, 0x73, 0x8C, 0x73, 0x8F,
  0xE1, 0xF8, 0x33, 0x8E, 0x31, 0xC7, 0x30, 0xC6, 0x39, 0xFE, 0x3F, 0x80,
  0x0F, 0xC7, 0xF3, 0x88, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE1, 0x1F, 0x83, 0xE0, 0x1F, 0x83, 0xF8, 0x63, 0x8C,
  0x73, 0x86, 0x70, 0xCC, 0x19, 0x87, 0x30, 0xEE, 0x19, 0xC7, 0x30, 0xE6,
  0x79, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0xF0, 0xFC, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xFC, 0x3F, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x00, 0x07, 0xE3, 0xFC, 0xF1, 0x1C, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x1E, 0xE7, 0xDC, 0x3B, 0x86, 0x70, 0xCE, 0x18,
  0xFF, 0x0F, 0xC0, 0x1C, 0x31, 0x83, 0x18, 0x71, 0x87, 0x38, 0x63, 0x86,
  0x3F, 0xE3, 0xFE, 0x30, 0xE7, 0x0C, 0x70, 0xC6, 0x1C, 0x61, 0xCE, 0x18,
  0xE1, 0x80, 0x1F, 0x87, 0x83, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x03, 0x83, 0xE3, 0xF0, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x7C, 0x3C, 0x00, 0x1C, 0x71, 0x8E, 0x18, 0xC1, 0x98, 0x3B,
  0x83, 0xF0, 0x36, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0x77, 0x06, 0x30, 0x63,
  0x06, 0x38, 0xE3, 0x80, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x06, 0x1F, 0xFF, 0x80, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0x36, 0x36, 0x3E, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0xEC,
  0x76, 0xCC, 0x66, 0xDC, 0x67, 0x98, 0x67, 0x98, 0x67, 0x18, 0xE7, 0x38,
  0x1C, 0x18, 0xE0, 0xC7, 0x8E, 0x3C, 0x63, 0xE3, 0x1B, 0x18, 0xDD, 0xC6,
  0x6C, 0x33, 0x63, 0x9B, 0x18, 0xD8, 0xC7, 0xC6, 0x1C, 0x70, 0xE3, 0x87,
  0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1B, 0x07, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x1F, 0x83,
  0xF8, 0x63, 0x8C, 0x73, 0x8E, 0x71, 0x8C, 0x71, 0xFC, 0x3F, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x98,
  0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x07, 0x70, 0xCE,
  0x38, 0xFE, 0x0F, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0x87,
  0xF1, 0x9C, 0x63, 0x38, 0xCE, 0x33, 0x1C, 0xFE, 0x3E, 0x1D, 0xC7, 0x71,
  0x8C, 0x63, 0x18, 0xEE, 0x38, 0x0F, 0xC7, 0xE3, 0x88, 0xC0, 0x30, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x87, 0x3F, 0x8F, 0xC0,
  0xFF, 0xFF, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xE0, 0xC0, 0x38, 0x66, 0x1C, 0xC3, 0x98, 0x67, 0x0C, 0xE1, 0x98,
  0x73, 0x0E, 0xE1, 0x9C, 0x33, 0x8E, 0x61, 0xCE, 0x71, 0xFE, 0x1F, 0x80,
  0xC1, 0xF0, 0x6C, 0x3B, 0x0C, 0xC7, 0x31, 0x8C, 0x63, 0x38, 0xCC, 0x37,
  0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0E, 0x00, 0xC3, 0x87, 0x87, 0x1F, 0x0E,
  0x36, 0x3C, 0x6C, 0x79, 0xD9, 0xB3, 0x33, 0x6E, 0x6E, 0xD8, 0xD9, 0xB1,
  0xB3, 0xC3, 0xC5, 0x87, 0x8F, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x60, 0x00,
  0x1C, 0x70, 0xC6, 0x0C, 0xE0, 0xCC, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x70,
  0x0F, 0x01, 0xF0, 0x1B, 0x03, 0xB8, 0x73, 0x86, 0x18, 0xE1, 0x80, 0xC3,
  0xF1, 0xB9, 0xDC, 0xC6, 0xE3, 0x61, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x80, 0x1F, 0xE3, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xFE, 0x3F,
  0xC0, 0x0F, 0x87, 0x83, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x78, 0x7C, 0x00, 0xCC, 0xE6,
  0x66, 0x66, 0x67, 0x33, 0x33, 0x30, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xF0,
  0x06, 0x01, 0x80, 0xF0, 0x6C, 0x1B, 0x0C, 0xE3, 0x19, 0x86, 0xE1, 0xC0,
  0xFF, 0xE6, 0x70, 0x08, 0x1E, 0xDF, 0xEC, 0x7E, 0x37, 0x1B, 0x0D, 0x8E,
  0xC7, 0x67, 0x3F, 0x9E, 0xC0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x3B, 0x0F,
  0xE3, 0xDC, 0xE7, 0x31, 0xDC, 0x77, 0x19, 0x86, 0x63, 0x98, 0xCF, 0xF3,
  0x78, 0x0C, 0x3F, 0x7A, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC4, 0xFC,
  0x7C, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x09, 0x8F, 0x67, 0x79, 0x8E, 0xE3,
  0x30, 0xCC, 0x33, 0x1C, 0xC7, 0x33, 0x8F, 0xE3, 0xD8, 0x0C, 0x3F, 0x73,
  0x63, 0xE7, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x01, 0xC0, 0xF0,
  0x70, 0x18, 0x06, 0x07, 0xE1, 0xF8, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x03, 0xC0, 0xE0, 0x00,
  0x04, 0x07, 0xB3, 0xFC, 0xC7, 0x71, 0x9C, 0x66, 0x19, 0x8E, 0x63, 0x99,
  0xC7, 0xF1, 0xEC, 0x07, 0x01, 0x88, 0xE3, 0xF0, 0xF8, 0x00, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x3B, 0x0F, 0xE3, 0xF8, 0xE7, 0x31, 0x9C, 0x67, 0x19,
  0x8E, 0x63, 0x98, 0xCE, 0x33, 0x9C, 0x08, 0x71, 0x80, 0x00, 0xE3, 0x0C,
  0x31, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x0C, 0x0E, 0x1E, 0x0F, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x73, 0x38, 0xDC, 0x36, 0x1F, 0x07, 0xE1, 0xF8, 0x66, 0x19, 0x8E,
  0x73, 0x1C, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x61,
  0x8E, 0x38, 0x03, 0x18, 0xDE, 0xF3, 0xFE, 0xCE, 0x73, 0x31, 0x8D, 0xC6,
  0x37, 0x38, 0xD8, 0xE7, 0x63, 0x19, 0x8C, 0x6E, 0x31, 0xB1, 0xCE, 0x03,
  0x0D, 0xE3, 0xF8, 0xE7, 0x31, 0x9C, 0x67, 0x19, 0x8E, 0x63, 0x98, 0xCE,
  0x33, 0x9C, 0x0C, 0x3E, 0x77, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xCE,
  0xFE, 0x78, 0x01, 0x83, 0x78, 0x7B, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x31,
  0x86, 0x31, 0xC6, 0x31, 0xFE, 0x3F, 0x86, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x00, 0x08, 0x1E, 0xDD, 0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x8E, 0xC7,
  0x67, 0x3F, 0x9E, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x03, 0x37,
  0x3E, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x0C, 0x3F,
  0x72, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x10, 0xC3,
  0x3F, 0xFD, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xF3, 0xC0, 0x71, 0xB1, 0xD8,
  0xCC, 0x6E, 0x37, 0x3B, 0x1D, 0x8C, 0xCE, 0x7F, 0x3D, 0x80, 0xE3, 0xF3,
  0xB9, 0x9C, 0xCE, 0xC3, 0x61, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xE7,
  0x1F, 0x39, 0xF3, 0xCD, 0x9E, 0x6C, 0xB6, 0x6D, 0xB3, 0x6F, 0x9E, 0x78,
  0xF3, 0xC7, 0x1C, 0x38, 0xE0, 0x18, 0xE3, 0x30, 0x7E, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x81, 0xF0, 0x37, 0x0E, 0x63, 0x8C, 0x00, 0x1C, 0x71, 0xC6,
  0x1C, 0xC0, 0xCC, 0x0D, 0x80, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x1F, 0x8F, 0xC1,
  0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3F, 0x3F, 0x80, 0x07, 0x87,
  0x83, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x70, 0x70, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0F, 0x0F, 0x1C,
  0x18, 0x18, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0x70, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 8, 2, -15 },
  { 18, 11, 15, 11, 0, -15 },
  { 39, 10, 17, 10, 0, -16 },
  { 61, 13, 15, 15, 1, -15 },
  { 86, 11, 15, 11, 0, -15 },
  { 107, 3, 5, 5, 2, -15 },
  { 109, 7, 18, 6, 0, -15 },
  { 125, 7, 18, 6, -2, -15 },
  { 141, 8, 9, 9, 2, -16 },
  { 150, 9, 10, 10, 1, -12 },
  { 162, 4, 6, 5, -1, -3 },
  { 165, 6, 2, 6, 0, -7 },
  { 167, 3, 3, 5, 0, -3 },
  { 169, 10, 15, 8, -1, -15 },
  { 188, 9, 15, 10, 1, -15 },
  { 205, 7, 15, 10, 2, -15 },
  { 219, 11, 15, 10, -1, -15 },
  { 240, 10, 15, 10, 0, -15 },
  { 259, 10, 15, 10, 0, -15 },
  { 278, 10, 15, 10, 0, -15 },
  { 297, 9, 15, 10, 1, -15 },
  { 314, 10, 15, 10, 1, -15 },
  { 333, 10, 15, 10, 0, -15 },
  { 352, 9, 15, 10, 0, -15 },
  { 369, 5, 12, 5, 0, -12 },
  { 377, 6, 15, 5, -1, -12 },
  { 389, 9, 11, 10, 1, -13 },
  { 402, 9, 6, 10, 1, -10 },
  { 409, 9, 11, 10, 1, -13 },
  { 422, 7, 15, 7, 1, -15 },
  { 436, 13, 17, 15, 1, -15 },
  { 464, 10, 15, 10, -1, -15 },
  { 483, 11, 15, 11, 0, -15 },
  { 504, 10, 15, 10, 1, -15 },
  { 523, 11, 15, 12, 0, -15 },
  { 544, 10, 15, 9, 0, -15 },
  { 563, 10, 15, 9, 0, -15 },
  { 582, 11, 15, 12, 1, -15 },
  { 603, 12, 15, 12, 0, -15 },
  { 626, 9, 15, 7, -1, -15 },
  { 643, 9, 19, 5, -3, -15 },
  { 665, 12, 15, 10, 0, -15 },
  { 688, 7, 15, 9, 0, -15 },
  { 702, 16, 15, 15, 0, -15 },
  { 732, 13, 15, 13, 0, -15 },
  { 757, 11, 15, 12, 1, -15 },
  { 778, 11, 15, 10, 0, -15 },
  { 799, 11, 19, 12, 1, -15 },
  { 826, 10, 15, 10, 0, -15 },
  { 845, 10, 15, 9, 0, -15 },
  { 864, 8, 15, 9, 2, -15 },
  { 879, 11, 15, 12, 1, -15 },
  { 900, 10, 15, 10, 2, -15 },
  { 919, 15, 15, 16, 2, -15 },
  { 948, 12, 15, 10, -1, -15 },
  { 971, 9, 15, 9, 2, -15 },
  { 988, 11, 15, 9, -1, -15 },
  { 1009, 9, 18, 6, -1, -15 },
  { 1030, 4, 15, 8, 2, -15 },
  { 1038, 8, 18, 6, -1, -15 },
  { 1056, 10, 9, 10, 0, -15 },
  { 1068, 8, 1, 7, -2, 2 },
  { 1069, 4, 3, 6, 3, -16 },
  { 1071, 9, 12, 10, 1, -12 },
  { 1085, 10, 16, 10, 0, -16 },
  { 1105, 8, 12, 8, 1, -12 },
  { 1117, 10, 16, 10, 1, -16 },
  { 1137, 8, 12, 9, 1, -12 },
  { 1149, 10, 21, 6, -2, -16 },
  { 1176, 10, 17, 10, 0, -12 },
  { 1198, 10, 16, 10, 0, -16 },
  { 1218, 6, 16, 5, 0, -16 },
  { 1230, 9, 21, 5, -3, -16 },
  { 1254, 10, 16, 9, 0, -16 },
  { 1274, 6, 16, 5, 0, -16 },
  { 1286, 14, 12, 15, 0, -12 },
  { 1307, 10, 12, 10, 0, -12 },
  { 1322, 8, 12, 10, 1, -12 },
  { 1334, 11, 17, 10, -1, -12 },
  { 1358, 9, 17, 10, 1, -12 },
  { 1378, 8, 12, 7, 0, -12 },
  { 1390, 8, 12, 8, 0, -12 },
  { 1402, 6, 14, 6, 1, -14 },
  { 1413, 9, 11, 10, 1, -11 },
  { 1426, 9, 11, 9, 1, -11 },
  { 1439, 13, 11, 13, 1, -11 },
  { 1457, 11, 11, 9, -1, -11 },
  { 1473, 12, 16, 9, -2, -11 },
  { 1497, 9, 11, 8, -1, -11 },
  { 1510, 9, 18, 7, 0, -15 },
  { 1531, 2, 21, 9, 3, -16 },
  { 1537, 8, 18, 7, -1, -15 },
  { 1555, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC21PT7B_H_
