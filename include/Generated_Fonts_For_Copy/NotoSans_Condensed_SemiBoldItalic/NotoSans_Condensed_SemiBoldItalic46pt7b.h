#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC46PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x00, 0x80, 0x00, 0x7E, 0x7E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0x9F, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xEE, 0xF0, 0x3E, 0x61, 0x03, 0xE3, 0x00, 0x1F, 0x18, 0x00,
  0xF9, 0xC0, 0x07, 0xEC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xDF, 0x80, 0x0C, 0xFC, 0x00, 0x63, 0xE0, 0x03, 0x3F,
  0x10, 0x19, 0xF0, 0xE1, 0xDF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xC0,
  0x7F, 0x80, 0x3C, 0x07, 0xFC, 0x03, 0xC0, 0x7D, 0xF0, 0x1E, 0x03, 0xC7,
  0x81, 0xE0, 0x3C, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x0F, 0x0F, 0x0F,
  0x00, 0xF0, 0x78, 0x78, 0x07, 0x87, 0x87, 0x80, 0x3C, 0x3C, 0x3C, 0x01,
  0xE1, 0xE3, 0xC0, 0x0F, 0x0F, 0x3C, 0x00, 0x78, 0xF1, 0xE3, 0xE3, 0x87,
  0x9E, 0x3F, 0x9E, 0x7C, 0xF3, 0xFE, 0xF7, 0xCF, 0x3F, 0xF7, 0xFC, 0xF3,
  0xE7, 0x9F, 0xC7, 0x9E, 0x1E, 0x7C, 0x78, 0xF0, 0xF0, 0x03, 0xCF, 0x0F,
  0x00, 0x3C, 0x78, 0x78, 0x03, 0xE3, 0xC3, 0xC0, 0x1E, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0xF0, 0x0F, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x78, 0x0F, 0x83,
  0xC3, 0xC0, 0x78, 0x1E, 0x3C, 0x07, 0x80, 0xFB, 0xE0, 0x3C, 0x03, 0xFE,
  0x03, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0x87, 0xFF, 0x0F, 0x87, 0xEF, 0x87, 0xC3, 0xE7, 0xE7, 0xC3, 0xE3,
  0xF3, 0xE3, 0xF0, 0xFB, 0xF1, 0xF0, 0x7F, 0xF0, 0xF8, 0x1F, 0xF0, 0xFC,
  0x0F, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFE, 0x07,
  0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xF9, 0xF8,
  0x1F, 0xF0, 0xFC, 0x00, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1,
  0xE3, 0xC7, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x60, 0xF0, 0x1E, 0x38, 0x07, 0xEE,
  0x1B, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xDE, 0x07, 0xE7, 0xC0, 0xF1, 0xF0, 0x18, 0x3E, 0x02,
  0x0E, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0xC7,
  0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0x84,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7,
  0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x7E,
  0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7,
  0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8,
  0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0xBF,
  0xBE, 0xFD, 0xF1, 0xE7, 0xC6, 0x1F, 0x08, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x0F,
  0x03, 0xF0, 0x18, 0x0F, 0xC0, 0x40, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3E, 0x3F, 0x81, 0x80, 0xFC, 0x08, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF1, 0x00, 0x3F, 0x0E, 0x07, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x07,
  0x9F, 0x00, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E,
  0x00, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF9, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x20,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF1, 0x00, 0x3F, 0x0F, 0x07, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC1, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x1F, 0x7F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xDF, 0xC3, 0xF8, 0x3E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0xC7, 0xC0, 0x7C,
  0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0x3E, 0x7E, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xF7,
  0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x8F,
  0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x0F,
  0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xEF, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03,
  0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0,
  0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0xFE, 0x3F, 0x3F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0x7C, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x81, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x80, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x78, 0x04,
  0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF,
  0x1C, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x07, 0xF8, 0x70,
  0xF0, 0x7F, 0xE1, 0xC7, 0x83, 0xFF, 0x87, 0x1E, 0x1F, 0x1E, 0x1C, 0xF0,
  0xF8, 0x78, 0x73, 0xC3, 0xC3, 0xC1, 0xCE, 0x1E, 0x0F, 0x0F, 0x78, 0x78,
  0x3C, 0x3D, 0xE1, 0xE0, 0xF0, 0xF7, 0x8F, 0x07, 0x83, 0x9E, 0x3C, 0x1E,
  0x0E, 0x70, 0xF0, 0x78, 0x79, 0xC3, 0xC3, 0xE1, 0xCF, 0x0F, 0x0F, 0x0F,
  0x3C, 0x3C, 0x7C, 0x38, 0xF0, 0xFB, 0xFB, 0xE3, 0xC3, 0xFE, 0xFF, 0x07,
  0x07, 0xF3, 0xF8, 0x1E, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x10, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F,
  0x87, 0xE3, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xEF, 0x80, 0xFE, 0x02, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x08, 0x07,
  0xF8, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x87, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F,
  0x81, 0xFC, 0x07, 0xC1, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xF7, 0xE0, 0x3F, 0xC0, 0x30, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0xF8, 0x7C, 0x0F, 0xFC, 0x7E, 0x07, 0xFE, 0x3F, 0x03, 0xFF, 0x1F,
  0x81, 0xFF, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x80, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x04, 0x7E, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07,
  0xDF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00,
  0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3D, 0xF0, 0x1F, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x7D, 0xF0, 0x0F,
  0x3C, 0x0F, 0xBE, 0x03, 0xE7, 0x83, 0xE7, 0xC0, 0x7C, 0xF0, 0x7D, 0xF0,
  0x0F, 0x9E, 0x0F, 0x3E, 0x01, 0xF3, 0xC3, 0xE7, 0xC0, 0x7C, 0x78, 0x78,
  0xF8, 0x0F, 0x8F, 0x1F, 0x1F, 0x01, 0xF1, 0xE3, 0xC7, 0xC0, 0x3E, 0x3C,
  0xF8, 0xF8, 0x07, 0xC7, 0x9E, 0x1F, 0x01, 0xF0, 0xF7, 0xC3, 0xE0, 0x3E,
  0x1F, 0xF0, 0xFC, 0x07, 0xC3, 0xFE, 0x1F, 0x00, 0xF8, 0x7F, 0x83, 0xE0,
  0x1E, 0x0F, 0xF0, 0x7C, 0x07, 0xC1, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0x83,
  0xF0, 0x1F, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x00, 0x7C, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x01, 0xFE, 0x00,
  0xF8, 0x0F, 0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x03, 0xFE, 0x03, 0xE0,
  0x3E, 0xF0, 0x1F, 0x01, 0xF7, 0xC0, 0xF0, 0x0F, 0xBE, 0x0F, 0x80, 0x7D,
  0xF0, 0x7C, 0x07, 0xCF, 0x83, 0xE0, 0x3E, 0x3E, 0x1F, 0x01, 0xF1, 0xF1,
  0xF0, 0x0F, 0x8F, 0x8F, 0x80, 0x7C, 0x7C, 0x7C, 0x07, 0xC1, 0xE3, 0xE0,
  0x3E, 0x0F, 0x9F, 0x01, 0xF0, 0x7D, 0xF0, 0x0F, 0x83, 0xEF, 0x80, 0x7C,
  0x1F, 0x7C, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F,
  0xF0, 0x0F, 0x80, 0xFF, 0x80, 0x78, 0x03, 0xFC, 0x07, 0xC0, 0x1F, 0xE0,
  0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0,
  0x3F, 0x07, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C,
  0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xCF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xF8,
  0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01,
  0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x08, 0x01, 0xF8, 0x30, 0x0F, 0xE0,
  0xFD, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E,
  0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3F,
  0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x00,
  0xFB, 0xE0, 0x1F, 0x80, 0x7E, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8,
  0x07, 0xCF, 0x80, 0xFE, 0x03, 0xE3, 0xE0, 0x3F, 0x80, 0xF8, 0xF8, 0x1F,
  0xE0, 0x7E, 0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x83, 0xFE, 0x07, 0xC3, 0xE0,
  0xF7, 0x83, 0xE0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3E, 0x1F, 0x78, 0x7E, 0x0F,
  0x87, 0x9E, 0x1F, 0x03, 0xE3, 0xE7, 0x87, 0xC0, 0xF8, 0xF9, 0xE3, 0xE0,
  0x3E, 0x3C, 0x78, 0xF8, 0x0F, 0x9F, 0x1E, 0x7E, 0x03, 0xE7, 0x87, 0x9F,
  0x00, 0xFB, 0xE1, 0xE7, 0xC0, 0x3E, 0xF0, 0x7B, 0xE0, 0x0F, 0xBC, 0x1E,
  0xF8, 0x03, 0xFF, 0x07, 0xBE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0x7C, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1,
  0xF0, 0x7C, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E,
  0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x3E, 0x00,
  0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3D, 0xF0,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7C, 0x3E,
  0x3E, 0x1E, 0x0F, 0x01, 0xFC, 0x78, 0x1F, 0xF7, 0xC1, 0xFF, 0xBE, 0x1F,
  0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xBE, 0x07, 0xF9, 0xE0, 0x1F, 0x8F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF3, 0xF8, 0x0F, 0xBF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC7,
  0xE1, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0,
  0x7E, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7B, 0xFF, 0x07,
  0xDF, 0xF0, 0x3C, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xE3, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x10, 0x7E, 0x1C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xF3, 0xE0, 0x1F, 0xF7,
  0xC0, 0x7F, 0xEF, 0x81, 0xFF, 0xFF, 0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x07,
  0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xFC,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xDE, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9,
  0xF0, 0x1E, 0x3E, 0x07, 0xCF, 0xC1, 0xF9, 0xF1, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x60, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC4, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x1E, 0x01, 0xFF, 0x7C, 0x07, 0xFE, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF9,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0xF8, 0x07, 0xFB, 0xE0, 0x07, 0xE7,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x30, 0x0F, 0xC0, 0x7C, 0x7F, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF3, 0xF8, 0x0F, 0xBF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC7,
  0xE1, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C,
  0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x00, 0x60, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF8, 0x3E, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xBE, 0x00,
  0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0x8F, 0xE1, 0xFC, 0x07, 0x9F, 0xF3, 0xFE, 0x07, 0xBF,
  0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0x81,
  0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x03,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x03,
  0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0x7C, 0x3E, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x0F,
  0xC0, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xFC, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0x8F, 0xE0, 0x3C, 0xFF, 0x81,
  0xEF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x03,
  0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x80,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC7,
  0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xF7, 0xE0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x87,
  0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x03, 0xCF, 0xF8, 0x07, 0xBF, 0xF0,
  0x0F, 0x7F, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x07, 0xC0, 0xFC, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFE, 0x1F,
  0x81, 0xFC, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xBF, 0xC0,
  0x3E, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x78, 0x1F, 0xF3, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xE1, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xBE, 0x07,
  0xFB, 0xE0, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xCF,
  0xC1, 0xE7, 0xE0, 0x7B, 0xF8, 0x1E, 0xFE, 0x0F, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x83, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE2, 0x01, 0xF8, 0xC0, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x0F, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03,
  0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F,
  0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xDE, 0x0F, 0xF9, 0xE0, 0x7F, 0x1E, 0x00, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F,
  0xBE, 0x0F, 0xE0, 0x7D, 0xF0, 0x7F, 0x07, 0xCF, 0x83, 0xF8, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE3, 0xE1, 0xFE, 0x1F, 0x1F, 0x1E, 0xF0, 0xF8, 0xF8, 0xF7,
  0x8F, 0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x79, 0xE7, 0xC1, 0xF3, 0xCF, 0x3E,
  0x0F, 0xBC, 0x79, 0xE0, 0x79, 0xE3, 0xDF, 0x03, 0xCF, 0x1E, 0xF8, 0x1E,
  0xF0, 0xF7, 0x80, 0xF7, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8,
  0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01,
  0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x9F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x0C, 0x00,
  0x17, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x80, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 34, 12, 0, -33 },
  { 57, 15, 12, 18, 5, -33 },
  { 80, 25, 33, 24, 0, -33 },
  { 184, 21, 38, 21, 0, -35 },
  { 284, 29, 33, 33, 3, -33 },
  { 404, 25, 33, 25, 0, -33 },
  { 508, 7, 12, 10, 5, -33 },
  { 519, 15, 40, 13, 1, -33 },
  { 594, 15, 40, 13, -3, -33 },
  { 669, 18, 19, 20, 4, -35 },
  { 712, 19, 22, 22, 2, -27 },
  { 765, 9, 12, 11, -2, -6 },
  { 779, 11, 5, 13, 1, -15 },
  { 786, 7, 7, 11, 0, -6 },
  { 793, 23, 33, 17, -2, -33 },
  { 888, 20, 33, 21, 1, -33 },
  { 971, 14, 33, 21, 5, -33 },
  { 1029, 22, 33, 21, -1, -33 },
  { 1120, 21, 33, 21, 0, -33 },
  { 1207, 22, 33, 21, -1, -33 },
  { 1298, 21, 33, 21, 0, -33 },
  { 1385, 21, 33, 21, 1, -33 },
  { 1472, 21, 33, 21, 2, -33 },
  { 1559, 21, 33, 21, 0, -33 },
  { 1646, 20, 33, 21, 1, -33 },
  { 1729, 11, 26, 11, 0, -25 },
  { 1765, 13, 31, 11, -2, -25 },
  { 1816, 19, 23, 22, 2, -28 },
  { 1871, 19, 14, 22, 2, -23 },
  { 1905, 19, 23, 22, 2, -28 },
  { 1960, 16, 33, 16, 2, -33 },
  { 2026, 30, 37, 32, 1, -33 },
  { 2165, 23, 33, 23, -3, -33 },
  { 2260, 23, 33, 23, 0, -33 },
  { 2355, 23, 33, 22, 2, -33 },
  { 2450, 25, 33, 25, 0, -33 },
  { 2554, 22, 33, 20, 0, -33 },
  { 2645, 22, 33, 19, 0, -33 },
  { 2736, 25, 33, 26, 2, -33 },
  { 2840, 27, 33, 26, 0, -33 },
  { 2952, 20, 33, 14, -2, -33 },
  { 3035, 20, 42, 12, -7, -33 },
  { 3140, 26, 33, 22, 0, -33 },
  { 3248, 16, 33, 19, 0, -33 },
  { 3314, 35, 33, 34, 0, -33 },
  { 3459, 29, 33, 28, 0, -33 },
  { 3579, 24, 33, 27, 2, -33 },
  { 3678, 23, 33, 22, 0, -33 },
  { 3773, 24, 41, 27, 2, -33 },
  { 3896, 23, 33, 23, 0, -33 },
  { 3991, 22, 33, 20, 0, -33 },
  { 4082, 19, 33, 19, 4, -33 },
  { 4161, 25, 33, 26, 2, -33 },
  { 4265, 22, 33, 22, 4, -33 },
  { 4356, 34, 33, 34, 4, -33 },
  { 4497, 28, 33, 21, -3, -33 },
  { 4613, 20, 33, 20, 4, -33 },
  { 4696, 24, 33, 19, -2, -33 },
  { 4795, 18, 40, 13, -1, -33 },
  { 4885, 9, 33, 17, 5, -33 },
  { 4923, 18, 40, 13, -3, -33 },
  { 5013, 21, 20, 21, 0, -33 },
  { 5066, 16, 3, 16, -4, 4 },
  { 5072, 8, 7, 13, 7, -35 },
  { 5079, 21, 25, 22, 1, -25 },
  { 5145, 21, 35, 22, 0, -35 },
  { 5237, 18, 25, 18, 1, -25 },
  { 5294, 23, 35, 23, 1, -35 },
  { 5395, 19, 25, 20, 1, -25 },
  { 5455, 24, 46, 13, -5, -35 },
  { 5593, 23, 36, 23, -1, -25 },
  { 5697, 21, 35, 22, 0, -35 },
  { 5789, 12, 35, 11, 0, -35 },
  { 5842, 19, 46, 11, -6, -35 },
  { 5952, 23, 35, 20, 0, -35 },
  { 6053, 13, 35, 11, 0, -35 },
  { 6110, 32, 25, 33, 0, -25 },
  { 6210, 21, 25, 22, 0, -25 },
  { 6276, 20, 25, 22, 1, -25 },
  { 6339, 23, 36, 22, -2, -25 },
  { 6443, 21, 36, 22, 1, -25 },
  { 6538, 18, 25, 16, 0, -25 },
  { 6595, 18, 25, 17, 0, -25 },
  { 6652, 13, 30, 14, 2, -30 },
  { 6701, 20, 25, 22, 2, -25 },
  { 6764, 18, 25, 19, 3, -25 },
  { 6821, 29, 25, 29, 3, -25 },
  { 6912, 23, 25, 19, -2, -25 },
  { 6984, 25, 36, 19, -4, -25 },
  { 7097, 19, 25, 17, -1, -25 },
  { 7157, 18, 40, 16, 1, -33 },
  { 7247, 5, 46, 20, 7, -35 },
  { 7276, 18, 40, 16, -3, -33 },
  { 7366, 20, 7, 22, 2, -20 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC46PT7B_H_
