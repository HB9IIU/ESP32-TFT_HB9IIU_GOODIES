#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x44, 0x0C, 0xC0, 0x5A, 0xB4, 0x16, 0x29, 0xF9, 0x42,
  0x9F, 0x96, 0x28, 0xD0, 0x08, 0xF7, 0x5C, 0x70, 0xE2, 0xAA, 0xF8, 0x82,
  0x00, 0x62, 0xA4, 0xA8, 0xAA, 0xF5, 0x1D, 0x29, 0x6A, 0xCE, 0x3C, 0x58,
  0xA1, 0xC7, 0x6B, 0xB7, 0x6E, 0x7C, 0x5C, 0x19, 0x18, 0x84, 0x23, 0x18,
  0xC6, 0x10, 0x31, 0x11, 0x11, 0x32, 0x24, 0xC0, 0x35, 0x1E, 0xED, 0x00,
  0x21, 0x09, 0xF2, 0x10, 0x80, 0x2D, 0x60, 0xF0, 0xF0, 0x06, 0x18, 0x20,
  0xC1, 0x06, 0x08, 0x30, 0xC0, 0x3C, 0xB6, 0xD3, 0x4F, 0x2C, 0xB6, 0x70,
  0x37, 0xF3, 0x22, 0x26, 0x60, 0x3D, 0x30, 0xC2, 0x18, 0xC6, 0x30, 0xF8,
  0x7D, 0x30, 0xC6, 0x30, 0x20, 0xA6, 0xF0, 0x0C, 0x73, 0x8A, 0x4B, 0x6F,
  0xC4, 0x10, 0x3C, 0x86, 0x1C, 0x58, 0x20, 0xA6, 0xF0, 0x1C, 0x86, 0x16,
  0x6B, 0x3C, 0x96, 0x70, 0x7E, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0xC0,
  0x3D, 0x96, 0xCE, 0x73, 0x2C, 0xB2, 0x70, 0x3D, 0xB4, 0xD3, 0x7C, 0xA1,
  0x84, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64, 0xC0, 0x08, 0xD9,
  0x87, 0x0C, 0xF8, 0x3E, 0x86, 0x0C, 0x37, 0x60, 0x78, 0x46, 0x22, 0x30,
  0x08, 0xC0, 0x1F, 0x10, 0x5B, 0xAA, 0x55, 0x4E, 0xAA, 0x75, 0xA4, 0x40,
  0x1E, 0x00, 0x0C, 0x18, 0x70, 0xA3, 0x47, 0x99, 0xA3, 0xC6, 0x3C, 0x4D,
  0x93, 0x67, 0x89, 0x93, 0x66, 0xF8, 0x3D, 0x8C, 0x30, 0x82, 0x08, 0x34,
  0xF0, 0x3C, 0x4D, 0x9B, 0x36, 0x68, 0xD3, 0x6C, 0xF0, 0x3C, 0x86, 0x18,
  0x79, 0x04, 0x30, 0xF0, 0x3C, 0x86, 0x18, 0x79, 0x04, 0x30, 0xC0, 0x3E,
  0xC3, 0x06, 0x09, 0xD1, 0xA2, 0x64, 0x78, 0x33, 0x22, 0x62, 0x7E, 0x7E,
  0x44, 0x44, 0xCC, 0xCC, 0x3C, 0x61, 0x04, 0x30, 0xC3, 0x08, 0xF0, 0x0C,
  0x20, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xCE, 0x30, 0x36, 0x59, 0xA3, 0xC7,
  0x0B, 0x16, 0x64, 0xCC, 0x32, 0x66, 0x64, 0x4C, 0xF0, 0x31, 0xCC, 0x67,
  0x39, 0xCA, 0x57, 0x95, 0x65, 0x53, 0x64, 0xDB, 0x00, 0x31, 0x33, 0x73,
  0x7A, 0x5A, 0x4A, 0x4E, 0xCC, 0xCC, 0x3D, 0x9C, 0x71, 0x86, 0x38, 0xF6,
  0xF0, 0x3C, 0x4D, 0x9B, 0x27, 0xCE, 0x10, 0x60, 0xC0, 0x3D, 0x9C, 0x71,
  0x86, 0x38, 0xF6, 0xF0, 0xC1, 0x80, 0x3C, 0x96, 0x5B, 0x79, 0x65, 0xB2,
  0xCC, 0x3D, 0x86, 0x18, 0x30, 0x61, 0xA6, 0xF0, 0xF9, 0x08, 0xC6, 0x21,
  0x18, 0xC0, 0x66, 0x8B, 0x36, 0x6C, 0xD1, 0x22, 0x4C, 0xF0, 0xCF, 0x3C,
  0xB6, 0xD3, 0xCE, 0x38, 0xC0, 0xCC, 0xF3, 0x2D, 0xDB, 0x74, 0xFF, 0x2B,
  0x8A, 0xA3, 0x38, 0xCC, 0x00, 0x33, 0x16, 0x14, 0x1C, 0x18, 0x18, 0x2C,
  0x6C, 0xC4, 0xCF, 0x65, 0x1C, 0x61, 0x84, 0x10, 0xC0, 0x7C, 0x31, 0x84,
  0x31, 0x84, 0x30, 0xF8, 0x39, 0x18, 0xC4, 0x21, 0x18, 0xC4, 0x38, 0xC9,
  0x24, 0x9B, 0x20, 0x38, 0xC6, 0x21, 0x08, 0xC6, 0x21, 0x38, 0x18, 0xE2,
  0x92, 0xCC, 0xF0, 0xD0, 0x3D, 0xB4, 0xD3, 0xCB, 0x66, 0x80, 0x30, 0x82,
  0x1F, 0x6D, 0x34, 0xD3, 0xDA, 0xC0, 0x3B, 0x11, 0x8C, 0x65, 0xC0, 0x06,
  0x0C, 0x11, 0xE6, 0xC9, 0x93, 0x64, 0xD8, 0xD0, 0x39, 0xB4, 0xBC, 0xC3,
  0x27, 0x80, 0x06, 0x18, 0x20, 0xE1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x0E, 0x00, 0x3D, 0xB4, 0xD3, 0xCB, 0x67, 0x86, 0x93, 0xC0, 0x30, 0x82,
  0x1F, 0x6D, 0xB4, 0xD2, 0xCB, 0x60, 0x32, 0x06, 0x64, 0x44, 0xCC, 0x0C,
  0x20, 0x06, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0xE0, 0x30, 0x82, 0x1B,
  0x69, 0x47, 0x14, 0xDB, 0x60, 0x32, 0x26, 0x64, 0x44, 0xCC, 0x7F, 0xB6,
  0xD3, 0x69, 0x34, 0x96, 0x4B, 0x6C, 0x7D, 0xB6, 0xD3, 0x4B, 0x2D, 0x80,
  0x39, 0xB4, 0xF3, 0xCB, 0x67, 0x00, 0x3E, 0x6C, 0x99, 0x32, 0x6D, 0x9E,
  0x20, 0x41, 0x80, 0x3D, 0xB4, 0xD3, 0xCB, 0x66, 0x86, 0x10, 0x40, 0x7B,
  0x18, 0x84, 0x63, 0x00, 0x7A, 0x18, 0xE1, 0x5B, 0xC0, 0x22, 0x76, 0x64,
  0x4C, 0x60, 0x65, 0xB4, 0xD2, 0x4B, 0x66, 0x80, 0x9C, 0xAD, 0x4A, 0x63,
  0x00, 0x9B, 0xBA, 0xBE, 0xBC, 0xDC, 0xDC, 0xD8, 0x36, 0x78, 0x60, 0xC3,
  0x8D, 0x33, 0x00, 0x26, 0x48, 0xB1, 0x42, 0x86, 0x0C, 0x10, 0x61, 0x80,
  0x78, 0x8C, 0x44, 0x63, 0xC0, 0x19, 0x8C, 0x46, 0x61, 0x8C, 0x42, 0x18,
  0xFF, 0xF8, 0x30, 0xC4, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0x4F, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 3, 5, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 8, 9, 9, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 5, 11, 4, 0, -9 },
  { 50, 4, 11, 4, -1, -9 },
  { 56, 5, 5, 6, 1, -10 },
  { 60, 5, 7, 6, 1, -8 },
  { 65, 3, 4, 3, -1, -2 },
  { 67, 4, 1, 4, 0, -4 },
  { 68, 2, 2, 3, 0, -2 },
  { 69, 7, 9, 5, -1, -9 },
  { 77, 6, 9, 6, 0, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 6, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 6, 9, 6, 0, -9 },
  { 124, 7, 9, 6, 0, -9 },
  { 132, 6, 9, 6, 0, -9 },
  { 139, 6, 9, 6, 0, -9 },
  { 146, 3, 7, 3, 0, -7 },
  { 149, 4, 9, 3, -1, -7 },
  { 154, 5, 6, 6, 1, -8 },
  { 158, 5, 3, 6, 1, -6 },
  { 160, 5, 6, 6, 1, -8 },
  { 164, 5, 9, 5, 0, -9 },
  { 170, 9, 10, 9, 0, -9 },
  { 182, 7, 9, 6, -1, -9 },
  { 190, 7, 9, 7, 0, -9 },
  { 198, 6, 9, 6, 1, -9 },
  { 205, 7, 9, 7, 0, -9 },
  { 213, 6, 9, 6, 0, -9 },
  { 220, 6, 9, 5, 0, -9 },
  { 227, 7, 9, 7, 1, -9 },
  { 235, 8, 9, 7, 0, -9 },
  { 244, 6, 9, 4, -1, -9 },
  { 251, 6, 12, 3, -2, -9 },
  { 260, 7, 9, 6, 0, -9 },
  { 268, 4, 9, 5, 0, -9 },
  { 273, 10, 9, 10, 0, -9 },
  { 285, 8, 9, 8, 0, -9 },
  { 294, 6, 9, 8, 1, -9 },
  { 301, 7, 9, 6, 0, -9 },
  { 309, 6, 11, 8, 1, -9 },
  { 318, 6, 9, 6, 0, -9 },
  { 325, 6, 9, 6, 0, -9 },
  { 332, 5, 9, 5, 1, -9 },
  { 338, 7, 9, 7, 1, -9 },
  { 346, 6, 9, 6, 1, -9 },
  { 353, 10, 9, 10, 1, -9 },
  { 365, 8, 9, 6, -1, -9 },
  { 374, 6, 9, 6, 1, -9 },
  { 381, 6, 9, 5, 0, -9 },
  { 388, 5, 11, 4, 0, -9 },
  { 395, 3, 9, 5, 1, -9 },
  { 399, 5, 11, 4, -1, -9 },
  { 406, 6, 5, 6, 0, -9 },
  { 410, 4, 1, 4, -1, 1 },
  { 411, 2, 2, 4, 2, -10 },
  { 412, 6, 7, 6, 0, -7 },
  { 418, 6, 10, 6, 0, -10 },
  { 426, 5, 7, 5, 0, -7 },
  { 431, 7, 10, 6, 0, -10 },
  { 440, 6, 7, 6, 0, -7 },
  { 446, 7, 13, 4, -2, -10 },
  { 458, 6, 10, 6, 0, -7 },
  { 466, 6, 10, 6, 0, -10 },
  { 474, 4, 10, 3, 0, -10 },
  { 479, 6, 13, 3, -2, -10 },
  { 489, 6, 10, 6, 0, -10 },
  { 497, 4, 10, 3, 0, -10 },
  { 502, 9, 7, 9, 0, -7 },
  { 510, 6, 7, 6, 0, -7 },
  { 516, 6, 7, 6, 0, -7 },
  { 522, 7, 10, 6, -1, -7 },
  { 531, 6, 10, 6, 0, -7 },
  { 539, 5, 7, 4, 0, -7 },
  { 544, 5, 7, 5, 0, -7 },
  { 549, 4, 9, 4, 0, -9 },
  { 554, 6, 7, 6, 0, -7 },
  { 560, 5, 7, 5, 1, -7 },
  { 565, 8, 7, 8, 1, -7 },
  { 572, 7, 7, 5, -1, -7 },
  { 579, 7, 10, 5, -1, -7 },
  { 588, 5, 7, 5, 0, -7 },
  { 593, 5, 11, 4, 0, -9 },
  { 600, 1, 13, 6, 2, -10 },
  { 602, 5, 11, 4, -1, -9 },
  { 609, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC13PT7B_H_
