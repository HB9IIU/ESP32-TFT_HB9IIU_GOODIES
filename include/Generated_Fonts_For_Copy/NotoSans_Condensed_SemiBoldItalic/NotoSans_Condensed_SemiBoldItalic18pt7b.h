#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCC, 0x63, 0x18, 0x8C, 0x60, 0x11, 0xCC, 0x00, 0xEF, 0x6D,
  0xB6, 0x90, 0x0C, 0x83, 0x60, 0x90, 0x64, 0x7F, 0xC4, 0x81, 0x20, 0xDA,
  0xFF, 0x09, 0x06, 0xC1, 0xB0, 0x48, 0x00, 0x04, 0x04, 0x1F, 0x3F, 0x34,
  0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x96, 0xFE, 0xFC, 0x10, 0x20, 0x38, 0xCF,
  0x11, 0x26, 0x64, 0x8D, 0xB1, 0xBD, 0xFD, 0x7B, 0x69, 0x0B, 0x23, 0x64,
  0xCD, 0x99, 0xA6, 0x1C, 0x0E, 0x07, 0xC1, 0xB0, 0xCC, 0x1E, 0x07, 0x03,
  0xCD, 0xB6, 0x6D, 0xB1, 0xCC, 0x73, 0xFC, 0x7B, 0x80, 0xFB, 0x68, 0x0C,
  0x61, 0x8C, 0x31, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x18,
  0x60, 0x83, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8C, 0x31, 0x86, 0x30, 0x18,
  0x4D, 0x3F, 0x37, 0xED, 0x84, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0x10, 0x36, 0x6C, 0x7F, 0xC0, 0x5F, 0x00, 0x01, 0x81, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x0E, 0x1F,
  0x33, 0x33, 0x63, 0x63, 0x63, 0x63, 0x66, 0xC6, 0x6E, 0x7C, 0x78, 0x1C,
  0xE7, 0xB6, 0x98, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x60, 0x0F, 0x0F, 0xC4,
  0x60, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0xEF, 0xE0,
  0x1E, 0x3F, 0x23, 0x03, 0x03, 0x0E, 0x3C, 0x0E, 0x06, 0x06, 0x06, 0xFC,
  0xF8, 0x03, 0x07, 0x0F, 0x0B, 0x1E, 0x36, 0x26, 0x66, 0xC4, 0xFF, 0x0C,
  0x0C, 0x0C, 0x1F, 0x1F, 0x30, 0x30, 0x30, 0x3C, 0x7E, 0x06, 0x06, 0x06,
  0x06, 0xFC, 0xF8, 0x0F, 0x3E, 0x30, 0x60, 0x60, 0xDC, 0xEC, 0xC6, 0xC6,
  0xCC, 0xCC, 0xFC, 0x78, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x70, 0x60, 0xE0, 0xC0, 0x1E, 0x3F, 0x33, 0x33, 0x33, 0x3E, 0x3C,
  0x7E, 0xE6, 0xC6, 0xC6, 0xEE, 0x7C, 0x1E, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0x77, 0x3B, 0x06, 0x06, 0x0C, 0xFC, 0xF0, 0x33, 0x30, 0x00, 0x04, 0xEC,
  0x18, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x19, 0x80, 0x02, 0x0C, 0x7B, 0x8C,
  0x1E, 0x07, 0x03, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0x81, 0xC0,
  0xE0, 0x63, 0xDE, 0x70, 0x80, 0x79, 0xF0, 0xC3, 0x1C, 0xE3, 0x18, 0x40,
  0x00, 0x30, 0xC0, 0x07, 0x83, 0x98, 0xC1, 0xB1, 0x14, 0xFB, 0xB2, 0x64,
  0xCC, 0x9B, 0xB2, 0x72, 0xDA, 0x6E, 0x40, 0x0C, 0x00, 0xFC, 0x02, 0x00,
  0x03, 0x03, 0x81, 0x41, 0xA0, 0xD0, 0xC8, 0x66, 0x63, 0x3F, 0xB8, 0xD8,
  0x6C, 0x3C, 0x18, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0xF8, 0xF8, 0xC6,
  0x63, 0x31, 0x99, 0xDF, 0xCF, 0xC0, 0x0F, 0x9F, 0x8C, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0x87, 0xC0, 0x1E, 0x07, 0xE3,
  0x18, 0xC7, 0x31, 0xCC, 0x73, 0x19, 0x86, 0x61, 0x98, 0xC6, 0x73, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0x8C, 0x06, 0x03, 0x01, 0xF0, 0xF8, 0xC0, 0x60,
  0x30, 0x18, 0x1F, 0x8F, 0xC0, 0x1F, 0x8F, 0x8C, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0xFC, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x00, 0x0F, 0x9F, 0xCC, 0x2C,
  0x06, 0x06, 0x03, 0x1F, 0x9E, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xE0, 0x18,
  0xE3, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x7F, 0x0F, 0xE3, 0x0C, 0x61, 0x8C,
  0x31, 0x8C, 0x71, 0x8C, 0x30, 0x1F, 0x1E, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0xF0, 0xE0, 0x18,
  0xC6, 0x63, 0x38, 0xCC, 0x36, 0x0F, 0x03, 0xC1, 0xF0, 0x6E, 0x19, 0x86,
  0x63, 0x98, 0xC7, 0x00, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86,
  0x3F, 0xFC, 0x1C, 0x3C, 0x70, 0xE3, 0xC3, 0x8F, 0x1E, 0x3C, 0x58, 0xF3,
  0xC2, 0xCB, 0x1B, 0x6C, 0x6D, 0xB1, 0xBC, 0xC6, 0xF6, 0x33, 0x98, 0xC6,
  0x60, 0x18, 0x63, 0x8C, 0xF1, 0x9E, 0x33, 0xCC, 0x69, 0x89, 0xB3, 0x36,
  0x66, 0x8C, 0xF1, 0x8E, 0x61, 0xCC, 0x38, 0x0F, 0x1F, 0xCC, 0x6C, 0x36,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xDF, 0xC7, 0xC0, 0x1F, 0x0F,
  0xCC, 0x66, 0x33, 0x19, 0x9C, 0xFC, 0xFC, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x00, 0x0F, 0x1F, 0xCC, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1,
  0xB1, 0xDF, 0xC7, 0xC0, 0xE0, 0x30, 0x1C, 0x1E, 0x0F, 0x8C, 0x66, 0x33,
  0x19, 0x98, 0xFC, 0xF8, 0x6C, 0x33, 0x19, 0x9C, 0xCC, 0x70, 0x1F, 0x3F,
  0x31, 0x30, 0x30, 0x38, 0x1C, 0x0E, 0x0E, 0x06, 0x8E, 0xFC, 0xF8, 0x7F,
  0xFF, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x31, 0x98, 0xD8, 0x6C, 0x36, 0x3B, 0x1B, 0x8D, 0x86, 0xC3, 0x63, 0x31,
  0x9F, 0xC7, 0xC0, 0xC3, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0xC6, 0x1E, 0x31, 0xB3, 0x8D, 0x9C, 0xEC, 0xE6,
  0x6F, 0x32, 0x5B, 0x16, 0xD8, 0xB6, 0x85, 0x3C, 0x39, 0xE1, 0x8E, 0x0C,
  0x70, 0x00, 0x18, 0xE3, 0x18, 0x66, 0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x06, 0xC0, 0xCC, 0x31, 0x8C, 0x30, 0xC7, 0xC6, 0xCC, 0xCC,
  0xD8, 0xF0, 0x70, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x1F, 0xC7, 0xE0,
  0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0x0E, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x78, 0xF0, 0xDB, 0x6C, 0x9B, 0x6D, 0xB6, 0x1E,
  0x3C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x3C,
  0x78, 0x04, 0x0C, 0x1E, 0x16, 0x36, 0x22, 0x63, 0xC3, 0xFE, 0xD9, 0x80,
  0x1D, 0x9F, 0x8C, 0xCC, 0x66, 0x33, 0x19, 0x99, 0xCC, 0x7E, 0x3B, 0x00,
  0x18, 0x18, 0x38, 0x30, 0x36, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x63, 0x66,
  0xFE, 0xDC, 0x3D, 0xF6, 0x30, 0xC3, 0x0C, 0x30, 0xFB, 0xE0, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x1D, 0x8F, 0xC3, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x63,
  0x98, 0x7E, 0x1D, 0x80, 0x3C, 0xFD, 0x9E, 0x3F, 0xDE, 0x30, 0x60, 0xC8,
  0xF0, 0x03, 0x83, 0xC1, 0x80, 0xC0, 0xF0, 0xF8, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0xF0, 0x70, 0x00, 0x1D, 0x9F,
  0x8C, 0xCC, 0x66, 0x33, 0x19, 0x99, 0xCC, 0x7E, 0x3B, 0x01, 0x81, 0x89,
  0xC7, 0xC0, 0x18, 0x18, 0x38, 0x30, 0x36, 0x3F, 0x33, 0x73, 0x63, 0x63,
  0x66, 0x66, 0xC6, 0xC6, 0x10, 0xC4, 0x03, 0x18, 0xCC, 0x63, 0x18, 0xCC,
  0x60, 0x04, 0x0C, 0x10, 0x00, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0xE1, 0xC0, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x39, 0x98,
  0xD8, 0xD8, 0x78, 0x3E, 0x1B, 0x0D, 0x8C, 0xE6, 0x30, 0x18, 0xC6, 0x63,
  0x18, 0xCC, 0x63, 0x18, 0xCC, 0x60, 0x36, 0x73, 0xFF, 0x33, 0x37, 0x33,
  0x63, 0x36, 0x63, 0x66, 0x36, 0x66, 0xC6, 0x6C, 0x66, 0x36, 0x3F, 0x33,
  0x73, 0x63, 0x63, 0x66, 0x66, 0xC6, 0xC6, 0x3C, 0xFD, 0x9E, 0x3C, 0x78,
  0xF3, 0xE6, 0xFC, 0xF0, 0x1B, 0x0F, 0xC6, 0x67, 0x33, 0x19, 0x8C, 0xC6,
  0x66, 0x7F, 0x37, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x1D, 0x9F, 0x8C, 0xCC,
  0x66, 0x33, 0x19, 0x99, 0xCC, 0x7E, 0x3B, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x36, 0x7C, 0xE3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x80, 0x3C, 0xFD, 0x83,
  0x07, 0x07, 0x07, 0x06, 0xF9, 0xF0, 0x31, 0x1F, 0xF6, 0x33, 0x18, 0xC6,
  0x39, 0xC0, 0x63, 0x66, 0x66, 0xC6, 0xC6, 0xC6, 0xCC, 0xCC, 0xFC, 0xEC,
  0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x3C, 0x78, 0xE0, 0xC0, 0xC6, 0x79, 0xCF,
  0x39, 0x6F, 0x6D, 0xED, 0xAF, 0x3D, 0xE7, 0x38, 0xE7, 0x1C, 0xC0, 0x31,
  0x8D, 0x86, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x6C, 0x66, 0x73, 0x00, 0x31,
  0x98, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0x50, 0x38, 0x18, 0x0C, 0x06, 0x06,
  0x0F, 0x07, 0x00, 0x1F, 0x3F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x7C,
  0xFC, 0x06, 0x1C, 0x60, 0xC1, 0x83, 0x0C, 0x78, 0xE0, 0x60, 0xC3, 0x06,
  0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x38, 0x30, 0x60,
  0xC3, 0x06, 0x07, 0x1E, 0x30, 0xC1, 0x83, 0x06, 0x38, 0x60, 0x63, 0xFE,
  0x78,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 10, 13, 9, 0, -13 },
  { 31, 8, 15, 8, 0, -14 },
  { 46, 11, 13, 13, 1, -13 },
  { 64, 10, 13, 10, 0, -13 },
  { 81, 3, 5, 4, 2, -13 },
  { 83, 6, 16, 5, 0, -13 },
  { 95, 6, 16, 5, -1, -13 },
  { 107, 6, 8, 8, 2, -14 },
  { 113, 7, 9, 9, 1, -11 },
  { 121, 4, 4, 4, -1, -2 },
  { 123, 5, 2, 5, 0, -6 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 9, 13, 7, -1, -13 },
  { 142, 8, 13, 8, 0, -13 },
  { 155, 6, 13, 8, 2, -13 },
  { 165, 9, 13, 8, -1, -13 },
  { 180, 8, 13, 8, 0, -13 },
  { 193, 8, 13, 8, 0, -13 },
  { 206, 8, 13, 8, 0, -13 },
  { 219, 8, 13, 8, 1, -13 },
  { 232, 8, 13, 8, 1, -13 },
  { 245, 8, 13, 8, 0, -13 },
  { 258, 8, 13, 8, 0, -13 },
  { 271, 4, 10, 4, 0, -10 },
  { 276, 5, 12, 4, -1, -10 },
  { 284, 7, 9, 9, 1, -11 },
  { 292, 7, 5, 9, 1, -9 },
  { 297, 7, 9, 9, 1, -11 },
  { 305, 6, 13, 6, 1, -13 },
  { 315, 11, 15, 12, 1, -13 },
  { 336, 9, 13, 9, -1, -13 },
  { 351, 9, 13, 9, 0, -13 },
  { 366, 9, 13, 9, 1, -13 },
  { 381, 10, 13, 10, 0, -13 },
  { 398, 9, 13, 8, 0, -13 },
  { 413, 9, 13, 7, 0, -13 },
  { 428, 9, 13, 10, 1, -13 },
  { 443, 11, 13, 10, 0, -13 },
  { 461, 8, 13, 6, -1, -13 },
  { 474, 8, 17, 5, -3, -13 },
  { 491, 10, 13, 9, 0, -13 },
  { 508, 6, 13, 7, 0, -13 },
  { 518, 14, 13, 13, 0, -13 },
  { 541, 11, 13, 11, 0, -13 },
  { 559, 9, 13, 11, 1, -13 },
  { 574, 9, 13, 9, 0, -13 },
  { 589, 9, 16, 11, 1, -13 },
  { 607, 9, 13, 9, 0, -13 },
  { 622, 8, 13, 8, 0, -13 },
  { 635, 8, 13, 8, 1, -13 },
  { 648, 9, 13, 10, 1, -13 },
  { 663, 8, 13, 9, 2, -13 },
  { 676, 13, 13, 13, 2, -13 },
  { 698, 11, 13, 8, -1, -13 },
  { 716, 8, 13, 8, 2, -13 },
  { 729, 10, 13, 8, -1, -13 },
  { 746, 8, 16, 5, -1, -13 },
  { 762, 3, 13, 7, 2, -13 },
  { 767, 7, 16, 5, -1, -13 },
  { 781, 8, 8, 8, 0, -13 },
  { 789, 7, 1, 6, -2, 2 },
  { 790, 3, 3, 5, 3, -14 },
  { 792, 9, 10, 9, 0, -10 },
  { 804, 8, 14, 9, 0, -14 },
  { 818, 6, 10, 7, 1, -10 },
  { 826, 10, 14, 9, 0, -14 },
  { 844, 7, 10, 8, 1, -10 },
  { 853, 9, 18, 5, -2, -14 },
  { 874, 9, 14, 9, 0, -10 },
  { 890, 8, 14, 9, 0, -14 },
  { 904, 5, 14, 4, 0, -14 },
  { 913, 7, 18, 4, -2, -14 },
  { 929, 9, 14, 8, 0, -14 },
  { 945, 5, 14, 4, 0, -14 },
  { 954, 12, 10, 13, 0, -10 },
  { 969, 8, 10, 9, 0, -10 },
  { 979, 7, 10, 9, 1, -10 },
  { 988, 9, 14, 9, -1, -10 },
  { 1004, 9, 14, 9, 0, -10 },
  { 1020, 7, 10, 6, 0, -10 },
  { 1029, 7, 10, 7, 0, -10 },
  { 1038, 5, 12, 5, 1, -12 },
  { 1046, 8, 10, 9, 1, -10 },
  { 1056, 7, 10, 7, 1, -10 },
  { 1065, 11, 10, 12, 1, -10 },
  { 1079, 9, 10, 8, -1, -10 },
  { 1091, 9, 14, 7, -1, -10 },
  { 1107, 8, 10, 7, -1, -10 },
  { 1117, 7, 16, 6, 0, -13 },
  { 1131, 2, 18, 8, 3, -14 },
  { 1136, 7, 16, 6, -1, -13 },
  { 1150, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC18PT7B_H_
