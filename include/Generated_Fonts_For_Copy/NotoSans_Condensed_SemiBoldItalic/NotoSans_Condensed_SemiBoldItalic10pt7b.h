#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xF4, 0x29, 0x5E, 0xAF, 0xB2, 0x80, 0x11, 0xDA,
  0xC3, 0x1A, 0xC8, 0x40, 0xCB, 0x4D, 0x3F, 0x35, 0x59, 0x80, 0x32, 0x9C,
  0xDB, 0xCB, 0xE0, 0xE0, 0x34, 0x44, 0x88, 0x88, 0x40, 0x23, 0x12, 0x22,
  0x24, 0x80, 0x2C, 0x7A, 0x21, 0x3E, 0x42, 0x00, 0xE0, 0xE0, 0xC0, 0x0C,
  0x21, 0x0C, 0x21, 0x0C, 0x00, 0x32, 0xD5, 0xA9, 0x49, 0x80, 0x7D, 0xA4,
  0x90, 0x70, 0xC4, 0x66, 0x63, 0xC0, 0x70, 0xC4, 0xC1, 0x0B, 0x80, 0x19,
  0x94, 0xAB, 0x30, 0x80, 0x7A, 0x10, 0xE1, 0x0B, 0x80, 0x3A, 0x1D, 0xAD,
  0x49, 0x80, 0x78, 0x84, 0x42, 0x23, 0x00, 0x72, 0x54, 0xC9, 0x4B, 0x80,
  0x72, 0xD4, 0xE1, 0x1B, 0x80, 0x50, 0x20, 0x24, 0x02, 0xB0, 0x09, 0xB0,
  0x60, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0xC8, 0x00, 0x71, 0x24, 0x40, 0xC0,
  0x3C, 0x85, 0x6D, 0x5A, 0xD7, 0x90, 0x3C, 0x18, 0xCA, 0x53, 0xA7, 0x20,
  0x7A, 0x52, 0xE5, 0xEB, 0xC0, 0x3B, 0x10, 0x8C, 0x21, 0xC0, 0x7A, 0x52,
  0x94, 0xEB, 0x80, 0x7A, 0x10, 0xE4, 0x63, 0x80, 0x7A, 0x10, 0xE4, 0x62,
  0x00, 0x3D, 0x84, 0x16, 0xC9, 0x27, 0x80, 0x65, 0x34, 0x9E, 0x4B, 0x29,
  0x00, 0x72, 0x44, 0x44, 0xC0, 0x18, 0x84, 0x21, 0x18, 0x84, 0xE0, 0x6D,
  0x65, 0x18, 0x73, 0x49, 0x00, 0x69, 0x25, 0xB8, 0x63, 0x66, 0x66, 0x6A,
  0x6E, 0xB4, 0xB4, 0x65, 0x96, 0x56, 0x5A, 0x69, 0x80, 0x39, 0xB4, 0xD3,
  0xC9, 0x27, 0x00, 0x7A, 0x52, 0xE4, 0x62, 0x00, 0x39, 0xB4, 0xD3, 0xC9,
  0x27, 0x04, 0x10, 0x7A, 0x52, 0xE7, 0x6A, 0x40, 0x7A, 0x10, 0x43, 0x0B,
  0x80, 0xF4, 0x44, 0xC8, 0x80, 0x65, 0x24, 0x92, 0x4B, 0x67, 0x00, 0x9C,
  0xA9, 0x4E, 0x63, 0x00, 0x93, 0x6E, 0xD5, 0xAD, 0x9B, 0x26, 0x00, 0x24,
  0xE1, 0x84, 0x31, 0xEC, 0x80, 0x9A, 0xAC, 0x48, 0x80, 0x78, 0x88, 0x44,
  0x63, 0xC0, 0x74, 0x44, 0x48, 0x88, 0xC0, 0xA9, 0x54, 0x31, 0x12, 0x22,
  0x22, 0xC0, 0x21, 0x95, 0x30, 0xF0, 0xD0, 0x23, 0xD5, 0xA9, 0x78, 0x23,
  0x14, 0xF5, 0xAB, 0x5C, 0x27, 0x4C, 0x86, 0x08, 0x4A, 0xB5, 0x6A, 0x4E,
  0x25, 0x5E, 0x86, 0x18, 0x88, 0xE2, 0x11, 0x88, 0x46, 0x00, 0x23, 0xD5,
  0xA9, 0x78, 0xDC, 0x23, 0x14, 0xF5, 0x2A, 0x52, 0x2C, 0x24, 0xA4, 0x13,
  0x02, 0x22, 0x44, 0x4C, 0x23, 0x12, 0xA6, 0x32, 0x92, 0x2D, 0x24, 0xA4,
  0x14, 0xF5, 0x4A, 0xB9, 0x52, 0x80, 0x13, 0xD4, 0xA9, 0x48, 0x25, 0x59,
  0x96, 0x13, 0xD6, 0xAD, 0x7A, 0x10, 0x22, 0xD5, 0xA9, 0x78, 0xC4, 0x17,
  0x44, 0x88, 0x25, 0x46, 0x2E, 0x2B, 0xA5, 0xB0, 0x4A, 0x95, 0x2F, 0x00,
  0xBA, 0xCC, 0x80, 0xAF, 0xAE, 0xAC, 0xB0, 0x5B, 0x18, 0xCB, 0x00, 0x2C,
  0xA3, 0x0C, 0x20, 0x8C, 0x00, 0x72, 0x4C, 0xE0, 0x32, 0x24, 0xC4, 0x44,
  0x40, 0xFF, 0xC0, 0x31, 0x33, 0x32, 0x24, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 7, 1, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 2, 2, 2, 1, -7 },
  { 28, 4, 9, 3, 0, -7 },
  { 33, 4, 9, 3, -1, -7 },
  { 38, 4, 4, 4, 1, -8 },
  { 40, 5, 5, 5, 0, -6 },
  { 44, 2, 2, 2, 0, -1 },
  { 45, 3, 1, 3, 0, -3 },
  { 46, 2, 1, 2, 0, -1 },
  { 47, 6, 7, 4, -1, -7 },
  { 53, 5, 7, 5, 0, -7 },
  { 58, 3, 7, 5, 1, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 5, 7, 5, 0, -7 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 2, 6, 2, 0, -6 },
  { 103, 3, 7, 2, -1, -6 },
  { 106, 5, 5, 5, 0, -6 },
  { 110, 5, 3, 5, 0, -5 },
  { 112, 5, 5, 5, 0, -6 },
  { 116, 4, 7, 4, 0, -7 },
  { 120, 7, 8, 7, 0, -7 },
  { 127, 5, 7, 5, -1, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 5, 7, 4, 0, -7 },
  { 152, 5, 7, 4, 0, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 6, 7, 6, 0, -7 },
  { 169, 4, 7, 3, 0, -7 },
  { 173, 5, 9, 3, -2, -7 },
  { 179, 6, 7, 5, 0, -7 },
  { 185, 3, 7, 4, 0, -7 },
  { 188, 8, 7, 7, 0, -7 },
  { 195, 6, 7, 6, 0, -7 },
  { 201, 6, 7, 6, 0, -7 },
  { 207, 5, 7, 5, 0, -7 },
  { 212, 6, 9, 6, 0, -7 },
  { 219, 5, 7, 5, 0, -7 },
  { 224, 5, 7, 4, 0, -7 },
  { 229, 4, 7, 4, 1, -7 },
  { 233, 6, 7, 6, 0, -7 },
  { 239, 5, 7, 5, 1, -7 },
  { 244, 7, 7, 7, 1, -7 },
  { 251, 6, 7, 5, -1, -7 },
  { 257, 4, 7, 4, 1, -7 },
  { 261, 5, 7, 4, 0, -7 },
  { 266, 4, 9, 3, 0, -7 },
  { 271, 2, 7, 4, 1, -7 },
  { 273, 4, 9, 3, -1, -7 },
  { 278, 5, 4, 5, 0, -7 },
  { 281, 4, 1, 3, -1, 1 },
  { 282, 2, 2, 3, 1, -8 },
  { 283, 5, 6, 5, 0, -6 },
  { 287, 5, 8, 5, 0, -8 },
  { 292, 4, 6, 4, 0, -6 },
  { 295, 5, 8, 5, 0, -8 },
  { 300, 4, 6, 4, 0, -6 },
  { 303, 5, 10, 3, -1, -8 },
  { 310, 5, 8, 5, 0, -6 },
  { 315, 5, 8, 5, 0, -8 },
  { 320, 3, 8, 2, 0, -8 },
  { 323, 4, 10, 2, -1, -8 },
  { 328, 5, 8, 4, 0, -8 },
  { 333, 3, 8, 2, 0, -8 },
  { 336, 7, 6, 7, 0, -6 },
  { 342, 5, 6, 5, 0, -6 },
  { 346, 4, 6, 5, 0, -6 },
  { 349, 5, 8, 5, 0, -6 },
  { 354, 5, 8, 5, 0, -6 },
  { 359, 4, 6, 3, 0, -6 },
  { 362, 4, 6, 4, 0, -6 },
  { 365, 3, 7, 3, 0, -7 },
  { 368, 5, 5, 5, 0, -5 },
  { 372, 4, 5, 4, 1, -5 },
  { 375, 6, 5, 6, 1, -5 },
  { 379, 5, 5, 4, 0, -5 },
  { 383, 6, 7, 4, -1, -5 },
  { 389, 4, 5, 4, 0, -5 },
  { 392, 4, 9, 3, 0, -7 },
  { 397, 1, 10, 4, 2, -8 },
  { 399, 4, 9, 3, -1, -7 },
  { 404, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC10PT7B_H_
