#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x39, 0x80, 0xDE, 0xF7, 0x20,
  0x0D, 0x84, 0x86, 0xCF, 0xF7, 0xF8, 0xB0, 0xD9, 0xFE, 0x24, 0x36, 0x12,
  0x0B, 0x00, 0x04, 0x0C, 0x3F, 0x3A, 0x28, 0x38, 0x3C, 0x0E, 0x16, 0x16,
  0xDE, 0xFC, 0x20, 0x20, 0x78, 0xCB, 0x33, 0x64, 0x6D, 0x09, 0x61, 0x2B,
  0xBB, 0xD8, 0x5B, 0x1A, 0x46, 0x48, 0x8B, 0x31, 0xC0, 0x1E, 0x0D, 0x8C,
  0xC6, 0xC1, 0xC0, 0xC1, 0xF6, 0xDA, 0xCF, 0x63, 0x3F, 0xCF, 0x60, 0xFE,
  0x0C, 0x63, 0x0C, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x00,
  0x18, 0xC2, 0x10, 0x84, 0x63, 0x18, 0x8C, 0x66, 0x23, 0x00, 0x18, 0xB1,
  0xED, 0xF3, 0x8D, 0x8A, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08,
  0x36, 0x6C, 0xF8, 0xF8, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x18, 0x00, 0x1E, 0x3F, 0x33, 0x63, 0x63, 0x62,
  0x66, 0x46, 0xC6, 0xCC, 0x7C, 0x78, 0x1B, 0xFF, 0x63, 0x18, 0xC4, 0x63,
  0x18, 0xC0, 0x0F, 0x0D, 0xC4, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x1F, 0x9F, 0xC0, 0x3E, 0x37, 0x03, 0x03, 0x06, 0x3C, 0x3C, 0x06,
  0x06, 0x0E, 0xFC, 0xF8, 0x07, 0x06, 0x0E, 0x1E, 0x16, 0x26, 0x64, 0xCC,
  0xFE, 0x0C, 0x0C, 0x18, 0x1F, 0x3F, 0x30, 0x30, 0x28, 0x7C, 0x06, 0x06,
  0x06, 0x0E, 0xFC, 0xF8, 0x1E, 0x75, 0x83, 0x0D, 0x9F, 0xB3, 0x66, 0x8D,
  0x9B, 0xE7, 0x80, 0x7F, 0x7E, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0xC0, 0x1E, 0x33, 0x33, 0x33, 0x36, 0x1C, 0x7C, 0x66, 0xC6,
  0xC6, 0xEC, 0x78, 0x1E, 0x36, 0x63, 0x63, 0x67, 0x66, 0x7E, 0x36, 0x04,
  0x0C, 0xF8, 0xF0, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0xC0, 0x00, 0x00,
  0x0E, 0x63, 0x30, 0x02, 0x1C, 0xE7, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x81, 0xC0, 0xE0, 0x70, 0xEF, 0x38, 0x40, 0xF9, 0x70,
  0xC2, 0x18, 0xC6, 0x10, 0x80, 0x0C, 0x30, 0x0F, 0x86, 0x18, 0x81, 0x27,
  0xBD, 0xB7, 0x26, 0xE4, 0x95, 0x92, 0xB6, 0x93, 0x72, 0x00, 0x60, 0x07,
  0xE0, 0x07, 0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x33, 0x3F, 0x3F, 0x63, 0x63,
  0xC3, 0x1F, 0x1F, 0xCC, 0x66, 0x63, 0x31, 0xF1, 0x98, 0xC6, 0x63, 0x33,
  0x3F, 0x9F, 0x80, 0x1F, 0x3A, 0x70, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFC, 0x7C, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x19, 0x8D, 0x86, 0xC6,
  0x63, 0x33, 0x3F, 0x9F, 0x00, 0x1F, 0x3F, 0x30, 0x30, 0x30, 0x3E, 0x7C,
  0x60, 0x60, 0x60, 0xFC, 0xFC, 0x1F, 0x3F, 0x30, 0x30, 0x30, 0x3E, 0x7C,
  0x60, 0x60, 0x60, 0xC0, 0xC0, 0x1F, 0x9D, 0x9C, 0x0C, 0x0C, 0x06, 0x7B,
  0x3D, 0x86, 0xC6, 0x63, 0x3F, 0x8F, 0xC0, 0x18, 0xCC, 0x33, 0x18, 0xC6,
  0x31, 0x8F, 0xE7, 0xF9, 0x8C, 0x63, 0x18, 0xCC, 0x33, 0x1C, 0x1F, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38,
  0xF0, 0x19, 0xCC, 0xE3, 0x30, 0xD8, 0x3C, 0x0F, 0x07, 0xC1, 0xB0, 0x6C,
  0x19, 0x8C, 0x63, 0x18, 0x18, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x8F,
  0xFF, 0x18, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0xCF, 0x16, 0xD9, 0xB6,
  0x8D, 0xEC, 0x6F, 0x62, 0x73, 0x33, 0x99, 0x99, 0x80, 0x18, 0x67, 0x18,
  0xF3, 0x1E, 0x62, 0xCC, 0x59, 0x19, 0x63, 0x3C, 0x67, 0x88, 0xF3, 0x1C,
  0x61, 0x80, 0x1F, 0x1D, 0x98, 0xEC, 0x3C, 0x1E, 0x1F, 0x0D, 0x86, 0xC3,
  0x63, 0x3F, 0x8F, 0x00, 0x1F, 0x1F, 0x8C, 0x66, 0x33, 0x31, 0x39, 0xF8,
  0xF0, 0x60, 0x30, 0x30, 0x18, 0x00, 0x1F, 0x1D, 0x98, 0xEC, 0x3C, 0x1E,
  0x1F, 0x0D, 0x86, 0xC3, 0x63, 0x3F, 0x8F, 0x01, 0x80, 0x60, 0x30, 0x1E,
  0x3F, 0x33, 0x33, 0x33, 0x27, 0x7C, 0x6C, 0x6C, 0x66, 0xC6, 0xC6, 0x1F,
  0x3E, 0x30, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0C, 0xFC, 0xF8, 0x7F,
  0xFC, 0x61, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x31, 0xB0,
  0xD8, 0xCC, 0x66, 0x36, 0x1B, 0x19, 0x8C, 0xC6, 0x63, 0x3F, 0x0F, 0x00,
  0x87, 0x86, 0x8C, 0xCC, 0xCC, 0xD8, 0xD8, 0xF0, 0xF0, 0xA0, 0xE0, 0xC0,
  0x43, 0x1A, 0x39, 0x91, 0xCC, 0x9E, 0x64, 0xF6, 0x65, 0xB3, 0x6F, 0x1A,
  0x78, 0xF2, 0xC7, 0x9C, 0x38, 0xE1, 0xC6, 0x00, 0x18, 0xC6, 0x61, 0xB0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x36, 0x0D, 0x86, 0x63, 0x0C, 0xC7,
  0x9B, 0x76, 0xCF, 0x1E, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x00, 0x1F, 0x8F,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x38, 0x1F, 0x9F, 0xC0,
  0x0E, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0E,
  0x3C, 0x00, 0xDB, 0x6C, 0x92, 0x6D, 0xB0, 0x1C, 0x30, 0xC3, 0x08, 0x21,
  0x86, 0x18, 0x43, 0x0C, 0x33, 0xCE, 0x00, 0x0C, 0x0C, 0x1C, 0x36, 0x26,
  0x62, 0xC3, 0x7F, 0xF0, 0xEC, 0x80, 0x3F, 0x37, 0x63, 0x62, 0x66, 0x66,
  0xC6, 0x6E, 0x74, 0x18, 0x30, 0x30, 0x30, 0x3E, 0x33, 0x73, 0x63, 0x63,
  0x66, 0x66, 0xEC, 0xFC, 0x1E, 0x65, 0x83, 0x06, 0x08, 0x38, 0x3C, 0x78,
  0x01, 0x80, 0xC0, 0x60, 0x63, 0xF1, 0xB9, 0x8C, 0xC4, 0x66, 0x23, 0x31,
  0x8D, 0xC7, 0x40, 0x1E, 0x6D, 0x9B, 0x77, 0xC8, 0x30, 0x32, 0x7C, 0x03,
  0x83, 0x81, 0x01, 0x81, 0xF0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC1, 0xE0, 0xE0, 0x00, 0x3F, 0x37, 0x63, 0x62, 0x66,
  0x66, 0xC6, 0x7E, 0x74, 0x0C, 0x0C, 0xF8, 0xF0, 0x18, 0x30, 0x30, 0x30,
  0x3E, 0x33, 0x73, 0x62, 0x66, 0x66, 0x46, 0xC6, 0xCC, 0x11, 0xC4, 0x03,
  0x19, 0x8C, 0x63, 0x19, 0x8C, 0x00, 0x04, 0x1C, 0x10, 0x00, 0xC1, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x70, 0xE0, 0x18, 0x10, 0x30,
  0x30, 0x33, 0x36, 0x6C, 0x78, 0x78, 0x6C, 0x4C, 0xCC, 0xCE, 0x18, 0x8C,
  0x63, 0x19, 0x8C, 0x63, 0x19, 0x8C, 0x00, 0x3E, 0xE3, 0x73, 0x73, 0x36,
  0x62, 0x66, 0x66, 0x66, 0x46, 0x6C, 0x46, 0xCC, 0xC0, 0x2E, 0x33, 0x73,
  0x62, 0x66, 0x66, 0x46, 0xC6, 0xCC, 0x1E, 0x36, 0x63, 0x63, 0x66, 0x46,
  0xC6, 0x7C, 0x78, 0x1F, 0x0C, 0xCE, 0x66, 0x33, 0x19, 0x98, 0xCC, 0xEC,
  0x6E, 0x30, 0x18, 0x08, 0x0C, 0x00, 0x3F, 0x37, 0x63, 0x62, 0x66, 0x46,
  0xC6, 0x6E, 0x74, 0x0C, 0x0C, 0x0C, 0x0C, 0x3E, 0x79, 0xC3, 0x06, 0x0C,
  0x18, 0x60, 0xC0, 0x3E, 0xC9, 0x83, 0x83, 0x83, 0x06, 0x7C, 0xF0, 0x23,
  0x3E, 0xC4, 0x63, 0x18, 0xC7, 0x38, 0x66, 0x8F, 0x1E, 0x6C, 0xD9, 0xA3,
  0x7E, 0xE8, 0xC7, 0x9B, 0x36, 0xCD, 0x9E, 0x3C, 0x70, 0xE0, 0xCC, 0x79,
  0x9B, 0x73, 0x6A, 0xCF, 0x59, 0xEA, 0x39, 0xC7, 0x30, 0xC6, 0x00, 0x33,
  0x8D, 0x87, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0xCC, 0xE6, 0x00, 0x31, 0x99,
  0x8C, 0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x30, 0x18, 0x18, 0x0C, 0x1C, 0x0C,
  0x00, 0x3F, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x7C, 0xFC, 0x0E, 0x38,
  0x60, 0xC1, 0x86, 0x1C, 0x70, 0x60, 0x41, 0x83, 0x06, 0x0E, 0x0C, 0x00,
  0xFF, 0xFF, 0x80, 0x18, 0x38, 0x30, 0x41, 0x83, 0x03, 0x86, 0x18, 0x60,
  0xC1, 0x83, 0x1C, 0x30, 0x00, 0xF3, 0x7C,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 7, 2, -12 },
  { 12, 9, 12, 9, 0, -12 },
  { 26, 8, 14, 8, 0, -13 },
  { 40, 11, 12, 12, 1, -12 },
  { 57, 9, 12, 9, 0, -12 },
  { 71, 2, 4, 4, 2, -12 },
  { 72, 6, 15, 5, 0, -12 },
  { 84, 5, 15, 5, -1, -12 },
  { 94, 7, 7, 7, 1, -13 },
  { 101, 7, 8, 8, 1, -10 },
  { 108, 4, 4, 4, -1, -2 },
  { 110, 5, 1, 5, 0, -5 },
  { 111, 3, 2, 4, 0, -2 },
  { 112, 9, 12, 6, -1, -12 },
  { 126, 8, 12, 8, 0, -12 },
  { 138, 5, 12, 8, 2, -12 },
  { 146, 9, 12, 8, -1, -12 },
  { 160, 8, 12, 8, 0, -12 },
  { 172, 8, 12, 8, 0, -12 },
  { 184, 8, 12, 8, 0, -12 },
  { 196, 7, 12, 8, 1, -12 },
  { 207, 8, 12, 8, 1, -12 },
  { 219, 8, 12, 8, 0, -12 },
  { 231, 8, 12, 8, 0, -12 },
  { 243, 4, 9, 4, 0, -9 },
  { 248, 5, 11, 4, -1, -9 },
  { 255, 7, 8, 8, 1, -10 },
  { 262, 7, 5, 8, 1, -8 },
  { 267, 7, 8, 8, 1, -10 },
  { 274, 6, 12, 6, 1, -12 },
  { 283, 11, 13, 12, 1, -12 },
  { 301, 8, 12, 8, -1, -12 },
  { 313, 9, 12, 9, 0, -12 },
  { 327, 8, 12, 8, 1, -12 },
  { 339, 9, 12, 9, 0, -12 },
  { 353, 8, 12, 7, 0, -12 },
  { 365, 8, 12, 7, 0, -12 },
  { 377, 9, 12, 10, 1, -12 },
  { 391, 10, 12, 10, 0, -12 },
  { 406, 8, 12, 5, -1, -12 },
  { 418, 8, 15, 4, -3, -12 },
  { 433, 10, 12, 8, 0, -12 },
  { 448, 6, 12, 7, 0, -12 },
  { 457, 13, 12, 12, 0, -12 },
  { 477, 11, 12, 10, 0, -12 },
  { 494, 9, 12, 10, 1, -12 },
  { 508, 9, 12, 8, 0, -12 },
  { 522, 9, 15, 10, 1, -12 },
  { 539, 8, 12, 8, 0, -12 },
  { 551, 8, 12, 7, 0, -12 },
  { 563, 7, 12, 7, 1, -12 },
  { 574, 9, 12, 9, 1, -12 },
  { 588, 8, 12, 8, 2, -12 },
  { 600, 13, 12, 13, 1, -12 },
  { 620, 10, 12, 8, -1, -12 },
  { 635, 7, 12, 8, 2, -12 },
  { 646, 9, 12, 7, -1, -12 },
  { 660, 7, 15, 5, -1, -12 },
  { 674, 3, 12, 6, 2, -12 },
  { 679, 6, 15, 5, -1, -12 },
  { 691, 8, 7, 8, 0, -12 },
  { 698, 6, 2, 6, -2, 1 },
  { 700, 3, 3, 5, 2, -13 },
  { 702, 8, 9, 8, 0, -9 },
  { 711, 8, 13, 8, 0, -13 },
  { 724, 7, 9, 7, 0, -9 },
  { 732, 9, 13, 8, 0, -13 },
  { 747, 7, 9, 8, 0, -9 },
  { 755, 9, 17, 5, -2, -13 },
  { 775, 8, 13, 8, 0, -9 },
  { 788, 8, 13, 8, 0, -13 },
  { 801, 5, 13, 4, 0, -13 },
  { 810, 7, 17, 4, -2, -13 },
  { 825, 8, 13, 8, 0, -13 },
  { 838, 5, 13, 4, 0, -13 },
  { 847, 12, 9, 12, 0, -9 },
  { 861, 8, 9, 8, 0, -9 },
  { 870, 8, 9, 8, 0, -9 },
  { 879, 9, 13, 8, -1, -9 },
  { 894, 8, 13, 8, 0, -9 },
  { 907, 7, 9, 6, 0, -9 },
  { 915, 7, 9, 6, 0, -9 },
  { 923, 5, 11, 5, 1, -11 },
  { 930, 7, 9, 8, 1, -9 },
  { 938, 7, 9, 7, 1, -9 },
  { 946, 11, 9, 11, 1, -9 },
  { 959, 9, 9, 7, -1, -9 },
  { 970, 9, 13, 7, -1, -9 },
  { 985, 8, 9, 6, -1, -9 },
  { 994, 7, 15, 6, 0, -12 },
  { 1008, 1, 17, 7, 3, -13 },
  { 1011, 7, 15, 6, -1, -12 },
  { 1025, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC17PT7B_H_
