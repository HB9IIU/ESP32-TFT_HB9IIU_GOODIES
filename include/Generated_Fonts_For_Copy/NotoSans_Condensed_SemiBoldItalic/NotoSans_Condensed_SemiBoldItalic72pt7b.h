#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xE1, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x7F,
  0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x10,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFD, 0xE7, 0xE0, 0x07, 0xF8, 0xF0, 0x70, 0x07, 0xF8,
  0x70, 0x10, 0x03, 0xFC, 0x38, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0xFE,
  0x1E, 0x00, 0x00, 0x7F, 0x0E, 0x00, 0x00, 0x3F, 0xC7, 0x00, 0x00, 0x1F,
  0xE3, 0x80, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xEF, 0xFC, 0x00, 0x00, 0x73, 0xFE,
  0x00, 0x00, 0x78, 0xFF, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x1C, 0x3F,
  0xC0, 0x00, 0x0E, 0x1F, 0xE0, 0x00, 0x07, 0x0F, 0xF0, 0x20, 0x07, 0x87,
  0xF8, 0x38, 0x03, 0xC7, 0xF8, 0x1F, 0x01, 0xC7, 0xFC, 0x0F, 0xF0, 0xEF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xF8,
  0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x01,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x60, 0x7E, 0x07,
  0xF1, 0xFC, 0x1F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC3, 0xFF, 0x9F, 0x83, 0xF8,
  0xFC, 0x3F, 0xFE, 0xFC, 0x1F, 0x8F, 0xE3, 0xFF, 0xF7, 0xF1, 0xFC, 0x7E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC, 0xFE, 0xFF, 0xFE, 0x3F, 0x1F,
  0xC3, 0xF7, 0xFF, 0xE3, 0xF0, 0xFC, 0x1F, 0x9F, 0xFE, 0x3F, 0x8F, 0xE0,
  0xFC, 0x7F, 0xE1, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xBF, 0xE0,
  0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xC7, 0xF8, 0x1F,
  0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC0, 0xFF, 0x9F, 0xC0, 0xFF, 0x01, 0xFF,
  0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFC, 0x0F,
  0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF,
  0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x9F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x10, 0x0F, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xFC, 0xFC, 0x00, 0x7F, 0xFF, 0xC1, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFB, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x3F,
  0xE3, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xF8, 0x1F,
  0xE0, 0x07, 0x00, 0xFE, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x0F, 0x83, 0xF8,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xFF, 0xF3, 0xFE, 0x7F, 0x8F, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xE3, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFF, 0xDF, 0xE3, 0xFF, 0x3F, 0xCF, 0xFC, 0xFF, 0x0F, 0xF1,
  0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0x07, 0xF8, 0x18, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x70, 0x00, 0xFF,
  0x80, 0x04, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0x1E,
  0x00, 0xFF, 0xC0, 0x06, 0x00, 0x1F, 0xF0, 0x01, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x08, 0x00,
  0x01, 0xFF, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x03, 0xF0, 0x0F,
  0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x40, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x3F, 0xF8,
  0x1F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x02, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3,
  0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xE0, 0x3F, 0xDF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF8, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFB, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x10, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x08, 0x00, 0xFF, 0xC0, 0x1F, 0x8F, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x03, 0xFE, 0x0F, 0x00, 0x7F, 0x81, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xE0,
  0x1F, 0x81, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xF0,
  0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xC1,
  0xF8, 0x7E, 0x03, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF3,
  0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x9F, 0x83, 0xF8, 0x0F, 0xE0, 0x3E, 0x3F,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x7C, 0x0F, 0xC0, 0x3F, 0x01, 0xF9, 0xF8,
  0x1F, 0x80, 0xFE, 0x03, 0xE3, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x3F, 0xE1, 0xF8, 0x3F, 0x03, 0xF8, 0xFF, 0xC7, 0xF0, 0x7E, 0x03,
  0xFF, 0xEF, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0x01, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0x00, 0x0F, 0xFC, 0x00,
  0x10, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x3F, 0xF8,
  0x07, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x8F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x40, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x1F, 0xF0,
  0x03, 0xFF, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xF7, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xE7, 0xE0,
  0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF9,
  0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFE,
  0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x3F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF1, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x17, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x07,
  0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE1,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0x60, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x3C, 0x00, 0x3F,
  0xF0, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFD, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFB, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x3F, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x8F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0xFE, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x3F, 0x0F, 0xF0, 0x00,
  0xFF, 0x1F, 0xC0, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x03, 0xF1, 0xFE,
  0x00, 0x0F, 0xF1, 0xFC, 0x0F, 0xC7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x3F,
  0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFC,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0xDF, 0xC0, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xCF, 0xE0, 0x0F,
  0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x3F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF,
  0xFB, 0xF8, 0x01, 0xFF, 0xF9, 0xFC, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x07, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x9F, 0xFE, 0x00, 0x3F,
  0xDF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xDF,
  0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xF0, 0x03, 0xF0,
  0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x3C, 0x07, 0xFE, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x40, 0x7F,
  0xC0, 0x38, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03,
  0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0xF9, 0xF8, 0x00,
  0x3F, 0xFF, 0x1F, 0x80, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x0F, 0xFC, 0x3F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x07,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xE3, 0xFD, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x02, 0x03, 0xFF, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x04,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x07, 0xFF, 0x87, 0xF0, 0x00, 0xFF,
  0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0xFE, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x7F, 0x80, 0x07, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x03,
  0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x38, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0xFF, 0x80,
  0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xDF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0x9F, 0xFE, 0x00, 0x3F, 0xDF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xEF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3F,
  0x83, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xC1, 0xFF, 0xF0, 0x03,
  0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F,
  0x8F, 0xFF, 0x00, 0x1F, 0xCF, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0xF0, 0x07,
  0xEF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xC7, 0xFF, 0x80, 0x01,
  0xFC, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xFF, 0xE0, 0x01, 0xF9, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0xFE, 0x00,
  0x0F, 0xF3, 0xFF, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x38,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x0F,
  0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xF7, 0xF0, 0x0F,
  0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFB, 0xF8, 0x01, 0xFF,
  0xFB, 0xFC, 0x00, 0x7F, 0xF9, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01,
  0xE0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xE7, 0xFE,
  0x00, 0xFE, 0xFF, 0xC0, 0x0F, 0xEF, 0xFC, 0x01, 0xFD, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x78, 0x07, 0xF8,
  0x01, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x3F, 0xE0, 0xE0, 0x07,
  0xFC, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x20, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xC7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xBF, 0x80, 0x7F,
  0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x3F, 0x80, 0x0F,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01,
  0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0x7E, 0x07, 0xF8, 0x3F, 0xC0, 0xFD, 0xF8,
  0x1F, 0xE0, 0xFF, 0x07, 0xF7, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0x9F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0x3F, 0xC3, 0xF9, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xC7, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x1F, 0x87, 0xF0,
  0x0F, 0xF1, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0xC7, 0xE3, 0xF8, 0xFE, 0x00,
  0xFF, 0x3F, 0x8F, 0xE7, 0xF8, 0x03, 0xFC, 0xFC, 0x3F, 0x9F, 0xE0, 0x0F,
  0xF7, 0xF0, 0xFE, 0x7F, 0x00, 0x3F, 0xDF, 0x83, 0xFB, 0xFC, 0x00, 0xFE,
  0x7E, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x02, 0x3F, 0xF8, 0x00, 0x0C, 0xFF, 0xFE, 0x00, 0x3B, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF9, 0x80, 0x01, 0xFF,
  0xE2, 0x00, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 20, 52, 18, 0, -51 },
  { 131, 24, 18, 28, 7, -51 },
  { 185, 38, 51, 37, 1, -51 },
  { 428, 33, 59, 33, 1, -55 },
  { 672, 45, 53, 52, 4, -52 },
  { 971, 39, 53, 39, 0, -52 },
  { 1230, 11, 18, 16, 7, -51 },
  { 1255, 23, 63, 20, 2, -52 },
  { 1437, 24, 63, 20, -5, -52 },
  { 1626, 28, 30, 32, 6, -55 },
  { 1731, 30, 35, 35, 3, -43 },
  { 1863, 16, 19, 17, -4, -9 },
  { 1901, 18, 7, 21, 1, -23 },
  { 1917, 11, 11, 17, 0, -10 },
  { 1933, 36, 52, 27, -4, -52 },
  { 2167, 31, 53, 33, 2, -52 },
  { 2373, 23, 51, 33, 7, -51 },
  { 2520, 35, 52, 33, -2, -52 },
  { 2748, 34, 53, 33, -1, -52 },
  { 2974, 34, 52, 33, -1, -52 },
  { 3195, 33, 52, 33, 0, -51 },
  { 3410, 32, 53, 33, 2, -52 },
  { 3622, 33, 51, 33, 3, -51 },
  { 3833, 34, 53, 33, 0, -52 },
  { 4059, 31, 53, 33, 1, -52 },
  { 4265, 17, 41, 17, 0, -40 },
  { 4353, 21, 50, 17, -4, -40 },
  { 4485, 31, 34, 35, 3, -43 },
  { 4617, 30, 21, 35, 3, -36 },
  { 4696, 31, 34, 35, 3, -43 },
  { 4828, 26, 53, 26, 3, -52 },
  { 5001, 47, 58, 50, 2, -52 },
  { 5342, 35, 52, 36, -4, -52 },
  { 5570, 36, 51, 36, 1, -51 },
  { 5800, 36, 53, 34, 3, -52 },
  { 6039, 37, 51, 39, 1, -51 },
  { 6275, 33, 51, 31, 1, -51 },
  { 6486, 33, 51, 30, 1, -51 },
  { 6697, 39, 53, 41, 3, -52 },
  { 6956, 41, 51, 41, 1, -51 },
  { 7218, 31, 51, 23, -3, -51 },
  { 7416, 31, 66, 18, -11, -51 },
  { 7672, 40, 51, 35, 1, -51 },
  { 7927, 24, 51, 29, 1, -51 },
  { 8080, 53, 51, 53, 1, -51 },
  { 8418, 44, 51, 43, 1, -51 },
  { 8699, 38, 53, 42, 3, -52 },
  { 8951, 36, 51, 35, 1, -51 },
  { 9181, 38, 64, 42, 3, -52 },
  { 9485, 35, 51, 36, 1, -51 },
  { 9709, 35, 53, 31, -1, -52 },
  { 9941, 30, 51, 30, 6, -51 },
  { 10133, 39, 52, 40, 3, -51 },
  { 10387, 35, 51, 35, 6, -51 },
  { 10611, 54, 51, 53, 6, -51 },
  { 10956, 43, 51, 33, -4, -51 },
  { 11231, 32, 51, 32, 6, -51 },
  { 11435, 37, 51, 30, -3, -51 },
  { 11671, 28, 63, 21, -2, -52 },
  { 11892, 15, 52, 27, 7, -52 },
  { 11990, 28, 63, 21, -5, -52 },
  { 12211, 32, 30, 33, 1, -51 },
  { 12331, 26, 5, 25, -7, 6 },
  { 12348, 13, 11, 21, 10, -55 },
  { 12366, 33, 41, 35, 2, -40 },
  { 12536, 33, 56, 35, 0, -55 },
  { 12767, 27, 41, 28, 2, -40 },
  { 12906, 36, 56, 35, 2, -55 },
  { 13158, 29, 41, 32, 2, -40 },
  { 13307, 37, 72, 21, -8, -55 },
  { 13640, 36, 57, 35, -1, -40 },
  { 13897, 33, 55, 35, 0, -55 },
  { 14124, 20, 54, 17, 0, -54 },
  { 14259, 29, 71, 17, -9, -54 },
  { 14517, 35, 55, 32, 0, -55 },
  { 14758, 20, 55, 17, 0, -55 },
  { 14896, 50, 40, 52, 0, -40 },
  { 15146, 33, 40, 35, 0, -40 },
  { 15311, 30, 41, 34, 2, -40 },
  { 15465, 36, 57, 35, -3, -40 },
  { 15722, 33, 57, 35, 2, -40 },
  { 15958, 28, 40, 24, 0, -40 },
  { 16098, 28, 41, 27, 0, -40 },
  { 16242, 21, 49, 22, 3, -48 },
  { 16371, 32, 40, 35, 2, -39 },
  { 16531, 29, 39, 30, 4, -39 },
  { 16673, 46, 39, 46, 4, -39 },
  { 16898, 36, 39, 30, -3, -39 },
  { 17074, 40, 56, 30, -6, -39 },
  { 17354, 30, 39, 26, -2, -39 },
  { 17501, 28, 62, 24, 1, -51 },
  { 17718, 7, 72, 31, 12, -55 },
  { 17781, 28, 62, 24, -4, -51 },
  { 17998, 31, 11, 35, 3, -31 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC72PT7B_H_
