#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x3E, 0x7C,
  0xF1, 0xF7, 0xC7, 0x9F, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0,
  0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F,
  0x0E, 0x00, 0x3C, 0x38, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00,
  0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38,
  0x78, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0x98, 0xC0, 0xF9, 0x80, 0x0F, 0x18, 0x00, 0xF3, 0x00, 0x0F,
  0xB0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x6F, 0x80, 0x0C, 0xF8,
  0x00, 0xCF, 0x80, 0x0C, 0xF8, 0x40, 0xCF, 0x87, 0x0D, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x0F, 0x01, 0xFE, 0x01,
  0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0x38, 0x1E, 0x03, 0xC7, 0x03, 0xC0, 0x70,
  0xE0, 0xF0, 0x1E, 0x1C, 0x1C, 0x03, 0xC3, 0x87, 0x80, 0x78, 0xF0, 0xE0,
  0x0E, 0x1E, 0x3C, 0x03, 0xC3, 0xCF, 0x00, 0x78, 0x71, 0xC0, 0x0F, 0x1E,
  0x79, 0xF9, 0xE3, 0xCE, 0x7F, 0xBC, 0xF3, 0xDF, 0xF3, 0xFE, 0xF3, 0xCF,
  0x7F, 0x9E, 0xF1, 0xE7, 0xE7, 0x9E, 0x3C, 0x00, 0xE3, 0x87, 0x80, 0x3C,
  0xF0, 0xF0, 0x0F, 0x1E, 0x1C, 0x01, 0xE3, 0xC3, 0x80, 0x78, 0x70, 0xF0,
  0x0E, 0x0E, 0x1E, 0x03, 0xC1, 0xC3, 0x80, 0xF0, 0x38, 0xF0, 0x1E, 0x07,
  0x9C, 0x07, 0x80, 0xFF, 0x80, 0xE0, 0x1F, 0xE0, 0x3C, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x87, 0xFC, 0x1E, 0x1F, 0xFC,
  0x7C, 0x7E, 0xF8, 0xF8, 0xF8, 0xFB, 0xE3, 0xE1, 0xF7, 0xC7, 0xC3, 0xFF,
  0x0F, 0x03, 0xFC, 0x3E, 0x07, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xBF, 0x03,
  0xFC, 0x3E, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xC0, 0x61, 0xC0, 0xF9, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0x7C,
  0xF0, 0x7C, 0xF0, 0x38, 0xF8, 0x10, 0x78, 0x00, 0x60, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x39, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xC7, 0xC3,
  0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x3E,
  0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xEF, 0x3F, 0x7C, 0x79, 0xF0,
  0xC7, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xC3, 0xF0, 0x38, 0x1F, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x30, 0x7E, 0x04, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x80, 0x3F, 0x18, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x07, 0x3C, 0x00, 0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0x78, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xBC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x63, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x80, 0x3F, 0x18, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x3E, 0x03,
  0xDF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xF8, 0xFC, 0x7E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xC3, 0xE0, 0x78,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x87, 0xC1, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC,
  0x7E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x78, 0x0F, 0x9F, 0x03, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x87, 0xC3,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0xF0, 0x1F, 0xBE, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x0F, 0x07, 0xF0, 0xF1, 0xE0, 0xFF, 0x8F, 0x1C, 0x1F, 0xF8, 0xF3, 0xC3,
  0xC7, 0x8F, 0x38, 0x78, 0x70, 0xF3, 0x87, 0x07, 0x0F, 0x78, 0xF0, 0xF0,
  0xE7, 0x0F, 0x0F, 0x0E, 0x70, 0xE0, 0xE0, 0xE7, 0x1E, 0x0E, 0x1E, 0x71,
  0xE1, 0xE1, 0xCF, 0x1E, 0x1E, 0x1C, 0xF1, 0xE3, 0xE3, 0x8F, 0x1E, 0x3E,
  0x78, 0xF1, 0xFE, 0xFF, 0x0F, 0x0F, 0xEF, 0xE0, 0xF0, 0x7C, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x04, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x3C,
  0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xFE,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3E, 0x1F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x60, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x40, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xE7, 0xF8, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC1, 0xF1, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x38, 0x3F, 0x00, 0x21, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0x3E, 0x07,
  0xFC, 0xF8, 0x1F, 0xF3, 0xE0, 0x7F, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3F, 0x01, 0xF0, 0xFC,
  0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xE0, 0x07, 0xCF, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F,
  0xBF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x1E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x78, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xBC, 0x07,
  0xFC, 0x07, 0xBC, 0x0F, 0xFC, 0x0F, 0xBC, 0x0F, 0x78, 0x0F, 0xBC, 0x1F,
  0x78, 0x0F, 0xBC, 0x1E, 0xF8, 0x0F, 0x3C, 0x1E, 0xF8, 0x0F, 0x3C, 0x3C,
  0xF8, 0x1F, 0x3C, 0x3C, 0xF0, 0x1F, 0x3C, 0x78, 0xF0, 0x1E, 0x3C, 0x79,
  0xF0, 0x1E, 0x3C, 0xF1, 0xF0, 0x1E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3D, 0xE1,
  0xE0, 0x3E, 0x3D, 0xE1, 0xE0, 0x3C, 0x3F, 0xC3, 0xE0, 0x3C, 0x3F, 0xC3,
  0xE0, 0x3C, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F, 0x83, 0xC0, 0x7C, 0x3F, 0x87,
  0xC0, 0x78, 0x3F, 0x07, 0xC0, 0x78, 0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x0F,
  0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3E, 0x07, 0xBC, 0x0F, 0x01, 0xEF, 0x03, 0xC0, 0xFB, 0xC1,
  0xF0, 0x3E, 0xF8, 0x7C, 0x0F, 0x1E, 0x1F, 0x03, 0xC7, 0x87, 0x80, 0xF1,
  0xE1, 0xE0, 0x7C, 0x7C, 0xF8, 0x1F, 0x1F, 0x3E, 0x07, 0x83, 0xCF, 0x01,
  0xE0, 0xF3, 0xC0, 0x78, 0x3E, 0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x81, 0xFF,
  0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x1F, 0x01,
  0xFE, 0x07, 0xC0, 0x3F, 0x81, 0xE0, 0x0F, 0xC0, 0x78, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC1,
  0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3E, 0x3F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F,
  0x07, 0xC1, 0xF8, 0x3E, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1, 0xF8, 0x3F,
  0x03, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01,
  0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E,
  0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x3E, 0x3F, 0x01, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x3F, 0x07, 0xC3, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE1, 0xC0, 0xFC,
  0x04, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x80, 0x3E,
  0x0E, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x83, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80,
  0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0,
  0x0F, 0xBC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0xFB, 0xC0, 0x3E, 0x01, 0xF7, 0x80,
  0x7C, 0x03, 0xCF, 0x01, 0xF8, 0x0F, 0x9E, 0x03, 0xF0, 0x1F, 0x3C, 0x0F,
  0xE0, 0x7C, 0x78, 0x1F, 0xC0, 0xF8, 0xF0, 0x3F, 0x81, 0xE1, 0xE0, 0xFF,
  0x07, 0xC3, 0xC1, 0xFE, 0x0F, 0x07, 0x87, 0xBC, 0x3E, 0x0F, 0x0F, 0x78,
  0x7C, 0x1E, 0x1E, 0xF0, 0xF0, 0x3C, 0x79, 0xE3, 0xE0, 0x78, 0xF3, 0xC7,
  0x80, 0xF3, 0xC7, 0x9F, 0x01, 0xE7, 0x8F, 0x3E, 0x03, 0xCF, 0x1E, 0x78,
  0x07, 0xBC, 0x3D, 0xF0, 0x0F, 0x78, 0x7B, 0xC0, 0x1F, 0xE0, 0xFF, 0x80,
  0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0x87, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x07, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xF1, 0xF0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03,
  0xCF, 0x00, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C,
  0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x01, 0xFF, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0xF9, 0xF1, 0xE1, 0xE3, 0xC3, 0x80, 0x01, 0xF1,
  0xE0, 0x7F, 0x3C, 0x1F, 0xF7, 0x87, 0xFF, 0xF1, 0xF8, 0xFE, 0x3E, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x1E,
  0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF1, 0xFC, 0x3F, 0xFF, 0x07, 0xFD, 0xE0,
  0xFF, 0x3C, 0x0F, 0xC7, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF9, 0xF0, 0x1E, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0xFF, 0x07, 0x8F, 0xC0, 0x00, 0xFE, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x82, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x8F, 0x00, 0xFE, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07,
  0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0x78, 0x07, 0xE3, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFB, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0xF8, 0x1E, 0x78, 0x1F,
  0x7C, 0x1F, 0x3E, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0x0F,
  0xC7, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x1F, 0xCF, 0x03, 0xFE, 0xF0,
  0x7F, 0xFF, 0x0F, 0xC7, 0xF0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x3F, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1,
  0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFD, 0xF0, 0x1F,
  0x9F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x08,
  0x07, 0xC0, 0xC0, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF9, 0xF0, 0x1E, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xC7,
  0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C,
  0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0xC0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xFB, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE1, 0xE0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0x07, 0x9F, 0x83, 0xE0, 0x3D, 0xFE, 0x7F, 0x83, 0xDF,
  0xF7, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x8F, 0x87, 0xE1, 0xF8,
  0x7C, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x1F, 0x1F, 0x03, 0xC0, 0xF8,
  0xF8, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0x7C, 0x3C, 0x0F, 0x83, 0xE3, 0xE0,
  0x78, 0x1F, 0x1F, 0x03, 0xC0, 0xF0, 0xF8, 0x3E, 0x07, 0x87, 0x81, 0xF0,
  0x7C, 0x7C, 0x0F, 0x83, 0xE3, 0xE0, 0x78, 0x1F, 0x1F, 0x07, 0xC0, 0xF0,
  0xF8, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0x7C, 0x7C, 0x0F, 0x03, 0xE3, 0xE0,
  0x78, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0xE7, 0xF8, 0x3D, 0xFF, 0x87, 0xBF,
  0xF0, 0xFE, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0,
  0x1E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x0F, 0xC7, 0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xE3, 0xE0, 0x0F, 0x7F, 0x80, 0x77, 0xFE, 0x07, 0xBF,
  0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xFC,
  0x1F, 0x07, 0xE1, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0x7F, 0x80,
  0xF9, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x7F, 0xBC, 0x1F, 0xF7,
  0x87, 0xFF, 0xF1, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3,
  0xF1, 0xFC, 0x7F, 0xFF, 0x07, 0xFD, 0xE0, 0xFF, 0x7C, 0x0F, 0xCF, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x07, 0x9F, 0x07, 0xBF, 0x0F, 0xFE, 0x0F, 0x7E, 0x0F, 0xFE, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x06, 0x1E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0F, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1,
  0xF0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87,
  0xC0, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1E,
  0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7F,
  0xFF, 0x07, 0xFD, 0xE0, 0xFF, 0x3C, 0x0F, 0xC7, 0x00, 0xF8, 0x0F, 0xFC,
  0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF8,
  0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x9F,
  0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x3E,
  0x07, 0xFC, 0x0F, 0x81, 0xEF, 0x07, 0xE0, 0xFB, 0xC1, 0xF8, 0x3E, 0xF0,
  0xFE, 0x0F, 0x3C, 0x3F, 0x87, 0xCF, 0x0E, 0xE1, 0xE3, 0xC7, 0xF8, 0xF8,
  0xF1, 0xDE, 0x3C, 0x3C, 0xF7, 0x8F, 0x0F, 0x3D, 0xE7, 0xC3, 0xCE, 0x79,
  0xE0, 0xF7, 0x9E, 0xF8, 0x3D, 0xE7, 0xBC, 0x0F, 0xF1, 0xEF, 0x03, 0xFC,
  0x7F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7C, 0xF0,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0x83, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E,
  0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE1,
  0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x09, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x5F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 30, 11, 0, -30 },
  { 46, 14, 11, 16, 4, -30 },
  { 66, 22, 30, 22, 0, -30 },
  { 149, 20, 34, 19, 0, -32 },
  { 234, 27, 30, 30, 2, -30 },
  { 336, 23, 30, 23, 0, -30 },
  { 423, 7, 11, 10, 4, -30 },
  { 433, 14, 37, 12, 1, -30 },
  { 498, 14, 37, 12, -3, -30 },
  { 563, 16, 17, 18, 4, -32 },
  { 597, 17, 20, 20, 2, -25 },
  { 640, 9, 11, 10, -2, -5 },
  { 653, 10, 5, 12, 1, -14 },
  { 660, 6, 6, 10, 0, -6 },
  { 665, 21, 30, 16, -2, -30 },
  { 744, 18, 30, 19, 1, -30 },
  { 812, 14, 30, 19, 4, -30 },
  { 865, 20, 30, 19, -1, -30 },
  { 940, 19, 30, 19, 0, -30 },
  { 1012, 20, 30, 19, -1, -30 },
  { 1087, 19, 30, 19, 0, -30 },
  { 1159, 19, 30, 19, 1, -30 },
  { 1231, 20, 30, 19, 1, -30 },
  { 1306, 20, 30, 19, 0, -30 },
  { 1381, 19, 30, 19, 0, -30 },
  { 1453, 10, 23, 10, 0, -23 },
  { 1482, 12, 29, 10, -2, -23 },
  { 1526, 18, 20, 20, 2, -25 },
  { 1571, 18, 12, 20, 2, -21 },
  { 1598, 18, 20, 20, 2, -25 },
  { 1643, 15, 30, 15, 2, -30 },
  { 1700, 28, 34, 29, 1, -30 },
  { 1819, 21, 30, 21, -3, -30 },
  { 1898, 21, 30, 21, 0, -30 },
  { 1977, 20, 30, 20, 2, -30 },
  { 2052, 22, 30, 23, 0, -30 },
  { 2135, 20, 30, 18, 0, -30 },
  { 2210, 20, 30, 17, 0, -30 },
  { 2285, 22, 30, 24, 2, -30 },
  { 2368, 25, 30, 24, 0, -30 },
  { 2462, 18, 30, 13, -2, -30 },
  { 2530, 18, 39, 11, -6, -30 },
  { 2618, 24, 30, 20, 0, -30 },
  { 2708, 14, 30, 17, 0, -30 },
  { 2761, 32, 30, 31, 0, -30 },
  { 2881, 26, 30, 25, 0, -30 },
  { 2979, 22, 30, 25, 2, -30 },
  { 3062, 21, 30, 20, 0, -30 },
  { 3141, 22, 37, 25, 2, -30 },
  { 3243, 21, 30, 21, 0, -30 },
  { 3322, 20, 30, 18, 0, -30 },
  { 3397, 18, 30, 18, 3, -30 },
  { 3465, 22, 30, 23, 2, -30 },
  { 3548, 20, 30, 20, 4, -30 },
  { 3623, 31, 30, 31, 4, -30 },
  { 3740, 25, 30, 19, -2, -30 },
  { 3834, 18, 30, 19, 4, -30 },
  { 3902, 21, 30, 18, -1, -30 },
  { 3981, 16, 37, 12, -1, -30 },
  { 4055, 9, 30, 16, 4, -30 },
  { 4089, 17, 37, 12, -3, -30 },
  { 4168, 19, 18, 19, 0, -30 },
  { 4211, 15, 2, 14, -4, 4 },
  { 4215, 7, 7, 12, 6, -32 },
  { 4222, 19, 23, 21, 1, -23 },
  { 4277, 19, 32, 20, 0, -32 },
  { 4353, 16, 23, 16, 1, -23 },
  { 4399, 21, 32, 21, 1, -32 },
  { 4483, 17, 23, 19, 1, -23 },
  { 4532, 22, 42, 12, -5, -32 },
  { 4648, 20, 33, 21, 0, -23 },
  { 4731, 19, 32, 20, 0, -32 },
  { 4807, 11, 32, 10, 0, -32 },
  { 4851, 16, 42, 10, -5, -32 },
  { 4935, 21, 32, 19, 0, -32 },
  { 5019, 12, 32, 10, 0, -32 },
  { 5067, 29, 23, 30, 0, -23 },
  { 5151, 19, 23, 20, 0, -23 },
  { 5206, 18, 23, 20, 1, -23 },
  { 5258, 21, 33, 20, -2, -23 },
  { 5345, 19, 33, 21, 1, -23 },
  { 5424, 16, 23, 14, 0, -23 },
  { 5470, 16, 23, 16, 0, -23 },
  { 5516, 12, 28, 13, 2, -28 },
  { 5558, 19, 23, 20, 1, -23 },
  { 5613, 17, 23, 17, 2, -23 },
  { 5662, 26, 23, 27, 3, -23 },
  { 5737, 21, 23, 18, -2, -23 },
  { 5798, 23, 33, 17, -3, -23 },
  { 5893, 17, 23, 15, -1, -23 },
  { 5942, 17, 37, 14, 0, -30 },
  { 6021, 4, 42, 18, 7, -32 },
  { 6042, 16, 37, 14, -2, -30 },
  { 6116, 18, 6, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC42PT7B_H_
