#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x0F,
  0x87, 0xC3, 0xC0, 0x79, 0xEF, 0x39, 0xC7, 0x39, 0xE7, 0x3C, 0xE7, 0x38,
  0xE7, 0x1C, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x18,
  0xE0, 0x1C, 0x70, 0x0E, 0x30, 0x3F, 0xFF, 0x3F, 0xFF, 0x83, 0x8C, 0x01,
  0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x00, 0x73, 0x81, 0xFF, 0xF9, 0xFF, 0xFC,
  0x1C, 0x60, 0x0C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x1C, 0x01, 0x8E,
  0x01, 0xC6, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC1, 0xEB, 0x87, 0xB1, 0x0E, 0x60, 0x1E, 0x80, 0x3D, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xBC, 0x03, 0x78, 0x06,
  0xF1, 0x09, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0x07, 0xC0, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x1F, 0x01, 0xC3, 0xF8, 0x38, 0x3B, 0x83, 0x87,
  0x38, 0x70, 0x73, 0x86, 0x0E, 0x38, 0xE0, 0xE3, 0x9C, 0x0E, 0x39, 0xC0,
  0xE7, 0x38, 0x0E, 0x73, 0x1C, 0xE7, 0x77, 0xEE, 0xEE, 0x7F, 0xFC, 0xEE,
  0x77, 0x9C, 0xE7, 0x01, 0xDC, 0x70, 0x39, 0xC7, 0x07, 0x1C, 0x70, 0x71,
  0xCE, 0x0E, 0x18, 0xE0, 0xE1, 0xCE, 0x1C, 0x1D, 0xC3, 0x81, 0xF8, 0x38,
  0x0F, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xF8, 0x01,
  0xF0, 0x01, 0xF8, 0x71, 0xFC, 0x79, 0xEF, 0x39, 0xE7, 0xBC, 0xE1, 0xFC,
  0xF0, 0xFE, 0x78, 0x3E, 0x3C, 0x1E, 0x1E, 0x1F, 0x87, 0xFF, 0xC3, 0xFE,
  0xF0, 0xFE, 0x7C, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C, 0x01, 0xC0, 0xE0, 0x78,
  0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x1E, 0x07, 0x03, 0x80, 0x04, 0x00, 0x78, 0x07, 0x04, 0x70,
  0xF7, 0x0F, 0xEF, 0x7F, 0xF0, 0xFF, 0x1F, 0x03, 0xB8, 0xFB, 0x87, 0x3C,
  0x21, 0xC0, 0x10, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x3C, 0x71, 0xE3, 0x87, 0x1C,
  0x78, 0x7F, 0xBF, 0xBF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87,
  0x9E, 0x1E, 0x38, 0xF0, 0xE3, 0xC3, 0xDE, 0x0E, 0x78, 0x39, 0xE0, 0xE7,
  0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x38, 0x3C, 0xE0, 0xF3,
  0x87, 0x8E, 0x1E, 0x3C, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x01,
  0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xBE, 0xE7, 0x78, 0x9E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0x1E,
  0x06, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x71, 0xF0, 0x81, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0x80, 0x7E,
  0x00, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC4, 0x0F, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xEE, 0x01,
  0xDC, 0x07, 0x78, 0x1C, 0xF0, 0x39, 0xC0, 0xE3, 0x83, 0x87, 0x0E, 0x1E,
  0x1C, 0x3C, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC6, 0x0F, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xE0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0xC1, 0xEF, 0x87, 0x7F, 0x1F, 0xBC, 0xF8,
  0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x78, 0x7F, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x78, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x0F, 0x3C, 0x1F, 0xF0, 0x1F, 0x80,
  0x7F, 0x01, 0xFF, 0x07, 0x9E, 0x1E, 0x1E, 0x38, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x87, 0x87, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCF,
  0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0xBF, 0x3F, 0xFC, 0x7E, 0xE0,
  0xF7, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xC3,
  0xFE, 0x0F, 0xE0, 0x00, 0x04, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0xF9, 0xE0, 0x01, 0x00, 0xE0, 0x7C,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0xC3,
  0xFE, 0x3F, 0xE3, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00,
  0x1C, 0x70, 0xF8, 0xE7, 0x0F, 0xE7, 0x30, 0xE7, 0x3B, 0x8E, 0x31, 0xDC,
  0xE3, 0x8E, 0xC7, 0x1C, 0x7E, 0x30, 0xE3, 0x73, 0x86, 0x3B, 0x9C, 0x71,
  0xDC, 0xE3, 0x8C, 0xE7, 0x3C, 0xE7, 0x3F, 0x7E, 0x38, 0xFB, 0xE1, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x10, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xCE,
  0x03, 0xCE, 0x03, 0x8E, 0x07, 0x8E, 0x07, 0x0E, 0x0F, 0x0E, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0x1F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E,
  0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xC6, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE7, 0xE0, 0xF0, 0xF8, 0x78,
  0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3E, 0x38, 0x1E,
  0x3C, 0x1F, 0x1E, 0x1F, 0x0F, 0x3F, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83,
  0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0x0C, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7F, 0x3C, 0x1F,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1,
  0xF0, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1C, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x70, 0x1C, 0x1E, 0x07, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x38,
  0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0,
  0x38, 0x3C, 0x0F, 0x00, 0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x80, 0x00, 0x07,
  0x83, 0xC1, 0xC1, 0xE0, 0x70, 0x78, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xCF,
  0x00, 0xE3, 0xC0, 0x39, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xCE, 0x00, 0xE3, 0xC0, 0x38,
  0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x1C, 0x1E,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC1, 0xFE, 0x1F,
  0xC1, 0xDC, 0x1F, 0xC1, 0xDC, 0x1D, 0xC3, 0xBC, 0x1C, 0xE3, 0xBC, 0x3C,
  0xE7, 0x3C, 0x3C, 0xE7, 0x38, 0x3C, 0xEE, 0x38, 0x38, 0xEE, 0x78, 0x38,
  0xFC, 0x78, 0x78, 0xFC, 0x78, 0x78, 0xF8, 0x70, 0x70, 0xF8, 0x70, 0x70,
  0xF8, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0x07, 0x80, 0xF0, 0x7C,
  0x0F, 0x07, 0xC0, 0xE0, 0xFC, 0x0E, 0x0F, 0xC0, 0xE0, 0xFC, 0x1E, 0x0F,
  0xE1, 0xE0, 0xEE, 0x1C, 0x1E, 0xE1, 0xC1, 0xCE, 0x3C, 0x1C, 0xF3, 0xC1,
  0xCF, 0x3C, 0x3C, 0x73, 0x83, 0xC7, 0x38, 0x38, 0x73, 0x83, 0x87, 0xF8,
  0x38, 0x3F, 0x07, 0x83, 0xF0, 0x78, 0x3F, 0x07, 0x03, 0xF0, 0x70, 0x3F,
  0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x0F, 0x3F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0x80, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F, 0x87,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x7C, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x3C, 0xE0, 0x3C,
  0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0x70,
  0x78, 0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFC, 0xE1, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE2, 0x03, 0xC6, 0x0F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0,
  0x70, 0x70, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE3, 0xE0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x81,
  0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xE1, 0xE3, 0xC3,
  0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3D, 0xE0, 0x7B, 0x80, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC1,
  0xEE, 0x0F, 0x83, 0xDC, 0x1F, 0x07, 0x38, 0x7E, 0x1E, 0x70, 0xFC, 0x38,
  0xE1, 0xF8, 0xF1, 0xC7, 0x71, 0xE3, 0x8E, 0xE3, 0x87, 0x39, 0xCF, 0x0E,
  0x73, 0x9C, 0x1C, 0xE7, 0x78, 0x3B, 0x8E, 0xF0, 0x77, 0x1D, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83,
  0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x70,
  0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x77,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x38,
  0x01, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x38,
  0x3C, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0x70, 0xF1,
  0xC7, 0x87, 0x1C, 0x1C, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x00, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x80, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x1C, 0x1E, 0x38,
  0x38, 0x70, 0xE0, 0xF1, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xC0, 0xFF, 0xFF,
  0xFC, 0xF7, 0x9C, 0xF3, 0x8C, 0x03, 0x02, 0x1F, 0xB8, 0x7F, 0x71, 0xFF,
  0xE3, 0xC7, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0x7E,
  0xE0, 0xF9, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x8C, 0x07, 0x7E, 0x1F, 0xFC, 0x3F, 0x7C, 0x78, 0x78,
  0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0xF0,
  0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F, 0xFE, 0x3F, 0xF8, 0x73, 0xE0,
  0x01, 0xC0, 0xFF, 0x1F, 0xF3, 0xF6, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x8F, 0xF8,
  0x7F, 0x83, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x03, 0x1E, 0x0F, 0xDC, 0x1F, 0xDC, 0x3E, 0xFC, 0x3C,
  0x7C, 0x78, 0x3C, 0x78, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0x70, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7C, 0xE0, 0x01, 0xC0, 0x3F, 0x87, 0xFC, 0x3C, 0xF3, 0xC7, 0xBC,
  0x3D, 0xE1, 0xCE, 0x3E, 0xFF, 0xE7, 0xFE, 0x3E, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC1, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC8,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x0B, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC1, 0x07, 0xEE, 0x0F, 0xEE, 0x1F,
  0xFE, 0x1E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0x7F,
  0xF0, 0x3F, 0x70, 0x3E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x81,
  0xE0, 0xE7, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x8C, 0x07, 0x7E,
  0x1F, 0xFC, 0x3F, 0xF8, 0x78, 0x78, 0xF0, 0xE1, 0xC1, 0xC7, 0x87, 0x8F,
  0x0F, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0xC7, 0x07,
  0x8E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x0B, 0xE0, 0x7E, 0x03, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x01, 0x0E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x70, 0x1C,
  0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7D,
  0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xE0, 0x00, 0x30, 0x70, 0x3B, 0xE3, 0xE1, 0xDF, 0xDF,
  0xC7, 0xFF, 0xFF, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xC3, 0xC3, 0xCF,
  0x0F, 0x0F, 0x3C, 0x3C, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x87, 0x9E, 0x1E,
  0x1E, 0x78, 0x78, 0x79, 0xE1, 0xE1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x3C,
  0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xC0, 0x02, 0x30, 0x19, 0xF8, 0x77, 0xF0,
  0xFF, 0xE1, 0xF1, 0xE3, 0xC3, 0x87, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xE0, 0xE3, 0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x38, 0x38,
  0xF0, 0x71, 0xE1, 0xE0, 0x01, 0x80, 0x7F, 0x07, 0xFC, 0x7D, 0xF3, 0xC7,
  0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x0F, 0x78, 0x7B, 0xC7, 0x8F, 0xFC, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0x18,
  0x07, 0x7E, 0x0E, 0xFE, 0x0F, 0xDE, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0, 0x7B, 0xE0, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x03, 0x82, 0x1F, 0xB8, 0x7F, 0xF1, 0xF7, 0xE3, 0xC7, 0xCF,
  0x07, 0x9E, 0x0E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x83,
  0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0x7E, 0xE0, 0xFB, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x30, 0xEF, 0x1F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0xFF, 0x1F, 0xF3, 0xE6,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x06, 0x03, 0x80,
  0xE0, 0x78, 0x7F, 0xDF, 0xE7, 0xF8, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xE3, 0xF8, 0x7E, 0x00,
  0x1C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x39, 0xE0, 0xE7, 0x87,
  0x9E, 0x1E, 0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7,
  0x8F, 0xFE, 0x3F, 0xB8, 0x7C, 0xE0, 0xE0, 0x7F, 0x07, 0xB8, 0x3D, 0xC3,
  0xCE, 0x1E, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xE7, 0x87, 0xB8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0xF0,
  0xFE, 0x1F, 0x0E, 0xE1, 0xF1, 0xEE, 0x3F, 0x1C, 0xE3, 0xF1, 0xCE, 0x37,
  0x3C, 0xE7, 0x73, 0x8E, 0x77, 0x78, 0xEE, 0x77, 0x0E, 0xE7, 0x70, 0xEC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0x80, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x83, 0xC7, 0x81, 0xE7, 0x80,
  0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0xF1,
  0xE0, 0x70, 0xF0, 0xF8, 0x78, 0x00, 0x07, 0x03, 0xC1, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x70,
  0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x17, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x01, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0x00, 0x18,
  0x05, 0xFC, 0x1F, 0xFF, 0xF9, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 11, 8, 12, 3, -23 },
  { 38, 17, 23, 16, 0, -23 },
  { 87, 15, 26, 15, 0, -24 },
  { 136, 20, 23, 23, 2, -23 },
  { 194, 17, 23, 17, 0, -23 },
  { 243, 5, 8, 7, 3, -23 },
  { 248, 10, 28, 9, 1, -23 },
  { 283, 10, 28, 9, -2, -23 },
  { 318, 12, 14, 14, 3, -25 },
  { 339, 14, 15, 16, 1, -19 },
  { 366, 7, 8, 8, -2, -4 },
  { 373, 9, 3, 9, 0, -10 },
  { 377, 5, 4, 8, 0, -4 },
  { 380, 16, 23, 12, -2, -23 },
  { 426, 14, 23, 15, 1, -23 },
  { 467, 10, 23, 15, 3, -23 },
  { 496, 16, 23, 15, -1, -23 },
  { 542, 15, 23, 15, 0, -23 },
  { 586, 15, 23, 15, 0, -23 },
  { 630, 15, 23, 15, 0, -23 },
  { 674, 14, 23, 15, 1, -23 },
  { 715, 15, 23, 15, 1, -23 },
  { 759, 15, 23, 15, 0, -23 },
  { 803, 14, 23, 15, 0, -23 },
  { 844, 7, 18, 8, 0, -18 },
  { 860, 10, 22, 8, -2, -18 },
  { 888, 14, 15, 16, 1, -19 },
  { 915, 14, 9, 16, 1, -16 },
  { 931, 14, 15, 16, 1, -19 },
  { 958, 12, 23, 11, 1, -23 },
  { 993, 21, 26, 22, 1, -23 },
  { 1062, 16, 23, 16, -2, -23 },
  { 1108, 16, 23, 16, 0, -23 },
  { 1154, 16, 23, 15, 1, -23 },
  { 1200, 17, 23, 18, 0, -23 },
  { 1249, 15, 23, 14, 0, -23 },
  { 1293, 15, 23, 13, 0, -23 },
  { 1337, 18, 23, 18, 1, -23 },
  { 1389, 19, 23, 18, 0, -23 },
  { 1444, 13, 23, 10, -1, -23 },
  { 1482, 14, 30, 8, -5, -23 },
  { 1535, 18, 23, 16, 0, -23 },
  { 1587, 11, 23, 13, 0, -23 },
  { 1619, 24, 23, 23, 0, -23 },
  { 1688, 20, 23, 19, 0, -23 },
  { 1746, 17, 23, 19, 1, -23 },
  { 1795, 16, 23, 16, 0, -23 },
  { 1841, 17, 28, 19, 1, -23 },
  { 1901, 16, 23, 16, 0, -23 },
  { 1947, 15, 23, 14, 0, -23 },
  { 1991, 13, 23, 13, 3, -23 },
  { 2029, 18, 23, 18, 1, -23 },
  { 2081, 15, 23, 15, 3, -23 },
  { 2125, 23, 23, 24, 3, -23 },
  { 2192, 19, 23, 15, -2, -23 },
  { 2247, 14, 23, 14, 3, -23 },
  { 2288, 16, 23, 13, -1, -23 },
  { 2334, 13, 28, 9, -1, -23 },
  { 2380, 7, 23, 12, 3, -23 },
  { 2401, 12, 28, 9, -2, -23 },
  { 2443, 15, 14, 15, 0, -23 },
  { 2470, 11, 2, 11, -3, 3 },
  { 2473, 5, 6, 9, 5, -25 },
  { 2477, 15, 18, 16, 1, -18 },
  { 2511, 15, 24, 16, 0, -24 },
  { 2556, 12, 18, 12, 1, -18 },
  { 2583, 16, 24, 16, 1, -24 },
  { 2631, 13, 18, 14, 1, -18 },
  { 2661, 17, 32, 9, -4, -24 },
  { 2729, 16, 26, 16, 0, -18 },
  { 2781, 15, 24, 16, 0, -24 },
  { 2826, 9, 24, 8, 0, -24 },
  { 2853, 13, 32, 8, -4, -24 },
  { 2905, 16, 24, 14, 0, -24 },
  { 2953, 9, 24, 7, 0, -24 },
  { 2980, 22, 18, 23, 0, -18 },
  { 3030, 15, 18, 16, 0, -18 },
  { 3064, 13, 18, 15, 1, -18 },
  { 3094, 16, 26, 16, -1, -18 },
  { 3146, 15, 26, 16, 1, -18 },
  { 3195, 12, 18, 11, 0, -18 },
  { 3222, 12, 18, 12, 0, -18 },
  { 3249, 10, 21, 10, 1, -21 },
  { 3276, 14, 17, 15, 1, -17 },
  { 3306, 13, 17, 13, 2, -17 },
  { 3334, 20, 17, 20, 2, -17 },
  { 3377, 17, 17, 14, -2, -17 },
  { 3414, 18, 25, 13, -3, -17 },
  { 3471, 13, 17, 12, -1, -17 },
  { 3499, 13, 28, 11, 0, -23 },
  { 3545, 3, 31, 14, 5, -24 },
  { 3557, 12, 28, 11, -2, -23 },
  { 3599, 14, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC32PT7B_H_
