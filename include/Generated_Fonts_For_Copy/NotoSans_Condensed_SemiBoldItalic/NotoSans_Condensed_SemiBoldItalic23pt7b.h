#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC0, 0x00,
  0x0C, 0x38, 0x70, 0x77, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0x07, 0x70, 0x66,
  0x06, 0x60, 0x44, 0x3F, 0xF3, 0xFF, 0x0C, 0xC1, 0x98, 0x19, 0x8F, 0xFE,
  0xFF, 0xE3, 0x30, 0x33, 0x02, 0x60, 0x66, 0x06, 0x60, 0x01, 0x00, 0x70,
  0x3F, 0x8F, 0xE3, 0xA0, 0x74, 0x0E, 0x80, 0xE0, 0x1F, 0x00, 0xF0, 0x1E,
  0x02, 0xC8, 0x99, 0x97, 0x3F, 0xC3, 0xF0, 0x18, 0x02, 0x00, 0x08, 0x00,
  0x7C, 0x31, 0xD8, 0xC3, 0x31, 0x86, 0x66, 0x18, 0xD8, 0x33, 0x30, 0x66,
  0xCE, 0xCD, 0xBE, 0xF6, 0xCC, 0xD9, 0x98, 0x36, 0x30, 0xCC, 0xC1, 0x99,
  0x86, 0x33, 0x1C, 0x7C, 0x30, 0x70, 0x03, 0x00, 0xFC, 0x0C, 0xC1, 0xCC,
  0x1C, 0xC1, 0xDC, 0x1F, 0x80, 0xF0, 0x1E, 0x03, 0xE7, 0x77, 0x76, 0x36,
  0xE3, 0xEE, 0x3C, 0xE3, 0xC7, 0xFC, 0x7C, 0xE0, 0x76, 0x66, 0xEC, 0x07,
  0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x30, 0x06, 0x06, 0x06, 0x07, 0x07,
  0x07, 0x03, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x60, 0xE0, 0x08, 0x06, 0x23, 0x1D, 0x8F, 0xF8, 0xFC, 0xF1,
  0xFC, 0x66, 0x02, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39, 0x9C, 0xCE, 0x60, 0x7F, 0xF0,
  0x7F, 0x80, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x00, 0x06, 0x0F, 0xCF, 0xE7, 0x37, 0x1B, 0x8D, 0x87, 0xC3, 0xE3,
  0xF1, 0xF0, 0xF8, 0x6C, 0x76, 0x3B, 0x39, 0xF8, 0x78, 0x00, 0x0F, 0x1E,
  0x3E, 0xFE, 0x6E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x70, 0x03, 0x81, 0xFC, 0x7F, 0x84, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0x03, 0xF8, 0x7F, 0x08, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x3C, 0x1E, 0x03, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x21, 0xC7, 0xF8,
  0xFC, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xD8, 0x1B, 0x06, 0x61,
  0x9C, 0x33, 0x8C, 0x63, 0xFF, 0x7F, 0xEF, 0xF8, 0x0E, 0x01, 0x80, 0x30,
  0x0F, 0xE3, 0xF8, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xC1, 0xFC, 0x03,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x39, 0x0E, 0x3F, 0xC7, 0xE0, 0x03, 0xC3,
  0xF1, 0xFC, 0xE0, 0x30, 0x1C, 0x06, 0x61, 0xFC, 0xFF, 0xB8, 0xEE, 0x3B,
  0x0E, 0xC3, 0x31, 0xCE, 0x73, 0xF8, 0x7C, 0x00, 0x7F, 0xEF, 0xF8, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x03, 0x01, 0xF8, 0x77, 0x8C, 0x73,
  0x8E, 0x71, 0x86, 0x70, 0xFC, 0x1E, 0x07, 0xE1, 0xCE, 0x30, 0xCE, 0x19,
  0xC3, 0x38, 0xE3, 0xF8, 0x3E, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0xE3, 0x30,
  0xCC, 0x37, 0x0D, 0xC7, 0x73, 0xCF, 0xF3, 0xD8, 0x06, 0x03, 0x81, 0xC0,
  0xF3, 0xF8, 0xF8, 0x00, 0x19, 0xCE, 0x60, 0x00, 0x00, 0x00, 0x19, 0xCE,
  0x00, 0x0C, 0x71, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x71, 0x8E,
  0x30, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0xF0, 0x0C, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80,
  0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x7C, 0x7C, 0x7C, 0x3C, 0x0C,
  0x00, 0x1C, 0x7F, 0x7F, 0x43, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70,
  0x60, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x40, 0x0F, 0xF0, 0x38, 0x70,
  0xC0, 0x63, 0x00, 0x66, 0x7C, 0xD9, 0xD9, 0xB3, 0x33, 0xCC, 0x47, 0x99,
  0x9B, 0x23, 0x36, 0xC6, 0x6C, 0xDD, 0x99, 0xFE, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x40, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x6C, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xE3, 0xFC, 0xFF, 0x98, 0x77, 0x0E,
  0xC1, 0xF8, 0x3F, 0x07, 0x1F, 0xE1, 0xFE, 0x1C, 0x71, 0x87, 0x18, 0x63,
  0x8E, 0x3F, 0xC3, 0xF0, 0x3F, 0xC3, 0x0C, 0x70, 0xC7, 0x0C, 0x71, 0xC6,
  0x3C, 0x7F, 0x8F, 0xE0, 0x03, 0x81, 0xFC, 0x7F, 0x9E, 0x13, 0x80, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C,
  0x43, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x1C, 0x71, 0xC7, 0x18, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x70, 0xE7, 0x0E, 0x71, 0xC6,
  0x78, 0x7F, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0F, 0xE1, 0xFC, 0x3F, 0x86, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1F,
  0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xFC, 0x3F, 0x86, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0x01, 0xC0, 0xFF, 0x1F, 0xF3, 0xC1, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE3, 0xEE, 0x3E, 0xE0, 0xEE, 0x0C, 0xE0, 0xCE, 0x1C, 0x71, 0xC7, 0xFC,
  0x3F, 0x80, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE0,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xC1, 0x87, 0x06, 0x1C, 0x38, 0x70,
  0xE1, 0x83, 0x86, 0x0C, 0x38, 0x70, 0x1F, 0xC1, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x07,
  0xE3, 0xF0, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x87, 0xC1, 0xE0, 0xF0, 0x00, 0x1C, 0x38, 0xE3, 0x87, 0x38, 0x33, 0x81,
  0x9C, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1C, 0xC0, 0xE7,
  0x07, 0x38, 0x31, 0xC1, 0x86, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x7F, 0xFF, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xF1, 0xE1, 0xF1, 0xF0, 0xD8,
  0xFC, 0xFC, 0x6E, 0x6E, 0x37, 0x76, 0x1B, 0xB3, 0x1C, 0xD9, 0x8E, 0x79,
  0xC6, 0x3C, 0xE3, 0x1C, 0x61, 0x8E, 0x31, 0xC6, 0x38, 0x1E, 0x0C, 0x78,
  0x71, 0xE1, 0xC7, 0xC6, 0x1F, 0x18, 0xEC, 0x63, 0xB3, 0x8C, 0xCE, 0x33,
  0xB0, 0xCE, 0xC7, 0x1B, 0x1C, 0x7C, 0x61, 0xF1, 0x87, 0x86, 0x0E, 0x38,
  0x38, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x77, 0x07, 0x70, 0x76,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7,
  0xF8, 0x3E, 0x00, 0x1F, 0xC1, 0xFE, 0x1C, 0x71, 0xC7, 0x18, 0x73, 0x86,
  0x38, 0xE3, 0x9E, 0x3F, 0xC3, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x77, 0x07,
  0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C,
  0xF3, 0xC7, 0xF8, 0x3E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0xC3, 0xFC, 0x73, 0x8C, 0x31, 0x86, 0x71, 0xCE, 0x39, 0xFE, 0x3F, 0x86,
  0xE1, 0xCC, 0x39, 0xC7, 0x38, 0xC7, 0x18, 0x67, 0x0E, 0x03, 0x81, 0xFC,
  0x7F, 0x1C, 0x23, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x31, 0xC7, 0xF8, 0xFC, 0x00, 0xFF, 0xFF, 0xC7,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0xC0, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x0E,
  0x70, 0xE7, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38,
  0x7F, 0x03, 0xE0, 0xE0, 0xFC, 0x3B, 0x87, 0x70, 0xCE, 0x39, 0xC6, 0x39,
  0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0xB0, 0x7E, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xE1, 0xC3, 0xF0, 0xE1, 0xB8, 0xF1, 0xDC, 0x78, 0xCE, 0x6C, 0xE7,
  0x36, 0x73, 0x1F, 0x31, 0x9B, 0xB8, 0xCD, 0xD8, 0x6E, 0xFC, 0x36, 0x7E,
  0x1B, 0x36, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0x1C,
  0x38, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x33, 0x03, 0x98, 0x38, 0xE1, 0x87, 0x1C,
  0x38, 0xE1, 0xF8, 0xE6, 0x39, 0x9C, 0x66, 0x1B, 0x87, 0xC1, 0xF0, 0x78,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x0F, 0xF1, 0xFF,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0x87, 0xC3,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x32, 0x1E, 0x1F, 0x00, 0xE7, 0x18, 0xC6, 0x31,
  0x8E, 0x71, 0x8C, 0x63, 0x18, 0xE7, 0x38, 0x0F, 0x87, 0xC0, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x1C, 0x0E, 0x1E, 0x1F, 0x00, 0x03, 0x01, 0xC0, 0xF0, 0x3E, 0x19,
  0x86, 0x63, 0x1D, 0xC3, 0xE0, 0xC0, 0xFF, 0xFF, 0xE7, 0x73, 0x0C, 0x0F,
  0xB3, 0xFD, 0xC7, 0x61, 0xB8, 0x6E, 0x3B, 0x0E, 0xC3, 0x31, 0xCE, 0x73,
  0xEC, 0x77, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x98, 0x7F, 0x8F,
  0xF1, 0xC7, 0x38, 0xE6, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xE3, 0x1C, 0xE7,
  0xF8, 0xDE, 0x00, 0x0E, 0x3F, 0x3F, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xE2, 0xFC, 0x7C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0xCC, 0x7F,
  0x8F, 0xF3, 0x8E, 0x61, 0x9C, 0x33, 0x8E, 0x61, 0xCC, 0x31, 0x8E, 0x39,
  0xC7, 0xD8, 0x73, 0x00, 0x0E, 0x0F, 0x8E, 0xEE, 0x7E, 0x3F, 0x3B, 0xF9,
  0xF0, 0xC0, 0x60, 0x38, 0x9F, 0xC7, 0xE0, 0x00, 0x60, 0x1F, 0x01, 0xF0,
  0x18, 0x03, 0x80, 0x3A, 0x0F, 0xC0, 0xFC, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x0F, 0x80, 0xF0, 0x04, 0x00, 0x06, 0x03, 0xEC, 0x7F, 0x9C,
  0x73, 0x0C, 0xE1, 0x9C, 0x73, 0x0E, 0x61, 0x8C, 0x71, 0xCE, 0x3F, 0xC3,
  0xB8, 0x06, 0x00, 0xC4, 0x38, 0xFE, 0x1F, 0x80, 0x40, 0x00, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x19, 0x8F, 0xF3, 0xFC, 0xE3, 0x38, 0xCC, 0x37, 0x1D,
  0xC7, 0x71, 0x98, 0x66, 0x3B, 0x8E, 0xE3, 0x80, 0x0C, 0x70, 0x80, 0x00,
  0x63, 0x8E, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE0, 0x01, 0x81, 0xC0,
  0x40, 0x00, 0x00, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x0F, 0x87, 0x81, 0x00, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x82, 0x31, 0x8E, 0x71, 0xDC, 0x37, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xCE, 0x19, 0xC7, 0x18, 0xE3, 0x80, 0x0C,
  0x71, 0xC7, 0x18, 0x63, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE0,
  0x01, 0x8C, 0x1F, 0xDF, 0x3F, 0xFF, 0x38, 0xE7, 0x38, 0xC7, 0x31, 0xC7,
  0x71, 0xC6, 0x71, 0x86, 0x71, 0x8E, 0x61, 0x8E, 0x63, 0x8C, 0xE3, 0x8C,
  0xE3, 0x1C, 0x01, 0x87, 0xF3, 0xFC, 0xE3, 0x38, 0xCC, 0x37, 0x1D, 0xC7,
  0x71, 0x98, 0x66, 0x3B, 0x8E, 0xE3, 0x80, 0x0E, 0x1F, 0x8F, 0xEE, 0x3E,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xB9, 0xDF, 0xC7, 0xC0, 0x00, 0xC0,
  0xFE, 0x1E, 0xE1, 0xC7, 0x1C, 0x71, 0x87, 0x38, 0x63, 0x8E, 0x38, 0xE3,
  0x8E, 0x39, 0xC7, 0xF8, 0x77, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0x0C, 0x0F, 0xB3, 0xFD, 0xC7, 0x61, 0xB8, 0x6E, 0x3B, 0x0E, 0xC3,
  0x31, 0xCE, 0x73, 0xFC, 0x77, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x01, 0x8F, 0x8F, 0xC7, 0x83, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x1C, 0x0E, 0x00, 0x0E, 0x1F, 0xCE, 0xCE, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0E, 0x03, 0x23, 0x9F, 0xCF, 0xC0, 0x18, 0x30, 0xCF, 0xEF, 0xCE,
  0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x1F, 0x3E, 0x00, 0x71, 0xDC, 0x77,
  0x19, 0x86, 0x63, 0xB8, 0xEE, 0x3B, 0x8C, 0xC7, 0x31, 0xCF, 0xB3, 0xD8,
  0xE1, 0xF8, 0xEE, 0x31, 0x9C, 0x66, 0x1B, 0x86, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xE3, 0x8F, 0xCF, 0x3B, 0x9E, 0x77, 0x3C, 0xCE, 0xDB,
  0x9D, 0xB6, 0x3E, 0x6C, 0x7C, 0xF0, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x07,
  0x0E, 0x00, 0x1C, 0xF1, 0xCC, 0x0D, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x3B, 0x03, 0x30, 0x73, 0x8E, 0x38, 0x1C, 0x38, 0x63, 0x83,
  0x18, 0x19, 0xC0, 0xCC, 0x06, 0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x1F, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x1C, 0x07, 0xF3, 0xF8, 0x07, 0x83, 0xC3, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x38, 0x78, 0x30, 0x3C, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70,
  0x3C, 0x0E, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0F, 0x81, 0x83, 0xC3, 0x81,
  0x80, 0xC0, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x18, 0x00, 0x70, 0x7F, 0xFC,
  0xFE, 0x0C,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 12, 16, 12, 0, -16 },
  { 45, 11, 18, 10, 0, -17 },
  { 70, 15, 17, 17, 1, -17 },
  { 102, 12, 17, 13, 0, -17 },
  { 128, 4, 6, 5, 2, -16 },
  { 131, 8, 20, 6, 0, -16 },
  { 151, 8, 21, 7, -2, -17 },
  { 172, 9, 10, 10, 2, -18 },
  { 184, 10, 11, 11, 1, -14 },
  { 198, 5, 6, 6, -1, -3 },
  { 202, 6, 2, 7, 0, -7 },
  { 204, 3, 3, 6, 0, -3 },
  { 206, 11, 17, 9, -1, -17 },
  { 230, 9, 17, 10, 1, -17 },
  { 250, 8, 16, 11, 2, -16 },
  { 266, 11, 17, 10, -1, -17 },
  { 290, 11, 17, 10, 0, -17 },
  { 314, 11, 16, 11, 0, -16 },
  { 336, 11, 16, 10, 0, -16 },
  { 358, 10, 17, 10, 1, -17 },
  { 380, 11, 16, 10, 1, -16 },
  { 402, 11, 17, 10, 0, -17 },
  { 426, 10, 17, 10, 0, -17 },
  { 448, 5, 13, 6, 0, -13 },
  { 457, 6, 16, 6, -1, -13 },
  { 469, 10, 11, 11, 1, -14 },
  { 483, 10, 6, 11, 1, -11 },
  { 491, 10, 11, 11, 1, -14 },
  { 505, 8, 17, 8, 1, -17 },
  { 522, 15, 19, 16, 1, -17 },
  { 558, 11, 16, 11, -1, -16 },
  { 580, 12, 16, 12, 0, -16 },
  { 604, 11, 17, 11, 1, -17 },
  { 628, 12, 16, 13, 0, -16 },
  { 652, 11, 16, 10, 0, -16 },
  { 674, 11, 16, 9, 0, -16 },
  { 696, 12, 17, 13, 1, -17 },
  { 722, 14, 16, 13, 0, -16 },
  { 750, 10, 16, 7, -1, -16 },
  { 770, 10, 21, 6, -4, -16 },
  { 797, 13, 16, 11, 0, -16 },
  { 823, 8, 16, 9, 0, -16 },
  { 839, 17, 16, 17, 0, -16 },
  { 873, 14, 16, 14, 0, -16 },
  { 901, 12, 17, 13, 1, -17 },
  { 927, 12, 16, 11, 0, -16 },
  { 951, 12, 21, 13, 1, -17 },
  { 983, 11, 16, 11, 0, -16 },
  { 1005, 11, 17, 10, 0, -17 },
  { 1029, 9, 16, 10, 2, -16 },
  { 1047, 12, 16, 13, 1, -16 },
  { 1071, 11, 16, 11, 2, -16 },
  { 1093, 17, 16, 17, 2, -16 },
  { 1127, 13, 16, 11, -1, -16 },
  { 1153, 10, 16, 10, 2, -16 },
  { 1173, 12, 16, 10, -1, -16 },
  { 1197, 9, 20, 7, -1, -16 },
  { 1220, 5, 17, 9, 2, -17 },
  { 1231, 9, 20, 7, -2, -16 },
  { 1254, 10, 9, 11, 0, -16 },
  { 1266, 8, 2, 8, -2, 2 },
  { 1268, 4, 4, 7, 3, -18 },
  { 1270, 10, 13, 11, 1, -13 },
  { 1287, 11, 17, 11, 0, -17 },
  { 1311, 8, 13, 9, 1, -13 },
  { 1324, 11, 17, 11, 1, -17 },
  { 1348, 9, 13, 10, 1, -13 },
  { 1363, 12, 24, 7, -3, -18 },
  { 1399, 11, 19, 11, 0, -13 },
  { 1426, 10, 17, 11, 0, -17 },
  { 1448, 6, 17, 5, 0, -17 },
  { 1461, 9, 23, 5, -3, -17 },
  { 1487, 11, 17, 10, 0, -17 },
  { 1511, 6, 17, 5, 0, -17 },
  { 1524, 16, 13, 17, 0, -13 },
  { 1550, 10, 13, 11, 0, -13 },
  { 1567, 9, 13, 11, 1, -13 },
  { 1582, 12, 18, 11, -1, -13 },
  { 1609, 10, 19, 11, 1, -13 },
  { 1633, 9, 13, 8, 0, -13 },
  { 1648, 9, 13, 9, 0, -13 },
  { 1663, 7, 15, 7, 1, -15 },
  { 1677, 10, 12, 11, 1, -12 },
  { 1692, 10, 12, 9, 1, -12 },
  { 1707, 15, 12, 15, 1, -12 },
  { 1730, 12, 12, 10, -1, -12 },
  { 1748, 13, 18, 10, -2, -12 },
  { 1778, 10, 12, 8, -1, -12 },
  { 1793, 9, 20, 8, 0, -16 },
  { 1816, 2, 23, 10, 4, -18 },
  { 1822, 9, 20, 8, -1, -16 },
  { 1845, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC23PT7B_H_
