#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x3F, 0x1F, 0x3E, 0x3F, 0x3E, 0x3F,
  0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC2, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xEE, 0x70, 0x1F, 0x9C, 0x20, 0x3E, 0x30, 0x00, 0x7C, 0x60, 0x00,
  0xF9, 0xC0, 0x01, 0xF3, 0x80, 0x03, 0xF6, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3B, 0xF0, 0x00, 0x63,
  0xE0, 0x00, 0xC7, 0xC0, 0x01, 0x8F, 0x84, 0x07, 0x3F, 0x0C, 0x0E, 0x7E,
  0x1F, 0x1B, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xF0,
  0x0F, 0xF0, 0x03, 0xE0, 0x3F, 0xE0, 0x07, 0x80, 0xFF, 0xE0, 0x1E, 0x03,
  0xE3, 0xC0, 0x7C, 0x07, 0x87, 0x80, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0x3E,
  0x1E, 0x07, 0x80, 0x78, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x7C, 0x03, 0xE1,
  0xF0, 0xF0, 0x07, 0xC3, 0xE3, 0xE0, 0x0F, 0x07, 0x87, 0x80, 0x1E, 0x0F,
  0x1E, 0x00, 0x3C, 0x3E, 0x7C, 0x3C, 0x78, 0x78, 0xF1, 0xFE, 0xF1, 0xF3,
  0xE7, 0xFD, 0xE3, 0xC7, 0x9F, 0xFF, 0xFF, 0x9E, 0x3C, 0xFF, 0xFE, 0x7C,
  0xF8, 0xF7, 0xF8, 0xF1, 0xE1, 0xE7, 0xE3, 0xE7, 0xC3, 0xC0, 0x07, 0x8F,
  0x07, 0x80, 0x1E, 0x1E, 0x0F, 0x00, 0x7C, 0x7C, 0x1E, 0x00, 0xF0, 0xF8,
  0x7C, 0x03, 0xE1, 0xE0, 0xF8, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0x07, 0x83,
  0xC0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x3C, 0x7C,
  0x07, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0x80,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x1F, 0x87, 0xFF, 0x83, 0xE1,
  0xFF, 0xF8, 0xFC, 0x3F, 0x3F, 0x1F, 0x0F, 0xC7, 0xE7, 0xE3, 0xF0, 0x7E,
  0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0x80, 0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x7E,
  0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFF,
  0x03, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xC0, 0xFF,
  0xF9, 0xFC, 0x07, 0xFC, 0x1F, 0x80, 0x08, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x20, 0x78, 0x03, 0x87, 0x80, 0x7E, 0x78, 0x17,
  0xFF, 0x3E, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x9F,
  0x07, 0xF8, 0x00, 0xFB, 0xC0, 0x1F, 0xBC, 0x07, 0xF3, 0xE0, 0x3E, 0x1F,
  0x01, 0xE1, 0xF0, 0x0C, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF,
  0x00, 0x1C, 0x7E, 0x7F, 0xFE, 0xFE, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E,
  0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F,
  0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0x7C, 0xFE, 0xFC, 0x78, 0xFC, 0x30, 0xF8,
  0x20, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x7E, 0x01, 0xC0, 0x7F, 0x00, 0x80, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x38, 0x1F, 0xC0, 0x40, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x10,
  0x01, 0xFC, 0x30, 0x07, 0xF0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xF1, 0xF8, 0x01,
  0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x0F,
  0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xE2, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x80,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x10, 0x01,
  0xFC, 0x30, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0xF8,
  0x03, 0xE7, 0xF8, 0x1F, 0xBF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFE, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C,
  0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x9F, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07,
  0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFE,
  0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8,
  0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFE, 0x1F,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xC0,
  0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x3C, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10,
  0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0x03, 0xF1, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x01, 0xFF,
  0x8F, 0x1F, 0x07, 0xFF, 0x0F, 0x1E, 0x0F, 0xFF, 0x0F, 0x3C, 0x1F, 0x0F,
  0x0F, 0x3C, 0x1E, 0x1F, 0x0F, 0x7C, 0x3C, 0x1E, 0x0F, 0x78, 0x3C, 0x1E,
  0x0F, 0x78, 0x78, 0x1E, 0x0F, 0x78, 0x78, 0x3E, 0x0F, 0xF0, 0xF8, 0x3C,
  0x1E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x7C,
  0x3C, 0xF0, 0xF0, 0x78, 0x3C, 0xF0, 0xF0, 0xF8, 0x7C, 0xF0, 0xF0, 0xF8,
  0x78, 0xF0, 0xF9, 0xFC, 0xF0, 0xF0, 0xFF, 0xBF, 0xF0, 0xF0, 0x7F, 0xBF,
  0xE0, 0xF0, 0x3E, 0x1F, 0x80, 0xF0, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x18, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x1F, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03,
  0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x3E, 0x7F, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x83,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0,
  0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xF0, 0x70, 0x1F, 0xE0, 0x10, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0x00,
  0x7E, 0x0F, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x0F, 0x83, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC,
  0x0F, 0x01, 0xFE, 0x00, 0x20, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xE1, 0xF8, 0x0F, 0xFC, 0x3F, 0x03, 0xFF,
  0x8F, 0xE0, 0x7F, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xF0,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xE0,
  0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x43, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0x3E,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07,
  0xDF, 0x80, 0x7C, 0xF0, 0x1F, 0x7E, 0x01, 0xF3, 0xC0, 0xF9, 0xF8, 0x07,
  0xCF, 0x03, 0xE7, 0xC0, 0x3F, 0x3C, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x7C,
  0xFC, 0x03, 0xE3, 0xE1, 0xF3, 0xF0, 0x0F, 0x8F, 0x8F, 0x8F, 0x80, 0x3E,
  0x3E, 0x3E, 0x3E, 0x01, 0xF8, 0xF9, 0xF0, 0xF8, 0x07, 0xC3, 0xE7, 0xC7,
  0xE0, 0x1F, 0x0F, 0xBE, 0x1F, 0x80, 0x7C, 0x3E, 0xF8, 0x7C, 0x03, 0xF0,
  0xFF, 0xC1, 0xF0, 0x0F, 0xC3, 0xFF, 0x0F, 0xC0, 0x3E, 0x0F, 0xF8, 0x3F,
  0x00, 0xF8, 0x3F, 0xE0, 0xFC, 0x03, 0xE0, 0xFF, 0x03, 0xE0, 0x1F, 0x83,
  0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7C, 0x07, 0xF8, 0x01, 0xF8, 0x0F, 0xF0,
  0x03, 0xE0, 0x1F, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0xC0,
  0x3F, 0x01, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x01,
  0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x1F, 0x7C, 0x0F, 0xC0, 0x7E, 0xF8, 0x1F,
  0x80, 0xF9, 0xF0, 0x3E, 0x01, 0xF3, 0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0xF8,
  0x07, 0xC7, 0xC3, 0xF0, 0x1F, 0x8F, 0x87, 0xE0, 0x3E, 0x1F, 0x8F, 0x80,
  0x7C, 0x3F, 0x1F, 0x00, 0xF8, 0x3E, 0x3E, 0x03, 0xF0, 0x7C, 0xFC, 0x07,
  0xE0, 0xF9, 0xF0, 0x0F, 0x81, 0xFB, 0xE0, 0x1F, 0x01, 0xF7, 0xC0, 0x3E,
  0x03, 0xEF, 0x80, 0xFC, 0x07, 0xDF, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0x3F, 0xE0, 0x3F, 0x00,
  0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xF0, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xF8, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F,
  0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xC7, 0xFC, 0x07, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0xFF, 0x07, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC1, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC7, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0x81, 0xFC, 0x07, 0xC1, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x0F, 0x81, 0xFC,
  0x02, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x18, 0x01, 0xF8, 0x3C, 0x0F, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x03,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xFC, 0x01, 0xF3,
  0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0xFF, 0x00, 0xF8, 0xFC, 0x07, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0xC0, 0x7E, 0x3F, 0x03, 0xFE, 0x03, 0xE1, 0xF8,
  0x1E, 0xF0, 0x3F, 0x0F, 0xC1, 0xF7, 0x81, 0xF0, 0x7E, 0x0F, 0xBC, 0x1F,
  0x83, 0xF0, 0x79, 0xE0, 0xFC, 0x1F, 0x87, 0xCF, 0x07, 0xC0, 0xFC, 0x3E,
  0x78, 0x7E, 0x07, 0xE3, 0xE3, 0xC3, 0xE0, 0x3F, 0x1F, 0x1E, 0x3F, 0x01,
  0xF9, 0xF0, 0xF1, 0xF8, 0x0F, 0xCF, 0x87, 0x8F, 0x80, 0x7E, 0x7C, 0x7C,
  0xFC, 0x03, 0xF7, 0xC3, 0xE7, 0xC0, 0x1F, 0xBE, 0x1F, 0x7E, 0x00, 0xFD,
  0xE0, 0xFB, 0xF0, 0x07, 0xDF, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFE, 0xF8, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0,
  0x7C, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x03,
  0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xDF,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x10, 0x00,
  0x01, 0xFC, 0x7C, 0x07, 0xFC, 0xF8, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFE, 0x7F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0xFC, 0x7E,
  0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x1F, 0x87, 0xF8, 0x3F, 0x9F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xEF, 0x80,
  0xFF, 0x9F, 0x00, 0xFE, 0x3E, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC3, 0x00, 0x1F, 0x3F, 0x80, 0x3E, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8,
  0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x9F, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x9F, 0xF8, 0x1F, 0x1F, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xE3, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x83, 0xFC, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x03, 0xE0, 0x03,
  0xF8, 0xF8, 0x01, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07,
  0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x1F, 0xE0, 0x1F, 0xCF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0x00, 0x3F, 0xE7, 0xC0, 0x07,
  0xF1, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x1F, 0x0F, 0xC1, 0xF1,
  0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x87, 0xF0, 0x30, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x1F, 0xF3, 0xE0,
  0x1F, 0xFD, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x3F, 0x9F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0xF8, 0x03,
  0xFE, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x40, 0x07, 0xE0,
  0x38, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0x00, 0x1F, 0x3F, 0xC0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F,
  0x81, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xFC,
  0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x30, 0x03,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC3, 0xF0,
  0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0x9F, 0x00,
  0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x78, 0xFE, 0x0F, 0xF0, 0x0F, 0x3F, 0xE3, 0xFE, 0x03,
  0xEF, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x9F,
  0x81, 0xFC, 0x3F, 0xC1, 0xF8, 0x7F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x07, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xC0,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x1F, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x1F,
  0x87, 0xE0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x7C, 0x1F, 0x81, 0xF8,
  0x0F, 0x83, 0xE0, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0xC0, 0x07, 0x8F, 0xF0, 0x0F, 0x3F, 0xF0, 0x3E, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x9F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF1, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x3E, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xF7,
  0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x78, 0xFE, 0x00, 0x3C, 0xFF,
  0x80, 0x3E, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0xE7, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xBF, 0xF8,
  0x07, 0xDF, 0xF8, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0x40, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xFC, 0x7C, 0x07, 0xFC, 0xF8, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC,
  0x7F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x7E, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x1F,
  0x87, 0xF8, 0x3F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xEF, 0x80, 0xFF,
  0xBF, 0x00, 0xFE, 0x7E, 0x00, 0x20, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x78, 0xFC, 0x0F, 0x3F, 0x83, 0xEF,
  0xE0, 0x7D, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x10, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x83,
  0x87, 0xE0, 0x20, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x20, 0x1F, 0xC7, 0x8F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFA, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0xC4, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x18, 0x00, 0x0F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x01,
  0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F,
  0xCF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E, 0x03, 0xF8,
  0xF0, 0x01, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF8,
  0xF8, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C,
  0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xDF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0x81, 0xF7,
  0xC0, 0xFF, 0x07, 0xEF, 0x81, 0xFE, 0x0F, 0xDF, 0x07, 0xFC, 0x1F, 0x3E,
  0x0F, 0xF8, 0x7E, 0x7C, 0x1F, 0xF0, 0xF8, 0xF8, 0x7F, 0xE3, 0xF1, 0xF0,
  0xF7, 0xC7, 0xC3, 0xE3, 0xEF, 0x8F, 0x87, 0xC7, 0x9F, 0x3F, 0x0F, 0x9F,
  0x3C, 0x7C, 0x1F, 0x3E, 0x79, 0xF8, 0x3E, 0x78, 0xF3, 0xE0, 0x7D, 0xF1,
  0xE7, 0xC0, 0xFB, 0xC3, 0xDF, 0x01, 0xF7, 0x87, 0xBE, 0x03, 0xFF, 0x0F,
  0x7C, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFB,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 37, 13, 0, -36 },
  { 66, 16, 13, 20, 5, -36 },
  { 92, 27, 36, 26, 0, -36 },
  { 214, 23, 41, 23, 0, -38 },
  { 332, 31, 36, 36, 3, -36 },
  { 472, 27, 37, 27, 0, -36 },
  { 597, 8, 13, 11, 5, -36 },
  { 610, 17, 44, 14, 1, -36 },
  { 704, 17, 44, 14, -4, -36 },
  { 798, 20, 20, 22, 4, -38 },
  { 848, 21, 24, 24, 2, -30 },
  { 911, 10, 13, 12, -2, -6 },
  { 928, 13, 5, 15, 1, -16 },
  { 937, 8, 8, 12, 0, -7 },
  { 945, 26, 36, 19, -3, -36 },
  { 1062, 22, 37, 23, 1, -36 },
  { 1164, 16, 36, 23, 5, -36 },
  { 1236, 24, 36, 23, -1, -36 },
  { 1344, 23, 37, 23, 0, -36 },
  { 1451, 24, 36, 23, -1, -36 },
  { 1559, 23, 37, 23, 0, -36 },
  { 1666, 22, 37, 23, 2, -36 },
  { 1768, 23, 36, 23, 2, -36 },
  { 1872, 23, 37, 23, 0, -36 },
  { 1979, 22, 37, 23, 1, -36 },
  { 2081, 12, 29, 12, 0, -28 },
  { 2125, 15, 35, 12, -3, -28 },
  { 2191, 21, 24, 24, 2, -30 },
  { 2254, 21, 15, 24, 2, -25 },
  { 2294, 21, 24, 24, 2, -30 },
  { 2357, 18, 37, 18, 2, -36 },
  { 2441, 32, 40, 35, 2, -36 },
  { 2601, 25, 36, 25, -3, -36 },
  { 2714, 25, 36, 25, 0, -36 },
  { 2827, 25, 37, 24, 2, -36 },
  { 2943, 27, 36, 27, 0, -36 },
  { 3065, 24, 36, 22, 0, -36 },
  { 3173, 24, 36, 21, 0, -36 },
  { 3281, 27, 37, 28, 2, -36 },
  { 3406, 29, 36, 28, 0, -36 },
  { 3537, 21, 36, 16, -2, -36 },
  { 3632, 22, 46, 13, -8, -36 },
  { 3759, 29, 36, 24, 0, -36 },
  { 3890, 17, 36, 20, 0, -36 },
  { 3967, 38, 36, 37, 0, -36 },
  { 4138, 31, 36, 30, 0, -36 },
  { 4278, 27, 37, 29, 2, -36 },
  { 4403, 25, 36, 24, 0, -36 },
  { 4516, 27, 45, 29, 2, -36 },
  { 4668, 25, 36, 25, 0, -36 },
  { 4781, 23, 37, 22, 0, -36 },
  { 4888, 21, 36, 21, 4, -36 },
  { 4983, 27, 37, 28, 2, -36 },
  { 5108, 24, 36, 24, 4, -36 },
  { 5216, 37, 36, 37, 4, -36 },
  { 5383, 30, 36, 23, -3, -36 },
  { 5518, 23, 36, 22, 4, -36 },
  { 5622, 26, 36, 21, -2, -36 },
  { 5739, 19, 44, 15, -1, -36 },
  { 5844, 10, 36, 19, 5, -36 },
  { 5889, 20, 44, 15, -4, -36 },
  { 5999, 23, 22, 23, 0, -36 },
  { 6063, 18, 4, 17, -5, 4 },
  { 6072, 9, 8, 14, 7, -38 },
  { 6081, 23, 29, 24, 1, -28 },
  { 6165, 23, 39, 24, 0, -38 },
  { 6278, 19, 29, 19, 1, -28 },
  { 6347, 26, 39, 24, 1, -38 },
  { 6474, 20, 29, 22, 1, -28 },
  { 6547, 26, 50, 14, -6, -38 },
  { 6710, 25, 40, 25, -1, -28 },
  { 6835, 23, 38, 24, 0, -38 },
  { 6945, 14, 38, 12, 0, -38 },
  { 7012, 20, 50, 12, -6, -38 },
  { 7137, 24, 38, 22, 0, -38 },
  { 7251, 14, 38, 12, 0, -38 },
  { 7318, 35, 28, 36, 0, -28 },
  { 7441, 23, 28, 24, 0, -28 },
  { 7522, 21, 29, 24, 1, -28 },
  { 7599, 25, 40, 24, -2, -28 },
  { 7724, 23, 40, 24, 1, -28 },
  { 7839, 19, 28, 17, 0, -28 },
  { 7906, 19, 29, 19, 0, -28 },
  { 7975, 15, 34, 15, 2, -33 },
  { 8039, 22, 28, 24, 2, -27 },
  { 8116, 20, 27, 21, 3, -27 },
  { 8184, 31, 27, 32, 3, -27 },
  { 8289, 25, 27, 21, -2, -27 },
  { 8374, 27, 39, 21, -4, -27 },
  { 8506, 21, 27, 18, -2, -27 },
  { 8577, 19, 44, 17, 1, -36 },
  { 8682, 5, 50, 21, 8, -38 },
  { 8714, 19, 44, 17, -3, -36 },
  { 8819, 21, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC50PT7B_H_
