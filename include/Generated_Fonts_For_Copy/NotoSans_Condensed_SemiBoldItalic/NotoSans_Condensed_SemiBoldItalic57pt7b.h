#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x10,
  0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF7, 0xF1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x10, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x10, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0x38, 0xE0, 0x1F, 0x8E, 0x08, 0x07, 0xE3, 0x00, 0x03, 0xF0, 0xC0, 0x00,
  0xFC, 0x70, 0x00, 0x3F, 0x9C, 0x00, 0x0F, 0xE7, 0x00, 0x01, 0xFD, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x67, 0xF0, 0x00, 0x39, 0xFC,
  0x00, 0x0E, 0x3F, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0xC3, 0xF0, 0x80, 0x31,
  0xFC, 0x38, 0x1C, 0x7E, 0x0F, 0xC7, 0x7F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x3F, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0xF0,
  0x03, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x3F,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0xF8,
  0x1F, 0x1F, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x3E, 0x1F,
  0x8F, 0x83, 0xE7, 0xC3, 0xFC, 0xF8, 0x7C, 0x7C, 0x7F, 0xEF, 0x87, 0xCF,
  0x8F, 0xFE, 0xFC, 0xF8, 0xF9, 0xFF, 0xF7, 0xFF, 0x9F, 0x1F, 0x1F, 0x7F,
  0xF3, 0xE3, 0xE1, 0xF3, 0xFE, 0x3E, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1,
  0xF0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x01, 0xF8,
  0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x83,
  0xE0, 0x0F, 0x80, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x00, 0xFF, 0xF0, 0x07,
  0xC0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0x81, 0xFF, 0xF0, 0x7F, 0x07, 0xF7,
  0xF0, 0xFC, 0x1F, 0xCF, 0xE1, 0xF8, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x1F,
  0xCF, 0xC3, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xFE, 0x0F, 0xC0, 0x3F,
  0xF8, 0x1F, 0x80, 0x7F, 0xF0, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0,
  0x0F, 0xFF, 0x87, 0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xC3, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x81, 0xF8, 0x07, 0x87, 0xC0, 0x1F, 0x9F,
  0x00, 0x7F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xDF, 0x00, 0xFE, 0x7C, 0x07, 0xF9, 0xF8, 0x0F, 0xC3, 0xE0, 0x1E, 0x0F,
  0xC0, 0x30, 0x3F, 0x00, 0x40, 0x70, 0x00, 0x01, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xE0, 0x1E, 0x1F, 0x9F, 0xCF, 0xFF, 0xF7, 0xF9, 0xFC,
  0xFC, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF,
  0xCF, 0xF7, 0xF1, 0xF1, 0xF8, 0x78, 0x7E, 0x0C, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0xF0,
  0x07, 0x80, 0x7F, 0x00, 0x20, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xF0, 0x0E, 0x03, 0xFC, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x20, 0x00,
  0xFF, 0x0C, 0x00, 0x7F, 0x83, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF8,
  0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7C,
  0x7F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x20, 0x00,
  0xFF, 0x0C, 0x00, 0x7F, 0x83, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x18, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0xF0, 0x1F, 0xBF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE1, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00,
  0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8,
  0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF8, 0x3F, 0xE1,
  0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFE, 0xFC,
  0x07, 0xFE, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x18, 0x1F,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x02,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xC7, 0xF8, 0x38, 0x0F, 0xE1, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x7F, 0x81, 0xF0,
  0xF8, 0x0F, 0xFF, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x7C, 0x7C, 0x0F, 0xFF,
  0xC3, 0xE3, 0xE0, 0xFC, 0x3C, 0x1F, 0x3E, 0x0F, 0xC3, 0xE0, 0xF9, 0xF0,
  0x7C, 0x1F, 0x07, 0xCF, 0x07, 0xC0, 0xF8, 0x3E, 0xF8, 0x3E, 0x07, 0xC1,
  0xF7, 0xC3, 0xE0, 0x7C, 0x0F, 0x3C, 0x1F, 0x03, 0xE0, 0x79, 0xE0, 0xF8,
  0x1F, 0x07, 0xDF, 0x07, 0x80, 0xF8, 0x3E, 0xF8, 0x7C, 0x0F, 0x81, 0xE7,
  0xC3, 0xE0, 0x7C, 0x1F, 0x3E, 0x1F, 0x03, 0xE0, 0xF9, 0xE0, 0xF8, 0x3F,
  0x07, 0x8F, 0x07, 0xC1, 0xF0, 0x7C, 0x78, 0x3E, 0x1F, 0xC7, 0xC3, 0xC1,
  0xF9, 0xFE, 0x7C, 0x1E, 0x07, 0xFE, 0xFF, 0xE0, 0xF8, 0x3F, 0xE7, 0xFE,
  0x07, 0xC0, 0xFE, 0x1F, 0xC0, 0x3E, 0x01, 0xC0, 0x38, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0x00, 0x00, 0xFF, 0xC1, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0x87, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0x80,
  0x7F, 0xC0, 0x08, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x20, 0x07, 0xFE, 0x3E, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC1, 0xFF, 0x80, 0x3F, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0xF8, 0xFE, 0x01, 0xFF, 0xE3, 0xF8, 0x07, 0xFF,
  0x8F, 0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFE,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x01, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xF8, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x03, 0xF1, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xFE, 0x01,
  0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x03, 0xFB, 0xF0, 0x1F,
  0x3F, 0x00, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x03, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x7C, 0x7F, 0x01, 0xF8,
  0xFC, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xC7,
  0xE1, 0xF8, 0x07, 0xE1, 0xF1, 0xF8, 0xFE, 0x01, 0xF8, 0x7C, 0xFC, 0x3F,
  0x80, 0xFC, 0x1F, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x0F,
  0xC1, 0xF7, 0xE0, 0xFC, 0x03, 0xF0, 0x7D, 0xF0, 0x7F, 0x00, 0xFC, 0x1F,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xFF, 0x81,
  0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0x80, 0x3F,
  0x3F, 0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x3F, 0x00, 0x7E, 0x3F, 0x03, 0xF0,
  0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0xFC,
  0x0F, 0xCF, 0xE0, 0x0F, 0xC0, 0xFC, 0xFC, 0x00, 0xFC, 0x0F, 0xCF, 0xC0,
  0x0F, 0xC0, 0xFC, 0xFC, 0x01, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x7E,
  0xFC, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF9, 0xF8, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF,
  0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF9,
  0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7E, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xC0, 0x1F,
  0xC0, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x1F, 0xC0, 0x78, 0x07, 0xFC,
  0x07, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF3,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFB,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xDF, 0x01, 0xF8, 0x3F, 0x01, 0xF7, 0xC0, 0xFE, 0x0F, 0xC0, 0xFD,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x9F, 0x07,
  0xF0, 0x3F, 0x07, 0xEF, 0xC1, 0xF8, 0x0F, 0xC1, 0xF3, 0xF0, 0xFE, 0x03,
  0xF0, 0xFC, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F,
  0x8F, 0xC7, 0xF0, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0xFC,
  0xFE, 0x00, 0xFC, 0xFC, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x0F, 0xCF, 0xC0,
  0x0F, 0xCF, 0x83, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x00, 0xFD,
  0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xBF, 0x00, 0x0F, 0xFE, 0x03,
  0xEF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0x80, 0xF8,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xE0,
  0xF8, 0x3F, 0x07, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xE3, 0xE0, 0x3F,
  0xFD, 0xF8, 0x1F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF8, 0x3F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x7F,
  0xFB, 0xF0, 0x0F, 0xFC, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0xFF, 0xC0, 0x3F, 0x7F,
  0xF8, 0x0F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F,
  0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xF0, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7D, 0xFF,
  0xF0, 0x3F, 0x3F, 0xF8, 0x0F, 0x87, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xF8, 0x30, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0x07, 0xF8, 0x38, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xF9, 0xF8,
  0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xF0, 0x03, 0xFF,
  0x3E, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0x83, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x3F, 0x80, 0xFC, 0xFC, 0x03,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0x7E, 0x0F, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x43, 0xFC, 0x03, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xE1, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F,
  0xFE, 0xFC, 0x01, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x1F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xC1, 0xFF, 0x00, 0xFE, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x08, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x40, 0x03, 0xF8, 0x03, 0xC0, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC1,
  0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF1, 0xFE,
  0x07, 0xF8, 0x07, 0xE7, 0xFE, 0x1F, 0xF8, 0x0F, 0x9F, 0xFE, 0x7F, 0xF8,
  0x1F, 0x7F, 0xFD, 0xFF, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7,
  0xFF, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0xFC, 0xFF, 0xC0,
  0x3E, 0x7F, 0xF8, 0x0F, 0xBF, 0xFE, 0x03, 0xEF, 0xFF, 0xC0, 0xFF, 0x8F,
  0xF0, 0x7F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFE, 0x3F, 0xC7, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0x7E,
  0x7F, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80,
  0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFE, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xF3,
  0xFF, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0xFB, 0xFF, 0xE0, 0x07, 0xDF, 0xFF,
  0x80, 0x3F, 0xE3, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFD, 0xFF, 0xE0, 0x07, 0xE7, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0,
  0x30, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xF3, 0xE0, 0x3F, 0xFC, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0,
  0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFD, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F,
  0x7F, 0x80, 0xFD, 0xFE, 0x03, 0xEF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xF1,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0x81, 0xC0,
  0xFC, 0x01, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x80, 0x1F, 0xC3, 0x80, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x10, 0x7F, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x08, 0x00, 0x07, 0xE0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xE1, 0xF8, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0x7E, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0x9F, 0x00, 0xFF, 0x0F, 0x80, 0x04,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0x7E, 0x07, 0xFC,
  0x07, 0xEF, 0xC0, 0xFF, 0x81, 0xF9, 0xF8, 0x1F, 0xF0, 0x3F, 0x3F, 0x07,
  0xFE, 0x0F, 0xE7, 0xE0, 0xFF, 0xC1, 0xF8, 0xF8, 0x3E, 0xF8, 0x3F, 0x1F,
  0x07, 0xDF, 0x0F, 0xC3, 0xE0, 0xFB, 0xE1, 0xF8, 0x7C, 0x3E, 0x7C, 0x7E,
  0x0F, 0x87, 0xCF, 0x8F, 0xC1, 0xF1, 0xF3, 0xF1, 0xF8, 0x3E, 0x3E, 0x7C,
  0x7E, 0x07, 0xC7, 0xCF, 0x8F, 0xC0, 0xF9, 0xF1, 0xF3, 0xF0, 0x1F, 0x3E,
  0x3E, 0x7E, 0x03, 0xEF, 0x87, 0xCF, 0xC0, 0x7D, 0xF0, 0xFB, 0xF0, 0x0F,
  0xBE, 0x1F, 0x7E, 0x01, 0xFF, 0x83, 0xEF, 0x80, 0x3F, 0xF0, 0x7F, 0xF0,
  0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xE0,
  0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x01, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x40, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFE, 0x80, 0x1F, 0xFC, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 42, 14, 0, -41 },
  { 85, 18, 15, 22, 6, -41 },
  { 119, 31, 41, 29, 0, -41 },
  { 278, 26, 46, 26, 1, -43 },
  { 428, 36, 42, 41, 3, -41 },
  { 617, 31, 42, 31, 0, -41 },
  { 780, 9, 15, 13, 6, -41 },
  { 797, 19, 50, 16, 1, -41 },
  { 916, 19, 50, 16, -4, -41 },
  { 1035, 22, 24, 25, 5, -44 },
  { 1101, 23, 28, 28, 3, -34 },
  { 1182, 12, 15, 14, -3, -7 },
  { 1205, 14, 6, 17, 1, -18 },
  { 1216, 9, 9, 14, 0, -8 },
  { 1227, 29, 41, 21, -3, -41 },
  { 1376, 24, 42, 26, 2, -41 },
  { 1502, 18, 41, 26, 6, -41 },
  { 1595, 28, 41, 26, -2, -41 },
  { 1739, 26, 42, 26, 0, -41 },
  { 1876, 27, 41, 26, -1, -41 },
  { 2015, 26, 42, 26, 0, -41 },
  { 2152, 25, 42, 26, 2, -41 },
  { 2284, 27, 41, 26, 2, -41 },
  { 2423, 27, 42, 26, 0, -41 },
  { 2565, 25, 42, 26, 1, -41 },
  { 2697, 13, 32, 14, 0, -31 },
  { 2749, 16, 39, 14, -3, -31 },
  { 2827, 24, 27, 28, 3, -34 },
  { 2908, 24, 16, 28, 3, -28 },
  { 2956, 24, 27, 28, 3, -34 },
  { 3037, 21, 42, 20, 2, -41 },
  { 3148, 37, 46, 40, 2, -41 },
  { 3361, 29, 41, 28, -4, -41 },
  { 3510, 29, 41, 29, 0, -41 },
  { 3659, 28, 42, 27, 3, -41 },
  { 3806, 30, 41, 31, 0, -41 },
  { 3960, 27, 41, 25, 0, -41 },
  { 4099, 27, 41, 23, 0, -41 },
  { 4238, 30, 42, 32, 3, -41 },
  { 4396, 34, 41, 32, 0, -41 },
  { 4571, 24, 41, 18, -2, -41 },
  { 4694, 25, 53, 14, -9, -41 },
  { 4860, 32, 41, 28, 1, -41 },
  { 5024, 20, 41, 23, 0, -41 },
  { 5127, 42, 41, 42, 1, -41 },
  { 5343, 36, 41, 34, 0, -41 },
  { 5528, 29, 42, 33, 3, -41 },
  { 5681, 29, 41, 28, 0, -41 },
  { 5830, 29, 51, 33, 3, -41 },
  { 6015, 27, 41, 28, 1, -41 },
  { 6154, 28, 42, 25, -1, -41 },
  { 6301, 23, 41, 24, 5, -41 },
  { 6419, 30, 42, 32, 3, -41 },
  { 6577, 27, 41, 27, 5, -41 },
  { 6716, 42, 41, 42, 5, -41 },
  { 6932, 34, 41, 26, -3, -41 },
  { 7107, 25, 41, 25, 5, -41 },
  { 7236, 29, 41, 24, -2, -41 },
  { 7385, 23, 50, 17, -2, -41 },
  { 7529, 11, 41, 21, 6, -41 },
  { 7586, 22, 50, 17, -4, -41 },
  { 7724, 26, 25, 26, 0, -41 },
  { 7806, 20, 4, 19, -5, 5 },
  { 7816, 10, 9, 16, 8, -44 },
  { 7828, 26, 32, 28, 2, -31 },
  { 7932, 26, 44, 28, 0, -43 },
  { 8075, 21, 32, 22, 2, -31 },
  { 8159, 28, 44, 28, 2, -43 },
  { 8313, 22, 32, 25, 2, -31 },
  { 8401, 30, 58, 16, -7, -44 },
  { 8619, 29, 45, 28, -1, -31 },
  { 8783, 26, 43, 28, 0, -43 },
  { 8923, 15, 43, 13, 0, -43 },
  { 9004, 23, 57, 13, -7, -43 },
  { 9168, 28, 43, 25, 0, -43 },
  { 9319, 16, 43, 13, 0, -43 },
  { 9405, 39, 31, 41, 0, -31 },
  { 9557, 26, 31, 28, 0, -31 },
  { 9658, 23, 32, 27, 2, -31 },
  { 9750, 29, 45, 28, -3, -31 },
  { 9914, 26, 45, 28, 2, -31 },
  { 10061, 22, 31, 19, 0, -31 },
  { 10147, 22, 32, 22, 0, -31 },
  { 10235, 17, 39, 17, 2, -38 },
  { 10318, 25, 32, 28, 2, -31 },
  { 10418, 23, 31, 23, 3, -31 },
  { 10508, 35, 31, 36, 4, -31 },
  { 10644, 29, 31, 24, -3, -31 },
  { 10757, 32, 45, 24, -5, -31 },
  { 10937, 24, 31, 21, -2, -31 },
  { 11030, 22, 50, 19, 1, -41 },
  { 11168, 6, 57, 24, 9, -44 },
  { 11211, 22, 50, 19, -3, -41 },
  { 11349, 24, 8, 28, 3, -24 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC57PT7B_H_
