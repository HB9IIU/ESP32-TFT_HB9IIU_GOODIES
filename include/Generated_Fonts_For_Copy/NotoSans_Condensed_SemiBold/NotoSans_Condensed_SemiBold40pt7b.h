#ifndef _NOTOSANS_CONDENSED_SEMIBOLD40PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0x78, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x0F,
  0x78, 0x73, 0xC3, 0x9C, 0x1C, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x3C, 0x78, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xF9, 0x84, 0xF1, 0x80,
  0xF1, 0x80, 0xF1, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xBE, 0x01, 0x9F, 0x01, 0x9F,
  0x01, 0x9F, 0x81, 0x9F, 0xC1, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x1F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x00,
  0x1C, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x0E, 0x00, 0xF3, 0xC0, 0xF0,
  0x07, 0x9E, 0x07, 0x80, 0x38, 0x70, 0x38, 0x01, 0xC3, 0xC3, 0xC0, 0x1E,
  0x1E, 0x1C, 0x00, 0xF0, 0xF1, 0xE0, 0x07, 0x87, 0x8E, 0x00, 0x3C, 0x3C,
  0xF0, 0x00, 0xE1, 0xE7, 0x84, 0x07, 0x0E, 0x38, 0xFC, 0x3C, 0xF3, 0xCF,
  0xF1, 0xE7, 0x9C, 0xFF, 0x87, 0xF9, 0xE7, 0x9E, 0x1F, 0xCF, 0x38, 0xF0,
  0x78, 0xF3, 0xC3, 0x80, 0x07, 0x9E, 0x1C, 0x00, 0x38, 0xF0, 0xF0, 0x03,
  0xC7, 0x87, 0x80, 0x1C, 0x3C, 0x3C, 0x01, 0xE1, 0xE1, 0xC0, 0x0F, 0x07,
  0x0E, 0x00, 0xF0, 0x38, 0xF0, 0x07, 0x81, 0xE7, 0x80, 0x38, 0x0F, 0xF8,
  0x03, 0xC0, 0x3F, 0xC0, 0x1C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C,
  0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0x1F, 0xF8, 0x3C, 0x3E, 0xF8, 0xF8, 0xF9, 0xF9, 0xF1,
  0xF1, 0xF3, 0xE7, 0xC1, 0xFF, 0x8F, 0x81, 0xFF, 0x1F, 0x03, 0xFC, 0x3E,
  0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x7E, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE7, 0xC0, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xBD,
  0xEF, 0x7B, 0xDC, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7C, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x61, 0xC7, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x0C,
  0x38, 0x04, 0x10, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x7C, 0xF9, 0xE7,
  0xCF, 0x9E, 0x3C, 0x79, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xEF,
  0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE1, 0xF0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07,
  0xDE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x7C, 0x78,
  0x3E, 0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x00,
  0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xFF, 0xDF,
  0x79, 0xF3, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xC3, 0xF1, 0x80, 0xF8, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0,
  0x1F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0x83, 0xF1, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0xC0, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xBE, 0x01, 0xEF, 0x80, 0x73,
  0xE0, 0x3C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8,
  0x78, 0x3E, 0x1E, 0x0F, 0x8F, 0x03, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC,
  0x20, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0xC0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xC1, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x3F, 0x87, 0xBF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFD,
  0xFC, 0x3E, 0xFC, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3E, 0x1F, 0x1F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x79, 0xF0, 0x3C, 0xF8,
  0x1E, 0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F, 0x83, 0xEF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0x7E, 0x3F, 0x1F, 0x9F, 0x07,
  0xCF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C,
  0x0F, 0xBF, 0x9F, 0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7,
  0x80, 0xFB, 0xE0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7,
  0xC1, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00,
  0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x31, 0xFF, 0xFF, 0xFD, 0xE0, 0x3C, 0x7D, 0xFB, 0xF3, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xF3, 0xCF,
  0x9F, 0x3C, 0x78, 0xF3, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF,
  0xE7, 0x87, 0xC4, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x83,
  0xF0, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x1E, 0x78, 0x1F, 0xE3, 0xDE, 0x1F, 0xF8, 0xF7, 0x0F, 0xFE, 0x1F,
  0xC3, 0xC7, 0x87, 0xF1, 0xE1, 0xE1, 0xFC, 0x78, 0x78, 0x7E, 0x1E, 0x1E,
  0x1F, 0x87, 0x07, 0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0x70, 0x78, 0x7E, 0x1C,
  0x1E, 0x1F, 0x87, 0x87, 0x8F, 0xF1, 0xE3, 0xE3, 0xBC, 0x3F, 0xDF, 0xEF,
  0x0F, 0xF7, 0xF1, 0xC1, 0xF8, 0xF8, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00,
  0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0x8F, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xFC, 0xF8, 0x3F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x1F, 0xC7, 0x8F, 0xC0, 0x27, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x81, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0xFC, 0xF8, 0x7F, 0x1F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC1,
  0xE3, 0xF0, 0x04, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3F, 0x81, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xBF, 0xEF, 0xF3, 0xFC, 0xFC,
  0x00, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F,
  0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBF, 0x03, 0xE3, 0xE0, 0x7C, 0x7E,
  0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF8, 0xF8, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xDE, 0x01, 0xEF, 0xF7, 0x80, 0x7B, 0xFD, 0xE0, 0x1E, 0xFF, 0x3C, 0x0F,
  0x3F, 0xCF, 0x03, 0xCF, 0xF3, 0xC0, 0xF3, 0xFE, 0xF0, 0x3C, 0xFF, 0x9E,
  0x1E, 0x3F, 0xE7, 0x87, 0x8F, 0xF9, 0xE1, 0xE3, 0xFE, 0x3C, 0xF0, 0xFF,
  0x8F, 0x3C, 0x3F, 0xE3, 0xCF, 0x0F, 0xF8, 0xF7, 0x83, 0xFE, 0x1F, 0xE0,
  0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x3F, 0x03, 0xFE, 0x0F,
  0xC0, 0xFF, 0x83, 0xF0, 0x3F, 0xE0, 0xF8, 0x0F, 0xF8, 0x1E, 0x03, 0xC0,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xF7, 0xC0, 0xFF, 0x7C,
  0x0F, 0xF3, 0xE0, 0xFF, 0x3E, 0x0F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF8,
  0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0x7C, 0xFF, 0x87, 0xCF, 0xF8, 0x3E, 0xFF,
  0x83, 0xEF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x87, 0xE0, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x80,
  0xFC, 0x3F, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x0F, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x3F, 0x3E, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0,
  0x3F, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xEF,
  0xE7, 0xDF, 0x01, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xBE, 0x01, 0xF7, 0xE0, 0x3E, 0x7E, 0x0F,
  0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x3E, 0x7C,
  0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x3C,
  0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x7C, 0x3E, 0x0E, 0x70, 0x7C, 0x3E,
  0x1E, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1F,
  0x1E, 0x78, 0xF8, 0x1F, 0x3E, 0x78, 0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F,
  0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3D, 0xF0, 0x0F,
  0xF8, 0x1D, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7D,
  0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x00, 0xF9,
  0xF0, 0x0F, 0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01,
  0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x18, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7E, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0x7E, 0x7F, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0x8F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF7, 0xFC, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0xF3,
  0xFF, 0x8F, 0xFE, 0x7E, 0x19, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x27, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xBE, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFE,
  0xF8, 0xFE, 0x3C, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x02, 0x7F, 0x3E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x00,
  0xC0, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0x98, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7F, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x87, 0x8F, 0xF7, 0xCF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xBE, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFE, 0xF8, 0xFE, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x90, 0x07, 0xCF, 0x9F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0,
  0x06, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE0, 0x0F, 0x0F, 0x87, 0xE3, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x87, 0xD7, 0xEF, 0xF7, 0xF3, 0xF0, 0xC0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x0F, 0x8F,
  0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xC0, 0x7B, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xCF, 0x83, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x01, 0xF7,
  0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x7E, 0x39, 0xFF, 0x3F, 0xEF,
  0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFE, 0x0F, 0xC1,
  0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07,
  0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E,
  0x03, 0xFC, 0x07, 0x80, 0xF0, 0xE1, 0xF0, 0xE7, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0xF8,
  0x1F, 0x3E, 0x0F, 0x9F, 0xDF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80,
  0xE1, 0xF0, 0xF7, 0xFC, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xBE, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFE,
  0xF8, 0xFE, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xE1, 0xFC, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0x78, 0x13, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C,
  0x1F, 0xBE, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFE, 0x78, 0xFE, 0x3C,
  0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F,
  0x03, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xF1,
  0xE0, 0x7C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xF8, 0x1F, 0x81, 0xF7, 0x81, 0xF8, 0x1F, 0x78, 0x1F, 0x81,
  0xE7, 0xC1, 0xF8, 0x1E, 0x7C, 0x1F, 0xC3, 0xE3, 0xC3, 0xFC, 0x3E, 0x3C,
  0x3F, 0xC3, 0xC3, 0xE3, 0x9C, 0x3C, 0x3E, 0x39, 0xC7, 0xC3, 0xE3, 0x9E,
  0x7C, 0x1E, 0x79, 0xE7, 0x81, 0xE7, 0x8E, 0x78, 0x1F, 0x70, 0xE7, 0x81,
  0xF7, 0x0E, 0xF8, 0x0F, 0x70, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x9F, 0x03, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0xBF, 0x03, 0xF0, 0xF8, 0x07, 0xFE,
  0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x03, 0xE3, 0xE0,
  0xF0, 0xF8, 0x7C, 0x1E, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0x7F, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x3F,
  0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x7F,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F,
  0x80, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xF0,
  0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF8, 0x00, 0x3F, 0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 29, 10, 2, -29 },
  { 23, 13, 11, 17, 2, -29 },
  { 41, 20, 29, 21, 1, -29 },
  { 114, 16, 32, 20, 2, -30 },
  { 178, 29, 29, 31, 1, -29 },
  { 284, 23, 29, 24, 1, -29 },
  { 368, 5, 11, 9, 2, -29 },
  { 375, 10, 35, 12, 2, -29 },
  { 419, 10, 35, 12, 1, -29 },
  { 463, 16, 16, 18, 1, -30 },
  { 495, 17, 19, 19, 1, -24 },
  { 536, 7, 10, 10, 1, -5 },
  { 545, 10, 4, 12, 1, -13 },
  { 550, 6, 6, 10, 2, -6 },
  { 555, 15, 29, 16, 0, -29 },
  { 610, 17, 29, 19, 1, -29 },
  { 672, 12, 29, 19, 2, -29 },
  { 716, 17, 29, 19, 1, -29 },
  { 778, 17, 29, 19, 1, -29 },
  { 840, 18, 29, 19, 1, -29 },
  { 906, 16, 29, 19, 2, -29 },
  { 964, 17, 29, 19, 1, -29 },
  { 1026, 17, 29, 19, 1, -29 },
  { 1088, 17, 29, 19, 1, -29 },
  { 1150, 17, 29, 19, 1, -29 },
  { 1212, 6, 22, 10, 2, -22 },
  { 1229, 7, 27, 10, 1, -22 },
  { 1253, 17, 19, 19, 1, -24 },
  { 1294, 17, 12, 19, 1, -20 },
  { 1320, 17, 19, 19, 1, -24 },
  { 1361, 15, 29, 15, 0, -29 },
  { 1416, 26, 32, 30, 2, -29 },
  { 1520, 22, 29, 22, 0, -29 },
  { 1600, 17, 29, 22, 3, -29 },
  { 1662, 18, 29, 21, 2, -29 },
  { 1728, 19, 29, 24, 3, -29 },
  { 1797, 14, 29, 19, 3, -29 },
  { 1848, 13, 29, 18, 3, -29 },
  { 1896, 20, 29, 24, 2, -29 },
  { 1969, 19, 29, 25, 3, -29 },
  { 2038, 11, 29, 13, 1, -29 },
  { 2078, 10, 37, 11, -2, -29 },
  { 2125, 19, 29, 21, 3, -29 },
  { 2194, 14, 29, 18, 3, -29 },
  { 2245, 26, 29, 32, 3, -29 },
  { 2340, 20, 29, 27, 3, -29 },
  { 2413, 22, 29, 26, 2, -29 },
  { 2493, 16, 29, 21, 3, -29 },
  { 2551, 22, 36, 26, 2, -29 },
  { 2650, 18, 29, 22, 3, -29 },
  { 2716, 15, 29, 18, 2, -29 },
  { 2771, 17, 29, 18, 1, -29 },
  { 2833, 19, 29, 24, 3, -29 },
  { 2902, 21, 29, 21, 0, -29 },
  { 2979, 32, 29, 32, 0, -29 },
  { 3095, 20, 29, 20, 0, -29 },
  { 3168, 20, 29, 20, 0, -29 },
  { 3241, 16, 29, 18, 1, -29 },
  { 3299, 9, 35, 13, 3, -29 },
  { 3339, 15, 29, 16, 0, -29 },
  { 3394, 9, 35, 13, 1, -29 },
  { 3434, 19, 18, 21, 1, -29 },
  { 3477, 17, 3, 17, 0, 3 },
  { 3484, 9, 7, 12, 2, -31 },
  { 3492, 16, 22, 19, 1, -22 },
  { 3536, 16, 30, 21, 3, -30 },
  { 3596, 14, 22, 17, 2, -22 },
  { 3635, 17, 30, 21, 2, -30 },
  { 3699, 16, 22, 19, 2, -22 },
  { 3743, 14, 31, 12, 0, -31 },
  { 3798, 17, 32, 21, 2, -22 },
  { 3866, 16, 30, 21, 3, -30 },
  { 3926, 6, 30, 10, 2, -30 },
  { 3949, 9, 40, 10, -1, -30 },
  { 3994, 17, 30, 20, 3, -30 },
  { 4058, 4, 30, 10, 3, -30 },
  { 4073, 26, 22, 32, 3, -22 },
  { 4145, 16, 22, 21, 3, -22 },
  { 4189, 17, 22, 21, 2, -22 },
  { 4236, 16, 32, 21, 3, -22 },
  { 4300, 17, 32, 21, 2, -22 },
  { 4368, 11, 22, 14, 3, -22 },
  { 4399, 14, 22, 16, 1, -22 },
  { 4438, 12, 26, 13, 1, -26 },
  { 4477, 17, 22, 21, 2, -22 },
  { 4524, 18, 22, 18, 0, -22 },
  { 4574, 28, 22, 28, 0, -22 },
  { 4651, 18, 22, 18, 0, -22 },
  { 4701, 18, 32, 18, 0, -22 },
  { 4773, 13, 22, 15, 1, -22 },
  { 4809, 12, 35, 15, 1, -29 },
  { 4862, 4, 39, 19, 7, -30 },
  { 4882, 12, 35, 15, 2, -29 },
  { 4935, 17, 6, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_SemiBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD40PT7B_H_
