#ifndef _NOTOSANS_CONDENSED_SEMIBOLD24PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x76, 0x66, 0x66, 0x66, 0x00, 0x7F, 0x70, 0xE7, 0xE7,
  0xE7, 0x67, 0x67, 0x67, 0x0E, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC7,
  0xFF, 0x7F, 0xF1, 0x8C, 0x19, 0xC1, 0x98, 0xFF, 0xFF, 0xFF, 0x19, 0x81,
  0x98, 0x31, 0x83, 0x38, 0x33, 0x00, 0x0C, 0x03, 0x03, 0xF9, 0xFE, 0xEC,
  0xBB, 0x0E, 0xC3, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x3F, 0x0D, 0xE3, 0x7E,
  0xFB, 0xFC, 0x3E, 0x03, 0x00, 0xC0, 0x78, 0x18, 0x7E, 0x18, 0x33, 0x0C,
  0x19, 0xCC, 0x0C, 0xE6, 0x06, 0x77, 0x03, 0x3B, 0x11, 0x99, 0xBE, 0xFD,
  0xBB, 0x3C, 0xD9, 0x80, 0xCC, 0xE0, 0x66, 0x70, 0x73, 0x38, 0x31, 0x9C,
  0x18, 0xEC, 0x18, 0x3E, 0x0C, 0x1E, 0x00, 0x3F, 0x01, 0xF8, 0x1C, 0xE0,
  0xE7, 0x07, 0x38, 0x3B, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x3B, 0xF3, 0xB9,
  0xDD, 0xC7, 0xEE, 0x3E, 0x70, 0xF3, 0xCF, 0x8F, 0xFE, 0x3E, 0x78, 0xFF,
  0xB6, 0xC0, 0x1C, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x86, 0x18, 0x70, 0xC3, 0x86, 0x1C, 0xC3, 0x1C, 0xE3, 0x1C, 0xE7, 0x18,
  0xC6, 0x31, 0x9C, 0xE7, 0x33, 0x99, 0xCC, 0x00, 0x1C, 0x0E, 0x23, 0x3F,
  0xFF, 0xF8, 0xE0, 0xD8, 0xEE, 0x63, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x77, 0x6E, 0xEC,
  0xFF, 0xFF, 0xC0, 0x7F, 0x70, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0,
  0x00, 0x3E, 0x1F, 0xC7, 0x3B, 0x8E, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xB8, 0xE7, 0x39, 0xFC, 0x3E, 0x00, 0x0E,
  0x3C, 0xFB, 0xBE, 0x68, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x7F, 0x3F, 0xCE, 0x39, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x3F, 0xE4, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0xF8, 0x3F, 0x03,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0xEC, 0x7B, 0xFE, 0xFE, 0x00, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x06, 0x61, 0xCC, 0x31, 0x8E, 0x31,
  0x86, 0x7F, 0xFF, 0xFE, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x9F,
  0xE6, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE3, 0xFC, 0x7F, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0xEC, 0x7B, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE7, 0x81,
  0xC0, 0x60, 0x38, 0x0E, 0xF3, 0xFE, 0xF3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x78, 0x00, 0x3F, 0x1F, 0xEE, 0x3B, 0x86, 0xE1, 0x98, 0xE7,
  0xF0, 0xF8, 0x3E, 0x1D, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x3D, 0xFE,
  0x3F, 0x00, 0x3E, 0x1F, 0xCE, 0x3B, 0x8E, 0xE1, 0xB8, 0x7E, 0x1F, 0x8F,
  0xF7, 0xDF, 0xF3, 0xD8, 0x06, 0x03, 0x80, 0xE0, 0xF1, 0xF8, 0x7C, 0x00,
  0x7F, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x70, 0x7F, 0x70, 0x00, 0x00, 0x00,
  0x77, 0x6E, 0xEC, 0x00, 0xC0, 0xF0, 0xF8, 0xF8, 0xF8, 0x38, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x78, 0xF8,
  0xF8, 0x38, 0x08, 0x00, 0x7E, 0x7F, 0x91, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x1C, 0x1C, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x38, 0x00,
  0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x0C, 0x30, 0x06, 0x71, 0xE6, 0x63, 0xF3,
  0xE6, 0x73, 0xC6, 0x73, 0xCE, 0x73, 0xCC, 0x73, 0xCC, 0x63, 0xCE, 0x73,
  0xC7, 0xFE, 0xE7, 0x9C, 0x60, 0x00, 0x70, 0x00, 0x38, 0x10, 0x1F, 0xF0,
  0x07, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x01, 0xDC, 0x0E, 0xE0,
  0x73, 0x03, 0x1C, 0x38, 0xE1, 0xC7, 0x0F, 0xF8, 0x7F, 0xE7, 0x07, 0x38,
  0x39, 0xC1, 0xDE, 0x07, 0xE0, 0x38, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3B, 0xFC, 0xFF, 0xB8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x7F, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0xF1, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x11, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xF3, 0x9F, 0x70, 0xEE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xBF,
  0xF7, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x0F, 0xF1, 0xFF, 0x3C, 0x27, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x07, 0x3C,
  0x73, 0xFF, 0x0F, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xE0, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x3F, 0xFC, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFE, 0xFB, 0x80, 0xE1, 0xFC,
  0x3B, 0x8E, 0x73, 0xCE, 0x71, 0xDC, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0xC3,
  0xBC, 0x73, 0x8E, 0x79, 0xC7, 0x38, 0xF7, 0x0E, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFD, 0x83,
  0x7B, 0x06, 0xF7, 0x1D, 0xF6, 0x3B, 0xEC, 0x67, 0xDC, 0xCF, 0xBB, 0x9F,
  0x36, 0x3E, 0x6C, 0x7C, 0xF8, 0xF8, 0xE1, 0xF1, 0xC3, 0xE3, 0x86, 0xF0,
  0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xDC, 0x7D, 0xC7, 0xCE, 0x7C, 0xE7, 0xE6,
  0x7E, 0x77, 0xE3, 0x7E, 0x3F, 0xE3, 0xBE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xF0, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x77, 0x03, 0xB8, 0x38,
  0xF3, 0xC7, 0xFC, 0x0F, 0xC0, 0xFE, 0x3F, 0xCE, 0x7B, 0x8E, 0xE1, 0xF8,
  0x7E, 0x3B, 0x8E, 0xFF, 0xBF, 0xCF, 0x83, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x77, 0x03,
  0xB8, 0x38, 0xF3, 0xC7, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0xFE, 0x1F, 0xF3, 0x9E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8, 0xE7,
  0x3C, 0xFF, 0x1F, 0xC3, 0xB8, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xE7, 0x0E,
  0xE1, 0xE0, 0x3F, 0xBF, 0xFC, 0x5C, 0x0E, 0x07, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x1F, 0x9F, 0xFE, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0xF3, 0xFE, 0x3F, 0x80, 0xE0, 0x3F,
  0x03, 0x98, 0x1C, 0xE0, 0xE7, 0x06, 0x18, 0x70, 0xE3, 0x87, 0x1C, 0x38,
  0xC0, 0xCE, 0x07, 0x70, 0x3B, 0x01, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x07, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xB8, 0x78, 0x77,
  0x1F, 0x1C, 0xE3, 0x63, 0x9C, 0x6C, 0x71, 0x8D, 0xCE, 0x3B, 0xB9, 0x87,
  0x73, 0x70, 0xEC, 0x6E, 0x1D, 0x8D, 0xC1, 0xB1, 0xF8, 0x3E, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x0E, 0x0F, 0x00, 0xF0, 0xF7, 0x0E, 0x39, 0xC3,
  0x9C, 0x1D, 0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81,
  0xF8, 0x39, 0xC3, 0x9C, 0x70, 0xE7, 0x0E, 0xE0, 0x70, 0xE0, 0xF7, 0x0E,
  0x70, 0xE3, 0x1C, 0x39, 0xC3, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x0C, 0x07, 0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0x80, 0x0C, 0x01, 0xC0, 0x78, 0x0F,
  0x83, 0xB0, 0x67, 0x1C, 0x63, 0x0E, 0xE0, 0xD8, 0x1C, 0xFF, 0xFF, 0xF0,
  0xF3, 0x8E, 0x3F, 0x3F, 0xC8, 0xE0, 0x70, 0x39, 0xFD, 0xFF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFF, 0xB7, 0xD8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37,
  0xCF, 0xFB, 0x8E, 0xE3, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x3B,
  0x8E, 0xFF, 0xB7, 0xC0, 0x3F, 0x7F, 0x71, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF,
  0x77, 0xFD, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D,
  0xCF, 0x7F, 0xCF, 0x30, 0x3F, 0x1F, 0xE7, 0x3B, 0x86, 0xE1, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x07, 0x09, 0xFE, 0x3F, 0x80, 0x1F, 0x3F, 0x38,
  0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3C, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x77, 0x3D, 0xFF, 0x3D, 0xC0, 0x70, 0x1E, 0x07, 0x7F,
  0x9F, 0xC3, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xFB, 0xFF, 0xE7,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xC0,
  0x6F, 0x60, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x18, 0xF1, 0x80,
  0x00, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x3B, 0xEF, 0xB8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFC, 0x73,
  0x1C, 0xCE, 0x37, 0x0D, 0xC3, 0xF0, 0xFE, 0x33, 0x8C, 0x73, 0x1C, 0xC3,
  0xB0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDF, 0x3C, 0xFF, 0x7E, 0xE7,
  0xCE, 0xE3, 0x86, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3,
  0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xDF, 0x7F, 0xF8,
  0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x38,
  0x3F, 0x1F, 0xE7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x77, 0x3D, 0xFE, 0x1F, 0x00, 0xDF, 0x3F, 0xEE, 0x3B, 0x8E, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xEF, 0x3B, 0xFE, 0xDF, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3C, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x3D, 0xFF, 0x3D, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0xDF, 0x7F, 0xF8, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0x7F, 0xFE, 0xE2, 0xE0, 0xE0, 0xF8, 0x7E, 0x1E, 0x07,
  0x07, 0x87, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0x77, 0x3D, 0xFB, 0x3C,
  0xC0, 0xE0, 0xFC, 0x19, 0xC7, 0x38, 0xE7, 0x1C, 0x63, 0x0E, 0xE1, 0xDC,
  0x1B, 0x03, 0x60, 0x7C, 0x0F, 0x00, 0xE0, 0xE1, 0xC3, 0xB0, 0xE1, 0x9C,
  0xF9, 0xCE, 0x6C, 0xE7, 0x36, 0x73, 0x9B, 0x30, 0xDD, 0x98, 0x7C, 0xFC,
  0x3E, 0x3E, 0x1F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xCE, 0x38, 0xEE, 0x1D, 0xC1, 0xF0, 0x3E, 0x03, 0x80, 0xF8, 0x1F, 0x07,
  0x71, 0xCE, 0x38, 0xEE, 0x1E, 0xE0, 0xEC, 0x19, 0xC7, 0x38, 0xE7, 0x1C,
  0x73, 0x0E, 0xE1, 0xDC, 0x1B, 0x03, 0x60, 0x7C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x7C, 0x0F, 0x01, 0x80, 0x00, 0xFE, 0xFE, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0x0F, 0x1F, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xF8, 0xF0, 0x78, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x3C,
  0x39, 0xF3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC7, 0x8C, 0x00, 0xF8, 0x7F,
  0xF8, 0xFC,
};

const GFXglyph NotoSans_Condensed_SemiBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 8, 6, 10, 1, -17 },
  { 16, 12, 17, 13, 0, -17 },
  { 42, 10, 19, 12, 1, -18 },
  { 66, 17, 17, 19, 1, -17 },
  { 103, 13, 17, 14, 1, -17 },
  { 131, 3, 6, 6, 1, -17 },
  { 134, 6, 21, 7, 1, -17 },
  { 150, 5, 21, 7, 1, -17 },
  { 164, 9, 9, 11, 1, -18 },
  { 175, 10, 11, 12, 1, -14 },
  { 189, 4, 6, 6, 1, -3 },
  { 192, 6, 3, 7, 1, -8 },
  { 195, 4, 3, 6, 1, -3 },
  { 197, 9, 17, 9, 0, -17 },
  { 217, 10, 17, 12, 1, -17 },
  { 239, 7, 17, 12, 1, -17 },
  { 254, 10, 17, 12, 1, -17 },
  { 276, 10, 17, 12, 1, -17 },
  { 298, 11, 17, 12, 0, -17 },
  { 322, 10, 17, 12, 1, -17 },
  { 344, 10, 17, 12, 1, -17 },
  { 366, 10, 17, 12, 1, -17 },
  { 388, 10, 17, 12, 1, -17 },
  { 410, 10, 17, 12, 1, -17 },
  { 432, 4, 13, 6, 1, -13 },
  { 439, 4, 16, 6, 1, -13 },
  { 447, 10, 11, 12, 1, -14 },
  { 461, 10, 7, 12, 1, -12 },
  { 470, 10, 11, 12, 1, -14 },
  { 484, 9, 17, 9, 0, -17 },
  { 504, 16, 19, 18, 1, -17 },
  { 542, 13, 17, 13, 0, -17 },
  { 570, 10, 17, 13, 2, -17 },
  { 592, 11, 17, 12, 1, -17 },
  { 616, 11, 17, 14, 2, -17 },
  { 640, 8, 17, 11, 2, -17 },
  { 657, 8, 17, 11, 2, -17 },
  { 674, 12, 17, 15, 1, -17 },
  { 700, 11, 17, 15, 2, -17 },
  { 724, 6, 17, 8, 1, -17 },
  { 737, 6, 22, 7, -1, -17 },
  { 754, 11, 17, 13, 2, -17 },
  { 778, 8, 17, 11, 2, -17 },
  { 795, 15, 17, 19, 2, -17 },
  { 827, 12, 17, 16, 2, -17 },
  { 853, 13, 17, 15, 1, -17 },
  { 881, 10, 17, 12, 2, -17 },
  { 903, 13, 21, 15, 1, -17 },
  { 938, 11, 17, 13, 2, -17 },
  { 962, 9, 17, 11, 1, -17 },
  { 982, 11, 17, 11, 0, -17 },
  { 1006, 11, 17, 15, 2, -17 },
  { 1030, 13, 17, 13, 0, -17 },
  { 1058, 19, 17, 19, 0, -17 },
  { 1099, 12, 17, 12, 0, -17 },
  { 1125, 12, 17, 12, 0, -17 },
  { 1151, 9, 17, 11, 1, -17 },
  { 1171, 5, 21, 8, 2, -17 },
  { 1185, 9, 17, 9, 0, -17 },
  { 1205, 5, 21, 8, 1, -17 },
  { 1219, 11, 10, 12, 1, -17 },
  { 1233, 10, 2, 10, 0, 2 },
  { 1236, 5, 3, 7, 1, -18 },
  { 1238, 9, 13, 12, 1, -13 },
  { 1253, 10, 18, 13, 2, -18 },
  { 1276, 8, 13, 10, 1, -13 },
  { 1289, 10, 18, 13, 1, -18 },
  { 1312, 10, 13, 12, 1, -13 },
  { 1329, 8, 18, 7, 0, -18 },
  { 1347, 10, 19, 13, 1, -13 },
  { 1371, 9, 18, 13, 2, -18 },
  { 1392, 4, 18, 6, 1, -18 },
  { 1401, 6, 24, 6, -1, -18 },
  { 1419, 10, 18, 12, 2, -18 },
  { 1442, 2, 18, 6, 2, -18 },
  { 1447, 16, 13, 19, 2, -13 },
  { 1473, 9, 13, 13, 2, -13 },
  { 1488, 10, 13, 12, 1, -13 },
  { 1505, 10, 19, 13, 2, -13 },
  { 1529, 10, 19, 13, 1, -13 },
  { 1553, 6, 13, 9, 2, -13 },
  { 1563, 8, 13, 10, 1, -13 },
  { 1576, 8, 16, 8, 0, -16 },
  { 1592, 10, 13, 13, 1, -13 },
  { 1609, 11, 13, 11, 0, -13 },
  { 1627, 17, 13, 17, 0, -13 },
  { 1655, 11, 13, 11, 0, -13 },
  { 1673, 11, 19, 11, 0, -13 },
  { 1700, 8, 13, 9, 1, -13 },
  { 1713, 8, 21, 9, 0, -17 },
  { 1734, 3, 24, 11, 4, -18 },
  { 1743, 7, 21, 9, 1, -17 },
  { 1762, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_SemiBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD24PT7B_H_
