#ifndef _NOTOSANS_CONDENSED_SEMIBOLD43PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC7, 0x80, 0x00, 0x00, 0x71,
  0xF7, 0xFF, 0xEF, 0x9F, 0x00, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xDE, 0x1F,
  0x78, 0x7D, 0xE1, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xE7, 0x87,
  0x80, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80,
  0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3,
  0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x78,
  0x03, 0xC3, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x3C,
  0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFD, 0xC7, 0x7C, 0xE0, 0x3E, 0x70, 0x1F, 0x38,
  0x0F, 0x9C, 0x07, 0xEE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0E, 0x7C, 0x07, 0x3E,
  0x03, 0x9F, 0x01, 0xCF, 0xE0, 0xE7, 0xFC, 0x77, 0xDF, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x3F, 0x80, 0x1E, 0x00,
  0xFF, 0x80, 0x78, 0x03, 0xEF, 0x80, 0xF0, 0x07, 0x8F, 0x03, 0xC0, 0x0F,
  0x1E, 0x07, 0x80, 0x1E, 0x3C, 0x0E, 0x00, 0x3C, 0x3C, 0x3C, 0x00, 0xF0,
  0x78, 0x78, 0x01, 0xE0, 0xF1, 0xE0, 0x01, 0xC1, 0xE3, 0xC0, 0x03, 0xC3,
  0xCF, 0x00, 0x07, 0x8F, 0x1E, 0x1E, 0x0F, 0x1E, 0x38, 0xFE, 0x1E, 0x3C,
  0xF3, 0xFE, 0x1E, 0xF9, 0xE7, 0xFE, 0x3F, 0xE7, 0x9E, 0x3C, 0x3F, 0x8F,
  0x3C, 0x78, 0x3E, 0x3C, 0x78, 0x78, 0x00, 0x78, 0xF0, 0xF0, 0x00, 0xE1,
  0xE1, 0xE0, 0x03, 0xC3, 0xC3, 0xC0, 0x07, 0x87, 0x87, 0x80, 0x1E, 0x0F,
  0x0F, 0x00, 0x3C, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x78, 0x01, 0xE0, 0x78,
  0xF0, 0x03, 0xC0, 0x79, 0xE0, 0x0F, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x3E, 0x1F, 0xF8, 0x3E, 0x3F, 0xFC, 0x3E, 0x7E,
  0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3F, 0x7C, 0xFC, 0x1F, 0xFC, 0xFC,
  0x0F, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0x7F,
  0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0x7E, 0x07,
  0xF8, 0x3F, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x03,
  0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F,
  0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0xF8,
  0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83,
  0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x18, 0x78,
  0x67, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0x78, 0x7C, 0x0E,
  0x1C, 0x00, 0x84, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFB,
  0xF7, 0xF7, 0xCF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE7, 0xE3, 0xE0, 0xF9, 0xF0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x8F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEF, 0xDF, 0xFC, 0xF9, 0xC7, 0xC4, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x8E, 0x07, 0xE1, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC7, 0x87, 0xF3, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1E,
  0x7C, 0x03, 0xCF, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0xC0, 0xF0,
  0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x20,
  0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xB8, 0x1F, 0xDF, 0xFF,
  0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFC, 0x11, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0E, 0x0F, 0xBF, 0xC7, 0xBF,
  0xF3, 0xDF, 0xFD, 0xFE, 0xFE, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xBE, 0x0F, 0xDF, 0x8F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0x9F, 0x83,
  0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x03, 0xE3, 0xE0, 0xF8,
  0xFC, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0xC3, 0xE1, 0xF9, 0xF0, 0x3F, 0x7C, 0x07, 0xDE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFD,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3F, 0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0x7C, 0x1F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x10, 0xF9, 0xF7, 0xF7, 0xCF,
  0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0xEF, 0xFF, 0xDF, 0x3E, 0x1C, 0x3E, 0x3E, 0x3F, 0x3E, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7C,
  0x7E, 0x20, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x3C, 0x07,
  0xC1, 0xE1, 0xE0, 0xFF, 0xC7, 0x9E, 0x0F, 0xFE, 0x3C, 0xF0, 0xF8, 0xF1,
  0xE7, 0x0F, 0x87, 0x87, 0x78, 0x78, 0x3C, 0x3F, 0xC3, 0xC1, 0xE1, 0xFE,
  0x1C, 0x0F, 0x0F, 0xF1, 0xE0, 0x78, 0x7F, 0x8F, 0x07, 0x83, 0xFC, 0x78,
  0x3C, 0x1D, 0xE3, 0xC1, 0xE0, 0xEF, 0x0E, 0x0F, 0x0F, 0x78, 0x78, 0x78,
  0x7B, 0xC3, 0xE7, 0xE7, 0x9E, 0x0F, 0xF7, 0xFC, 0x78, 0x7F, 0x9F, 0xC3,
  0xC0, 0xF8, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80,
  0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x07, 0xEF, 0x81, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x9F, 0x03, 0xFB, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0x7C, 0x7F,
  0x00, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x04, 0x7F, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7C, 0x0F, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xE0,
  0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x3F, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x1F, 0x0F, 0xE0,
  0x08, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xC7, 0xF0, 0x3E, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0xC3, 0xE0, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F,
  0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0,
  0xF8, 0xFC, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x0F, 0xC7,
  0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xEF, 0xFF, 0xC0, 0x1E, 0xFF,
  0xBC, 0x03, 0xEF, 0xFB, 0xC0, 0x3D, 0xFF, 0xBE, 0x03, 0xDF, 0xF9, 0xE0,
  0x3D, 0xFF, 0x9E, 0x07, 0x9F, 0xF9, 0xF0, 0x79, 0xFF, 0x9F, 0x07, 0x9F,
  0xF8, 0xF0, 0xF9, 0xFF, 0x8F, 0x0F, 0x1F, 0xF8, 0xF8, 0xF1, 0xFF, 0x87,
  0x9F, 0x1F, 0xF8, 0x79, 0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0xF8, 0x7D, 0xE1,
  0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8,
  0x1F, 0xC1, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8,
  0x1F, 0xF8, 0x0F, 0x01, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xEF, 0x81, 0xFF, 0xBE, 0x07, 0xFE,
  0x7C, 0x1F, 0xF9, 0xF0, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x1F,
  0x1F, 0xF8, 0x7C, 0x7F, 0xE0, 0xF9, 0xFF, 0x83, 0xE7, 0xFE, 0x07, 0xCF,
  0xF8, 0x1F, 0x3F, 0xE0, 0x7E, 0xFF, 0x80, 0xFB, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00,
  0x1F, 0xBF, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBE, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x83, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFE,
  0x7F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E,
  0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF8,
  0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xF8,
  0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFC, 0x06, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xF8,
  0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F,
  0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0xF8, 0x00, 0x79, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xFF,
  0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0x3E, 0x01, 0xF8, 0x03,
  0xE7, 0xC0, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xF0, 0x1F, 0x1F, 0x00, 0xFE,
  0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x07, 0xF8, 0x0F, 0x87, 0xC0,
  0xF7, 0x83, 0xF0, 0xF8, 0x1E, 0xF0, 0x7C, 0x1F, 0x07, 0xDE, 0x0F, 0x81,
  0xE0, 0xF3, 0xC1, 0xF0, 0x3E, 0x1E, 0x78, 0x3E, 0x07, 0xC3, 0xCF, 0x8F,
  0xC0, 0xF8, 0xF8, 0xF1, 0xF0, 0x1F, 0x1F, 0x1E, 0x3E, 0x01, 0xF3, 0xC3,
  0xC7, 0xC0, 0x3E, 0x78, 0x7C, 0xF8, 0x07, 0xCF, 0x0F, 0xBE, 0x00, 0xFB,
  0xE0, 0xF7, 0xC0, 0x0F, 0x7C, 0x1E, 0xF8, 0x01, 0xEF, 0x03, 0xDF, 0x00,
  0x3D, 0xE0, 0x7B, 0xE0, 0x07, 0xFC, 0x07, 0x78, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C,
  0x01, 0xF9, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0x80,
  0x1F, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00,
  0xFC, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xF0,
  0x3E, 0x0F, 0x80, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xEF, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xFC, 0x07, 0xE3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x87,
  0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF8, 0xF0,
  0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0,
  0x7C, 0x1E, 0x01, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xE1,
  0xF8, 0x40, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC1,
  0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xF8, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xF7, 0xFF, 0xFB, 0xFF,
  0xBC, 0xFF, 0x9E, 0x3F, 0x8F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x1C, 0x0F, 0x9F, 0xC3, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xF0, 0x3E, 0xFE, 0x1F, 0xBF, 0xFF,
  0xCF, 0x7F, 0xF3, 0xCF, 0xF8, 0xF1, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xFC,
  0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xC0, 0x9F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x23, 0xFF, 0xC7,
  0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC1, 0xE1, 0xF1, 0xFE, 0x7C, 0xFF, 0xDF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xCF, 0x0F, 0xE3, 0xC0, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x63, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x03,
  0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0x98, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x07,
  0xF8, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x87, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF,
  0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x40, 0x0F, 0x9C, 0x0F, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F,
  0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x3C, 0x3E,
  0xFF, 0x9F, 0xFF, 0xCF, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0xFF, 0xFD, 0xFE, 0xFE, 0x7E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0xFB, 0xE0, 0x7C,
  0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E,
  0x7C, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x0F,
  0x0F, 0x3F, 0xC3, 0xFC, 0xF7, 0xFE, 0x7F, 0xEF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF8,
  0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF,
  0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F,
  0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F,
  0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80,
  0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0x00, 0x70, 0x79,
  0xFF, 0x3D, 0xFF, 0xDE, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xBF, 0x9F,
  0x83, 0xE7, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x70, 0x3C, 0x7F, 0x0F, 0x3F,
  0xE3, 0xDF, 0xFC, 0xFF, 0x3F, 0xBF, 0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0xC0,
  0xFB, 0xF8, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xBF, 0xE3, 0xE7, 0xF0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x80, 0x07, 0xF8, 0xF3, 0xFF, 0x7C, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xF7, 0xFF,
  0xF9, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xE7,
  0xE3, 0xCF, 0x81, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFB, 0x03, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFF, 0x79, 0xFF, 0x3C, 0x7F, 0x1E, 0xFC, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83,
  0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0x8F,
  0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x7D, 0xF0, 0x3F, 0x01, 0xF7, 0xC0,
  0xFE, 0x0F, 0x9F, 0x03, 0xF8, 0x3E, 0x7C, 0x1F, 0xE0, 0xF8, 0xF8, 0x7F,
  0x83, 0xE3, 0xE1, 0xEE, 0x0F, 0x0F, 0x87, 0x3C, 0x7C, 0x3E, 0x3C, 0xF1,
  0xF0, 0x78, 0xF3, 0xC7, 0xC1, 0xF3, 0xCF, 0x1E, 0x07, 0xCF, 0x1C, 0xF8,
  0x1F, 0x38, 0x7B, 0xE0, 0x3D, 0xE1, 0xEF, 0x80, 0xF7, 0x87, 0xBC, 0x03,
  0xDE, 0x1E, 0xF0, 0x0F, 0xF8, 0x3B, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE7, 0xC1, 0xF8, 0xF8,
  0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xE3,
  0xE0, 0x7C, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01,
  0xF8, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1,
  0xF0, 0x3C, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x01, 0xEF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x87,
  0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F,
  0xC0, 0x70, 0x00, 0x3F, 0x80, 0x2F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFD, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 31, 11, 2, -31 },
  { 29, 14, 11, 18, 2, -31 },
  { 49, 21, 31, 23, 1, -31 },
  { 131, 17, 36, 21, 2, -33 },
  { 208, 31, 31, 33, 1, -31 },
  { 329, 24, 31, 25, 1, -31 },
  { 422, 6, 11, 10, 2, -31 },
  { 431, 10, 38, 13, 2, -31 },
  { 479, 10, 38, 13, 1, -31 },
  { 527, 18, 18, 20, 1, -33 },
  { 568, 18, 21, 21, 1, -26 },
  { 616, 8, 11, 11, 1, -5 },
  { 627, 11, 5, 13, 1, -14 },
  { 634, 7, 6, 11, 2, -6 },
  { 640, 17, 31, 17, 0, -31 },
  { 706, 17, 31, 21, 2, -31 },
  { 772, 13, 31, 21, 2, -31 },
  { 823, 18, 31, 21, 1, -31 },
  { 893, 17, 31, 21, 2, -31 },
  { 959, 19, 31, 21, 1, -31 },
  { 1033, 17, 31, 21, 2, -31 },
  { 1099, 17, 31, 21, 2, -31 },
  { 1165, 18, 31, 21, 1, -31 },
  { 1235, 18, 31, 21, 1, -31 },
  { 1305, 18, 31, 21, 1, -31 },
  { 1375, 7, 24, 11, 2, -24 },
  { 1396, 8, 30, 11, 1, -24 },
  { 1426, 18, 21, 21, 1, -26 },
  { 1474, 18, 12, 21, 1, -21 },
  { 1501, 19, 21, 21, 1, -26 },
  { 1551, 16, 31, 16, 0, -31 },
  { 1613, 29, 35, 33, 2, -31 },
  { 1740, 24, 31, 24, 0, -31 },
  { 1833, 19, 31, 24, 3, -31 },
  { 1907, 19, 31, 22, 2, -31 },
  { 1981, 21, 31, 26, 3, -31 },
  { 2063, 15, 31, 20, 3, -31 },
  { 2122, 15, 31, 19, 3, -31 },
  { 2181, 21, 31, 26, 2, -31 },
  { 2263, 21, 31, 27, 3, -31 },
  { 2345, 12, 31, 14, 1, -31 },
  { 2392, 11, 40, 12, -3, -31 },
  { 2447, 20, 31, 23, 3, -31 },
  { 2525, 15, 31, 19, 3, -31 },
  { 2584, 28, 31, 35, 3, -31 },
  { 2693, 22, 31, 29, 3, -31 },
  { 2779, 23, 31, 28, 2, -31 },
  { 2869, 18, 31, 22, 3, -31 },
  { 2939, 23, 38, 28, 2, -31 },
  { 3049, 20, 31, 23, 3, -31 },
  { 3127, 16, 31, 20, 2, -31 },
  { 3189, 18, 31, 20, 1, -31 },
  { 3259, 20, 31, 26, 3, -31 },
  { 3337, 23, 31, 23, 0, -31 },
  { 3427, 35, 31, 34, 0, -31 },
  { 3563, 22, 31, 22, 0, -31 },
  { 3649, 21, 31, 21, 0, -31 },
  { 3731, 17, 31, 19, 1, -31 },
  { 3797, 10, 38, 14, 3, -31 },
  { 3845, 17, 31, 17, 0, -31 },
  { 3911, 10, 38, 14, 1, -31 },
  { 3959, 20, 19, 22, 1, -31 },
  { 4007, 18, 3, 18, 0, 4 },
  { 4014, 9, 7, 13, 2, -33 },
  { 4022, 17, 24, 21, 1, -24 },
  { 4073, 18, 33, 23, 3, -33 },
  { 4148, 15, 24, 18, 2, -24 },
  { 4193, 18, 33, 23, 2, -33 },
  { 4268, 17, 24, 21, 2, -24 },
  { 4319, 14, 33, 13, 1, -33 },
  { 4377, 18, 34, 23, 2, -24 },
  { 4454, 17, 33, 23, 3, -33 },
  { 4525, 5, 32, 11, 3, -32 },
  { 4545, 9, 42, 11, -1, -32 },
  { 4593, 18, 33, 21, 3, -33 },
  { 4668, 5, 33, 11, 3, -33 },
  { 4689, 28, 24, 34, 3, -24 },
  { 4773, 17, 24, 23, 3, -24 },
  { 4824, 18, 24, 22, 2, -24 },
  { 4878, 18, 34, 23, 3, -24 },
  { 4955, 18, 34, 23, 2, -24 },
  { 5032, 12, 24, 16, 3, -24 },
  { 5068, 15, 24, 17, 1, -24 },
  { 5113, 12, 28, 14, 1, -28 },
  { 5155, 17, 23, 23, 3, -23 },
  { 5204, 19, 23, 20, 0, -23 },
  { 5259, 30, 23, 30, 0, -23 },
  { 5346, 19, 23, 19, 0, -23 },
  { 5401, 19, 33, 20, 0, -23 },
  { 5480, 14, 23, 16, 1, -23 },
  { 5521, 13, 38, 16, 1, -31 },
  { 5583, 4, 43, 20, 8, -33 },
  { 5605, 13, 38, 16, 2, -31 },
  { 5667, 19, 6, 21, 1, -18 },
};

const GFXfont NotoSans_Condensed_SemiBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD43PT7B_H_
