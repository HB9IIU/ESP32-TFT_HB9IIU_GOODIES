#ifndef _NOTOSANS_CONDENSED_SEMIBOLD16PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x12, 0x12, 0x16, 0x7F, 0x34,
  0x34, 0xFF, 0xFF, 0x24, 0x2C, 0x6C, 0x21, 0xEF, 0xF8, 0xE3, 0x83, 0x8B,
  0x2E, 0xBF, 0x88, 0x20, 0x40, 0x1E, 0x62, 0xCC, 0x49, 0x09, 0x61, 0x6B,
  0xBF, 0x5A, 0x5B, 0x0B, 0x63, 0x6C, 0x45, 0x98, 0xE0, 0x18, 0x1E, 0x19,
  0x8C, 0x83, 0xC1, 0xC1, 0xE6, 0xDB, 0xC7, 0x33, 0x9F, 0xC7, 0xB0, 0xFF,
  0x76, 0xCC, 0xCC, 0x8C, 0xCC, 0xC4, 0x63, 0xE6, 0x33, 0x33, 0x13, 0x33,
  0x36, 0x6C, 0x18, 0x21, 0xFC, 0xC2, 0xCD, 0x80, 0x30, 0xC3, 0x3F, 0x30,
  0xC3, 0x00, 0xFE, 0xFF, 0xF0, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x21,
  0x84, 0x30, 0x31, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0x9E, 0x3B,
  0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xE8, 0xC3, 0x0C, 0x61, 0x8C,
  0x63, 0x0F, 0xFF, 0x33, 0xE8, 0xC3, 0x0D, 0xE7, 0x83, 0x0C, 0x39, 0xFE,
  0x0C, 0x1C, 0x14, 0x3C, 0x2C, 0x6C, 0x4C, 0xFF, 0xFF, 0x0C, 0x0C, 0xFB,
  0x0C, 0x30, 0xFA, 0x70, 0xC3, 0x0F, 0x7F, 0x80, 0x19, 0xFE, 0x30, 0xC2,
  0xEC, 0xF3, 0xCF, 0x3F, 0xDE, 0xFE, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x0C,
  0x10, 0x60, 0xC0, 0x33, 0xEC, 0xF3, 0xCD, 0xE7, 0xB3, 0x8E, 0x3C, 0xDE,
  0x23, 0xEC, 0xE3, 0x8F, 0x3F, 0xDF, 0x0C, 0x3B, 0xBC, 0xFC, 0x03, 0xC0,
  0xFC, 0x03, 0xF8, 0x04, 0x33, 0xB8, 0xC1, 0xC1, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x83, 0x0F, 0x07, 0x0C, 0xEE, 0x20, 0x33, 0xE8, 0xC3, 0x0C, 0x63,
  0x08, 0x00, 0x07, 0x0C, 0x04, 0x0F, 0xC6, 0x09, 0x13, 0xDE, 0x64, 0x99,
  0x26, 0xC9, 0x92, 0x67, 0x6C, 0x01, 0x84, 0x3F, 0x00, 0x1C, 0x0E, 0x0D,
  0x06, 0xC3, 0x61, 0x31, 0xFC, 0xFE, 0x63, 0x61, 0xB0, 0x60, 0xFD, 0x9F,
  0x1E, 0x3F, 0xDF, 0xB1, 0xE3, 0xC7, 0xFF, 0xF0, 0x18, 0xFD, 0x8E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xC1, 0xF9, 0xF0, 0xFC, 0xCE, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0xF8, 0xFF, 0x0C, 0x30, 0xFB, 0xEC, 0x30,
  0xC3, 0xFF, 0xC0, 0xFF, 0x0C, 0x30, 0xC3, 0xEC, 0x30, 0xC3, 0x0C, 0x00,
  0x0C, 0x3F, 0x62, 0xC0, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xE3, 0x7F, 0x3F,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF9,
  0x8C, 0x63, 0x18, 0xC6, 0x33, 0xBE, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFE, 0xC7, 0xCC, 0xCC, 0xD8, 0xF0, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0xFC, 0x3F,
  0xC7, 0xF8, 0xBD, 0x17, 0xB6, 0xF6, 0x9E, 0x53, 0xCE, 0x79, 0xCF, 0x31,
  0x80, 0xE1, 0xE1, 0xF1, 0xF1, 0xD9, 0xD9, 0xCD, 0xCD, 0xC7, 0xC7, 0xC3,
  0x18, 0x7E, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C,
  0xFD, 0x9B, 0x1E, 0x3C, 0xDF, 0xBE, 0x60, 0xC1, 0x83, 0x00, 0x18, 0x7E,
  0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0x06, 0x06,
  0x03, 0xFC, 0xCE, 0xC6, 0xC6, 0xCC, 0xFC, 0xD8, 0xCC, 0xCC, 0xC6, 0xC7,
  0x33, 0xFC, 0xB0, 0xC3, 0x87, 0x86, 0x0C, 0x3F, 0xBE, 0xFE, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x7C, 0xC3, 0x43, 0x63, 0x62, 0x66, 0x26,
  0x34, 0x34, 0x3C, 0x1C, 0x18, 0xC6, 0x1E, 0x38, 0x91, 0xCC, 0xCA, 0x66,
  0xD3, 0x36, 0xD9, 0xB6, 0x85, 0x3C, 0x38, 0xE1, 0xC7, 0x0E, 0x30, 0xE7,
  0x66, 0x3C, 0x3C, 0x18, 0x18, 0x3C, 0x3C, 0x66, 0x66, 0xC3, 0xC7, 0x66,
  0x66, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x18, 0x30,
  0xC1, 0x86, 0x0C, 0x30, 0x61, 0xFF, 0xF8, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xFF, 0xC1, 0x06, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x60, 0xC3, 0xF3,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x1C, 0x3C, 0x26, 0x66, 0xC3,
  0xFE, 0xCC, 0x7B, 0xE0, 0xC3, 0xFF, 0x38, 0xF7, 0xFC, 0xC1, 0x83, 0x06,
  0xCF, 0xD8, 0xF1, 0xE3, 0xC7, 0x8F, 0xB7, 0xE0, 0x3F, 0xF1, 0x8C, 0x63,
  0x1D, 0x78, 0x04, 0x10, 0x5D, 0xFF, 0x3C, 0x71, 0xC7, 0x3E, 0xDD, 0x33,
  0xFC, 0xF3, 0xFF, 0x0C, 0x39, 0x7C, 0x3B, 0xD8, 0xFF, 0xB1, 0x8C, 0x63,
  0x18, 0xC0, 0x77, 0xFC, 0xF1, 0xC7, 0x1C, 0xFB, 0x74, 0x10, 0xFF, 0x78,
  0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xF3, 0xFF, 0xFF,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC1, 0x83, 0x06, 0x3C,
  0xDB, 0x3C, 0x78, 0xD9, 0x93, 0x36, 0x30, 0xFF, 0xFF, 0xFF, 0xD9, 0xDF,
  0xFB, 0x39, 0xE6, 0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x60, 0xDB,
  0xFC, 0xF1, 0xC7, 0x1C, 0x71, 0xC4, 0x39, 0xFB, 0x36, 0x3C, 0x78, 0xF3,
  0x76, 0x78, 0xD9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xF6, 0xFD, 0x83, 0x06,
  0x0C, 0x00, 0x77, 0xFC, 0xF1, 0xC7, 0x1C, 0xFB, 0x74, 0x10, 0x41, 0x04,
  0xDF, 0xB9, 0x8C, 0x63, 0x18, 0xC0, 0x77, 0xE1, 0x8F, 0x1C, 0x77, 0xF0,
  0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x4E, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xFF, 0x74, 0xC7, 0x8D, 0x9B, 0x66, 0xC5, 0x8A, 0x1C, 0x38, 0xC6, 0x79,
  0xCD, 0x39, 0xB5, 0x26, 0xBC, 0xD7, 0x8E, 0x71, 0xCC, 0x31, 0x80, 0xC6,
  0xD9, 0xB1, 0xC3, 0x87, 0x1B, 0x36, 0xC6, 0xC7, 0x8D, 0x9B, 0x66, 0xC5,
  0x8E, 0x1C, 0x18, 0x30, 0xC7, 0x8E, 0x00, 0x7D, 0xF1, 0x86, 0x30, 0xC6,
  0x1F, 0xFC, 0x39, 0x8C, 0x63, 0x1B, 0x0E, 0x31, 0x8C, 0x63, 0x84, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC6, 0x66, 0x66, 0x16, 0x66, 0x66, 0xC8, 0xE7, 0xF8,
  0x80,
};

const GFXglyph NotoSans_Condensed_SemiBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 9, 0, -11 },
  { 18, 6, 13, 8, 1, -12 },
  { 28, 11, 12, 12, 1, -12 },
  { 45, 9, 12, 9, 0, -12 },
  { 59, 2, 4, 4, 1, -11 },
  { 60, 4, 14, 5, 1, -11 },
  { 67, 4, 14, 5, 0, -11 },
  { 74, 7, 6, 7, 0, -12 },
  { 80, 6, 7, 8, 1, -9 },
  { 86, 2, 4, 4, 1, -2 },
  { 87, 4, 2, 5, 0, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 12, 6, 0, -12 },
  { 98, 6, 12, 8, 1, -12 },
  { 107, 5, 11, 8, 1, -11 },
  { 114, 6, 12, 8, 1, -12 },
  { 123, 6, 12, 8, 1, -12 },
  { 132, 8, 11, 8, 0, -11 },
  { 143, 6, 11, 8, 1, -11 },
  { 152, 6, 12, 8, 1, -12 },
  { 161, 7, 11, 8, 0, -11 },
  { 171, 6, 12, 8, 1, -12 },
  { 180, 6, 12, 8, 1, -12 },
  { 189, 2, 9, 4, 1, -9 },
  { 192, 2, 11, 4, 1, -9 },
  { 195, 6, 8, 8, 1, -10 },
  { 201, 6, 5, 8, 1, -8 },
  { 205, 6, 8, 8, 1, -10 },
  { 211, 6, 12, 6, 0, -12 },
  { 220, 10, 13, 12, 1, -12 },
  { 237, 9, 11, 9, 0, -11 },
  { 250, 7, 11, 9, 1, -11 },
  { 260, 7, 12, 8, 1, -12 },
  { 271, 8, 11, 10, 1, -11 },
  { 282, 6, 11, 7, 1, -11 },
  { 291, 6, 11, 7, 1, -11 },
  { 300, 8, 12, 10, 1, -12 },
  { 312, 8, 11, 10, 1, -11 },
  { 323, 5, 11, 5, 0, -11 },
  { 330, 4, 14, 4, -1, -11 },
  { 337, 8, 11, 9, 1, -11 },
  { 348, 6, 11, 7, 1, -11 },
  { 357, 11, 11, 13, 1, -11 },
  { 373, 8, 11, 11, 1, -11 },
  { 384, 8, 12, 10, 1, -12 },
  { 396, 7, 11, 8, 1, -11 },
  { 406, 8, 15, 10, 1, -12 },
  { 421, 8, 11, 9, 1, -11 },
  { 432, 6, 12, 7, 1, -12 },
  { 441, 7, 11, 7, 0, -11 },
  { 451, 8, 11, 10, 1, -11 },
  { 462, 8, 11, 8, 0, -11 },
  { 473, 13, 11, 13, 0, -11 },
  { 491, 8, 11, 8, 0, -11 },
  { 502, 8, 11, 8, 0, -11 },
  { 513, 7, 11, 7, 0, -11 },
  { 523, 4, 14, 5, 1, -11 },
  { 530, 6, 12, 6, 0, -12 },
  { 539, 4, 14, 5, 0, -11 },
  { 546, 8, 6, 8, 0, -11 },
  { 552, 7, 1, 7, 0, 1 },
  { 553, 3, 2, 5, 1, -12 },
  { 554, 6, 9, 8, 1, -9 },
  { 561, 7, 12, 8, 1, -12 },
  { 572, 5, 9, 7, 1, -9 },
  { 578, 6, 12, 8, 1, -12 },
  { 587, 6, 9, 8, 1, -9 },
  { 594, 5, 12, 5, 0, -12 },
  { 602, 6, 13, 8, 1, -9 },
  { 612, 6, 12, 8, 1, -12 },
  { 621, 2, 12, 4, 1, -12 },
  { 624, 4, 16, 4, -1, -12 },
  { 632, 7, 12, 8, 1, -12 },
  { 643, 2, 12, 4, 1, -12 },
  { 646, 11, 9, 13, 1, -9 },
  { 659, 6, 9, 8, 1, -9 },
  { 666, 7, 9, 8, 1, -9 },
  { 674, 7, 13, 8, 1, -9 },
  { 686, 6, 13, 8, 1, -9 },
  { 696, 5, 9, 6, 1, -9 },
  { 702, 5, 9, 6, 1, -9 },
  { 708, 5, 11, 5, 0, -11 },
  { 715, 6, 9, 8, 1, -9 },
  { 722, 7, 9, 7, 0, -9 },
  { 730, 11, 9, 11, 0, -9 },
  { 743, 7, 9, 7, 0, -9 },
  { 751, 7, 13, 7, 0, -9 },
  { 763, 6, 9, 6, 0, -9 },
  { 770, 5, 14, 6, 0, -11 },
  { 779, 2, 16, 7, 3, -12 },
  { 783, 4, 14, 6, 1, -11 },
  { 790, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_SemiBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD16PT7B_H_
