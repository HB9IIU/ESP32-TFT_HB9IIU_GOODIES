#ifndef _NOTOSANS_CONDENSED_SEMIBOLD22PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x6D, 0x80, 0xFF, 0xEF, 0xCF, 0x9F, 0x36, 0x6C,
  0xC0, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x40, 0x98, 0xFF, 0xDF, 0xF8, 0xCC,
  0x19, 0x83, 0x33, 0xFF, 0x89, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x08,
  0x04, 0x0F, 0xEF, 0xEE, 0x96, 0x43, 0xA1, 0xF0, 0x7C, 0x0F, 0x83, 0xC1,
  0x70, 0xBE, 0x5F, 0xFC, 0xF8, 0x08, 0x04, 0x00, 0x70, 0x31, 0xF0, 0xC3,
  0x31, 0x86, 0x66, 0x0C, 0xCC, 0x19, 0x98, 0x33, 0x66, 0x66, 0xDE, 0x7B,
  0x76, 0xE6, 0xCC, 0x19, 0x98, 0x33, 0x30, 0x66, 0x61, 0x8C, 0xC3, 0x0F,
  0x8C, 0x1E, 0x1C, 0x07, 0xF0, 0x77, 0x06, 0x30, 0x63, 0x07, 0x70, 0x3E,
  0x03, 0xC0, 0x7C, 0x6E, 0xEE, 0xE7, 0xEC, 0x7C, 0xC3, 0xCE, 0x3C, 0xFF,
  0xE7, 0xE7, 0xFF, 0xF6, 0xC0, 0x19, 0xCC, 0xE6, 0x33, 0x9C, 0xC6, 0x31,
  0x8E, 0x71, 0x8C, 0x71, 0x8E, 0xE1, 0xC3, 0x0E, 0x18, 0x61, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x61, 0x86, 0x30, 0xC6, 0x00, 0x18, 0x0C, 0x06, 0x1F,
  0xEF, 0xF9, 0xE0, 0xF8, 0xCE, 0x26, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x0F,
  0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x6F, 0xFD, 0x80, 0xFF, 0xC0,
  0xFF, 0x80, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x70, 0x60, 0xE0, 0x3C, 0x3F, 0x1D, 0xDC, 0x6E, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x33, 0x39, 0xFC, 0x7C,
  0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x3C, 0x7F, 0xB9, 0xC8, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x0E,
  0x0E, 0x06, 0x07, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0x3C, 0x7F, 0xB9, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x78, 0x3E, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x3B,
  0xFD, 0xFC, 0x03, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x86, 0xE1, 0xB8, 0xCE,
  0x33, 0x98, 0xE6, 0x3B, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x7F, 0x3F,
  0x9F, 0xCC, 0x06, 0x07, 0x03, 0xF1, 0xFE, 0x47, 0x01, 0xC0, 0xE0, 0x70,
  0x3C, 0x3B, 0xFD, 0xF8, 0x0F, 0x1F, 0x9E, 0x0C, 0x0E, 0x07, 0x03, 0x79,
  0xFE, 0xE3, 0xF1, 0xF0, 0xFC, 0x7E, 0x3B, 0x19, 0xFC, 0x7C, 0xFF, 0xFF,
  0xFF, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x83,
  0x81, 0xC0, 0xC0, 0xE0, 0x3C, 0x3F, 0xB9, 0xDC, 0x7E, 0x37, 0x19, 0xFC,
  0x78, 0x7E, 0x73, 0xB8, 0xF8, 0x7C, 0x3F, 0x1F, 0xFC, 0xFC, 0x3C, 0x3F,
  0x39, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F, 0xC7, 0xFF, 0xBF, 0xC0, 0xE0, 0x60,
  0x70, 0x79, 0xF8, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x0D, 0xFF, 0xB0, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x07, 0x01, 0xE0, 0x3E,
  0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x7C, 0xF8, 0xF0, 0x60, 0x00, 0x3C, 0xFE,
  0x67, 0x07, 0x07, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x38, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0xE6, 0x1C, 0xCC,
  0xFD, 0xB3, 0x99, 0xE6, 0x33, 0xCC, 0xE7, 0x99, 0x8F, 0x33, 0x16, 0x67,
  0x6C, 0x7B, 0x8C, 0x42, 0x18, 0x00, 0x1C, 0x10, 0x1F, 0xE0, 0x0F, 0x80,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0x98, 0x19, 0x83, 0x9C,
  0x39, 0xC3, 0xFC, 0x3F, 0xE7, 0xFE, 0x70, 0xE6, 0x06, 0xE0, 0x7E, 0x07,
  0xFC, 0x7F, 0xB3, 0xF8, 0x7C, 0x3E, 0x1F, 0x1D, 0xFC, 0xFF, 0x61, 0xF0,
  0xF8, 0x7C, 0x3E, 0x3F, 0xFD, 0xFC, 0x0F, 0x8F, 0xF3, 0x99, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x23,
  0xF8, 0x7E, 0xFC, 0x3F, 0xCF, 0xFB, 0x0E, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xB1, 0xEF, 0xF3, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x0F, 0xC3, 0xFC, 0xF3, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x1F, 0xE3, 0xFC, 0x7F, 0x83, 0xB0, 0x77, 0x0E, 0xF1, 0xCF, 0xF8, 0xFF,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xDC, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xFF, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFF, 0xE0, 0xC1, 0xF0, 0xEC, 0x73, 0x1C,
  0xCE, 0x33, 0x0D, 0xC3, 0xE0, 0xFC, 0x3B, 0x8C, 0xE3, 0x1C, 0xC7, 0x30,
  0xEC, 0x3B, 0x07, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF8, 0x6F, 0x61, 0xBD, 0x86, 0xF6, 0x33, 0xDC, 0xCF, 0x33, 0x3C, 0xD8,
  0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7F, 0x8F, 0xB1, 0xF7, 0x3E, 0x67, 0xCE, 0xF8, 0xDF, 0x1D,
  0xE1, 0xBC, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0x0F, 0x03, 0xFC, 0x79, 0xE7,
  0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0xF8, 0x7F, 0x3F, 0xD8, 0x6C,
  0x3E, 0x1F, 0x0D, 0x8E, 0xFF, 0x7E, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x0F, 0x03, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x9E, 0x3F, 0xC1,
  0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0xF8, 0x3F, 0x8F, 0xF3, 0x0C,
  0xC3, 0xB0, 0xEC, 0x33, 0x3C, 0xFE, 0x3F, 0x0C, 0xE3, 0x18, 0xC7, 0x30,
  0xCC, 0x3B, 0x07, 0x3E, 0x7F, 0xF7, 0xE0, 0xE0, 0xE0, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0x03, 0x03, 0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0xE7, 0xF8, 0xFC, 0xE0,
  0x7E, 0x06, 0x60, 0xE6, 0x0E, 0x70, 0xC7, 0x0C, 0x31, 0xC3, 0x1C, 0x39,
  0x81, 0x98, 0x1B, 0x81, 0xB0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0,
  0xC1, 0xF8, 0x70, 0x6E, 0x1C, 0x19, 0x87, 0x8E, 0x61, 0xE3, 0x9C, 0xF8,
  0xE7, 0x36, 0x30, 0xCD, 0xCC, 0x33, 0x37, 0x0C, 0xCD, 0xC3, 0xF3, 0x60,
  0xF8, 0xD8, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x70, 0xE0,
  0xEE, 0x39, 0xC7, 0x1D, 0xC3, 0xB8, 0x36, 0x07, 0xC0, 0x70, 0x0E, 0x03,
  0xE0, 0x6C, 0x1D, 0xC3, 0x18, 0xE3, 0x9C, 0x77, 0x07, 0xE0, 0xEC, 0x19,
  0xC7, 0x38, 0xC3, 0x38, 0x77, 0x06, 0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xBF, 0xDF, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x3F, 0xF0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C,
  0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xF0, 0x04, 0x01, 0xC0, 0x38, 0x0F,
  0x81, 0xB0, 0x73, 0x0C, 0x61, 0x86, 0x60, 0xDC, 0x0C, 0xFF, 0x80, 0xE3,
  0x8C, 0x30, 0x7E, 0x7F, 0x47, 0x03, 0x03, 0x7F, 0xF3, 0xE3, 0xC3, 0xE7,
  0xFF, 0x7B, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xCE,
  0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6F, 0x3B, 0xFE, 0xEF, 0x00,
  0x3F, 0x7E, 0x72, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0x7E, 0x3E,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x19, 0xED, 0xFF, 0xC7, 0xE3, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x1F, 0x8E, 0xFF, 0x3D, 0x80, 0x3E, 0x3F, 0x98, 0xDC,
  0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x30, 0x5F, 0xC7, 0xE0, 0x1F, 0x3E,
  0x3A, 0x30, 0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x3D, 0xBF, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xF1, 0xDF, 0xE7, 0xB0, 0x18, 0x0E, 0x0E, 0xFE, 0x7E, 0x00, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B, 0xFF, 0xE7, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0x80, 0x5F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x11, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x7F, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x7E,
  0x3B, 0x9C, 0xEE, 0x3B, 0x0F, 0xC3, 0xF8, 0xE6, 0x39, 0xCE, 0x33, 0x8E,
  0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF, 0x3D, 0xFF,
  0xFF, 0xCF, 0x3F, 0x1C, 0x7E, 0x38, 0x7C, 0x70, 0xF8, 0xE1, 0xF1, 0xC3,
  0xE3, 0x87, 0xC7, 0x0F, 0x8E, 0x1F, 0x1C, 0x30, 0xEF, 0x7F, 0xFC, 0xFC,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x30, 0x3E, 0x3F,
  0x98, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xB1, 0xDF, 0xC7, 0xC0,
  0xEF, 0x3F, 0xEF, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xBC,
  0xEF, 0xFB, 0xBC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3D, 0xBF,
  0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xDF, 0xE7, 0xB0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xCF, 0xFF, 0xEF, 0x8E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x00, 0x7F, 0xFF, 0x0E, 0x0F, 0x0F, 0x0F, 0x07,
  0x07, 0x1F, 0xFF, 0xE0, 0x30, 0x60, 0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0xC7, 0x80, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE3, 0xB1, 0xDF, 0xE7, 0xB0, 0xE1, 0xF8, 0x76, 0x19,
  0xCE, 0x73, 0x8C, 0xC3, 0x30, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xE3,
  0x86, 0xC7, 0x8D, 0x8F, 0x3B, 0x1E, 0x67, 0x6C, 0xCE, 0xD9, 0x8D, 0x9F,
  0x1B, 0x3E, 0x36, 0x78, 0x78, 0xF0, 0x71, 0xE0, 0xE3, 0xC0, 0xE1, 0xDC,
  0xE3, 0x30, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x1C, 0xC7, 0x3B,
  0x87, 0xE1, 0xD8, 0x76, 0x19, 0xCE, 0x73, 0x8C, 0xC3, 0xB0, 0xFC, 0x1E,
  0x07, 0x81, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC1, 0xE0, 0x70, 0x00, 0xFF,
  0xFC, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC3, 0xFF, 0xF0, 0x06, 0x3C,
  0x70, 0xC1, 0x83, 0x06, 0x0C, 0x39, 0xE3, 0xC1, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x3C, 0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE1,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x3C, 0x79, 0xC3, 0x06, 0x0C, 0x18,
  0x31, 0xE3, 0x84, 0x00, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 11, 16, 12, 0, -16 },
  { 35, 9, 18, 11, 1, -17 },
  { 56, 15, 16, 17, 1, -16 },
  { 86, 12, 16, 13, 1, -16 },
  { 110, 3, 6, 5, 1, -16 },
  { 113, 5, 19, 7, 1, -16 },
  { 125, 6, 19, 7, 0, -16 },
  { 140, 9, 9, 10, 1, -17 },
  { 151, 9, 10, 11, 1, -13 },
  { 163, 3, 6, 6, 1, -3 },
  { 166, 5, 2, 7, 1, -7 },
  { 168, 3, 3, 6, 1, -3 },
  { 170, 8, 16, 9, 0, -16 },
  { 186, 9, 16, 11, 1, -16 },
  { 204, 7, 16, 11, 1, -16 },
  { 218, 9, 16, 11, 1, -16 },
  { 236, 9, 16, 11, 1, -16 },
  { 254, 10, 16, 11, 0, -16 },
  { 274, 9, 16, 11, 1, -16 },
  { 292, 9, 16, 11, 1, -16 },
  { 310, 9, 16, 11, 1, -16 },
  { 328, 9, 16, 11, 1, -16 },
  { 346, 9, 16, 11, 1, -16 },
  { 364, 3, 12, 6, 1, -12 },
  { 369, 3, 15, 6, 1, -12 },
  { 375, 9, 10, 11, 1, -13 },
  { 387, 9, 6, 11, 1, -11 },
  { 394, 9, 10, 11, 1, -13 },
  { 406, 8, 16, 8, 0, -16 },
  { 422, 15, 18, 17, 1, -16 },
  { 456, 12, 16, 12, 0, -16 },
  { 480, 9, 16, 12, 2, -16 },
  { 498, 10, 16, 11, 1, -16 },
  { 518, 10, 16, 13, 2, -16 },
  { 538, 7, 16, 10, 2, -16 },
  { 552, 7, 16, 10, 2, -16 },
  { 566, 11, 16, 13, 1, -16 },
  { 588, 10, 16, 14, 2, -16 },
  { 608, 5, 16, 7, 1, -16 },
  { 618, 5, 20, 6, -1, -16 },
  { 631, 10, 16, 12, 2, -16 },
  { 651, 7, 16, 10, 2, -16 },
  { 665, 14, 16, 18, 2, -16 },
  { 693, 11, 16, 15, 2, -16 },
  { 715, 12, 16, 14, 1, -16 },
  { 739, 9, 16, 11, 2, -16 },
  { 757, 12, 20, 14, 1, -16 },
  { 787, 10, 16, 12, 2, -16 },
  { 807, 8, 16, 10, 1, -16 },
  { 823, 10, 16, 10, 0, -16 },
  { 843, 10, 16, 13, 2, -16 },
  { 863, 12, 16, 12, 0, -16 },
  { 887, 18, 16, 18, 0, -16 },
  { 923, 11, 16, 11, 0, -16 },
  { 945, 11, 16, 11, 0, -16 },
  { 967, 9, 16, 10, 0, -16 },
  { 985, 5, 20, 7, 1, -16 },
  { 998, 8, 16, 9, 0, -16 },
  { 1014, 5, 20, 7, 1, -16 },
  { 1027, 11, 10, 11, 0, -16 },
  { 1041, 9, 1, 9, 0, 2 },
  { 1043, 5, 4, 7, 1, -17 },
  { 1046, 8, 12, 11, 1, -12 },
  { 1058, 10, 17, 12, 1, -17 },
  { 1080, 8, 12, 9, 1, -12 },
  { 1092, 9, 17, 12, 1, -17 },
  { 1112, 9, 12, 11, 1, -12 },
  { 1126, 8, 17, 7, 0, -17 },
  { 1143, 9, 17, 12, 1, -12 },
  { 1163, 9, 17, 12, 1, -17 },
  { 1183, 3, 17, 5, 1, -17 },
  { 1190, 5, 22, 5, -1, -17 },
  { 1204, 10, 17, 11, 1, -17 },
  { 1226, 3, 17, 5, 1, -17 },
  { 1233, 15, 12, 17, 1, -12 },
  { 1256, 9, 12, 12, 1, -12 },
  { 1270, 9, 12, 11, 1, -12 },
  { 1284, 10, 17, 12, 1, -12 },
  { 1306, 9, 17, 12, 1, -12 },
  { 1326, 7, 12, 8, 1, -12 },
  { 1337, 7, 12, 9, 1, -12 },
  { 1348, 7, 15, 7, 0, -15 },
  { 1362, 9, 12, 12, 1, -12 },
  { 1376, 10, 12, 10, 0, -12 },
  { 1391, 15, 12, 16, 0, -12 },
  { 1414, 10, 12, 10, 0, -12 },
  { 1429, 10, 17, 10, 0, -12 },
  { 1451, 7, 12, 8, 1, -12 },
  { 1462, 7, 20, 8, 0, -16 },
  { 1480, 2, 22, 10, 4, -17 },
  { 1486, 7, 20, 8, 1, -16 },
  { 1504, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_SemiBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD22PT7B_H_
