#ifndef _NOTOSANS_CONDENSED_SEMIBOLD20PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x6C, 0x3F, 0xC0, 0xEF, 0x9B, 0x36, 0x6C, 0xC0,
  0x0D, 0x82, 0x61, 0x98, 0x64, 0x7F, 0xC6, 0xC1, 0xB0, 0x4C, 0xFF, 0xFF,
  0xF3, 0x20, 0xC8, 0x36, 0x09, 0x80, 0x10, 0x1C, 0x7F, 0xF2, 0xD0, 0xD0,
  0xF0, 0x7C, 0x1E, 0x17, 0x13, 0x97, 0xFE, 0xFC, 0x10, 0x10, 0x70, 0x63,
  0x63, 0x0D, 0x88, 0x36, 0x60, 0xD9, 0x83, 0x6C, 0xCD, 0xB7, 0x9C, 0xB3,
  0x06, 0xCC, 0x1B, 0x30, 0xCC, 0xC3, 0x33, 0x18, 0x78, 0x61, 0xE0, 0x3E,
  0x0F, 0xC1, 0x98, 0x33, 0x06, 0xE0, 0x78, 0x0E, 0x07, 0xE6, 0xCC, 0xD8,
  0xFB, 0x1E, 0x71, 0xCF, 0xFC, 0xF9, 0xC0, 0xFB, 0x6C, 0x39, 0x98, 0xCE,
  0x63, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x86, 0x38, 0xE1, 0x8C, 0x71, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x98, 0xCE, 0xE0, 0x18, 0x18, 0xD6, 0xFF, 0x38,
  0x6C, 0xEE, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x68, 0xFF, 0x7F, 0x80, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x10, 0x7C, 0x7E, 0xE6,
  0xC7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0x1C,
  0xF7, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x7C, 0xFE,
  0x86, 0x07, 0x06, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFE, 0x87, 0x07, 0x06, 0x0E, 0x78, 0x7E, 0x07, 0x07, 0x07, 0x87,
  0xFE, 0xFC, 0x07, 0x03, 0x83, 0xC3, 0x61, 0xB1, 0x98, 0xCC, 0xC6, 0x63,
  0x7F, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x7E, 0x7E, 0xE0, 0xE0, 0xC0, 0xFC,
  0xFE, 0x07, 0x07, 0x07, 0x07, 0x86, 0xFE, 0xFC, 0x3E, 0x7E, 0x60, 0xC0,
  0xC0, 0xDE, 0xFE, 0xE7, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70,
  0x7E, 0xEE, 0xC7, 0xC7, 0xE6, 0x7E, 0x38, 0x7E, 0xE7, 0xC3, 0xC3, 0xC7,
  0xFE, 0x7C, 0x7C, 0xFE, 0xC6, 0xC7, 0xC3, 0xC7, 0xE7, 0xFB, 0x7B, 0x07,
  0x06, 0x0E, 0xFC, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x1F, 0xED, 0x00, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0xFC, 0xFC, 0x18, 0x30, 0x61, 0xC7, 0x1C,
  0x30, 0x60, 0x01, 0x83, 0x87, 0x00, 0x0F, 0xC1, 0xC3, 0x1C, 0x0C, 0xC6,
  0x3C, 0xFD, 0xE6, 0x6F, 0x22, 0x7B, 0x13, 0xD8, 0x9E, 0x4C, 0xF3, 0xFD,
  0x8C, 0xC6, 0x00, 0x38, 0x20, 0x7F, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x6C,
  0x0D, 0x81, 0xB0, 0x77, 0x0C, 0x61, 0x8C, 0x3F, 0x8F, 0xF9, 0xC3, 0x30,
  0x6E, 0x0F, 0xC1, 0xC0, 0xFF, 0x7F, 0xF8, 0xFC, 0x7E, 0x3F, 0x3B, 0xF9,
  0xFE, 0xE3, 0xF0, 0xF8, 0x7C, 0x7F, 0xF7, 0xF0, 0x3F, 0xBF, 0x9C, 0x1C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x13, 0xF0, 0xF8,
  0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1B, 0x8E, 0xFF, 0x3F, 0x80, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF,
  0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0F, 0xFF, 0xC3,
  0x0C, 0x30, 0xC3, 0x00, 0x1F, 0xCF, 0xE7, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x7F, 0x9F, 0xE1, 0xF8, 0x76, 0x1D, 0xC7, 0x3F, 0xC7, 0xF0, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0C, 0xFB, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xCF, 0x7C, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xE7, 0xF7, 0x00, 0xC3,
  0xE3, 0xB3, 0x99, 0x8D, 0xC7, 0xC3, 0xE1, 0xF0, 0xDC, 0x66, 0x33, 0x98,
  0xEC, 0x76, 0x1C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xC0, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xFC, 0x5F, 0x66, 0xFB, 0x37, 0xD9, 0xBE, 0x79, 0xF3, 0xCF, 0x9E, 0x7C,
  0xE3, 0xE3, 0x1C, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF9, 0xF6, 0x7D, 0xDF,
  0x33, 0xCE, 0xF1, 0xBC, 0x7F, 0x0F, 0xC3, 0xF0, 0x70, 0x04, 0x07, 0xF1,
  0xFE, 0x38, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0xFE, 0x7F, 0xB8, 0xDC, 0x7E, 0x3F,
  0x1B, 0x9D, 0xFC, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x04, 0x07,
  0xF1, 0xFF, 0x38, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xB0, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0x18, 0x03, 0x80, 0x3C, 0xFE,
  0x3F, 0xCE, 0x3B, 0x8E, 0xE3, 0xB8, 0xCF, 0xF3, 0xF8, 0xEE, 0x39, 0x8E,
  0x73, 0x8C, 0xE3, 0xB8, 0x70, 0x7F, 0xFF, 0x06, 0x0E, 0x1E, 0x1E, 0x0F,
  0x0E, 0x0C, 0x1C, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x1D,
  0x86, 0x7F, 0x8F, 0xC0, 0xE0, 0xFC, 0x19, 0x87, 0x30, 0xC7, 0x18, 0x63,
  0x0C, 0xE1, 0x98, 0x3B, 0x03, 0x60, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x00,
  0xC1, 0x83, 0xE1, 0x87, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xCE,
  0x76, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x1C, 0x3C,
  0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xDC, 0xE3, 0x30, 0xEC, 0x1E, 0x07, 0x80,
  0xE0, 0x78, 0x1E, 0x0F, 0xC3, 0x31, 0xCE, 0x61, 0xB8, 0x70, 0xE1, 0xD8,
  0x67, 0x38, 0xCC, 0x37, 0x0F, 0x81, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x7F, 0x3F, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0xFE, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xE0, 0x60, 0x60, 0x30, 0x30,
  0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x0C, 0x03, 0x81, 0xE0, 0x6C, 0x33,
  0x0C, 0x66, 0x1B, 0x87, 0xFF, 0xE7, 0x30, 0x7C, 0x7E, 0x46, 0x06, 0x1F,
  0x7F, 0xC7, 0xC7, 0xC7, 0xFF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7,
  0xFB, 0x8D, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x37, 0xFB, 0x78, 0x3E,
  0xFF, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xFC, 0xF8, 0x03, 0x03, 0x03,
  0x03, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x7B,
  0x3C, 0x7E, 0xE7, 0xC3, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x7E, 0x3E, 0x3E,
  0x78, 0xC1, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x00, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x7B,
  0x03, 0x03, 0xC7, 0xFE, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xDF, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFD, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x39, 0xC4, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0x3B, 0xB9, 0xD8,
  0xF8, 0x7E, 0x3B, 0x1D, 0xCE, 0x67, 0x3B, 0x8E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xDE, 0x73, 0x7F, 0xEE, 0x79, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C,
  0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xC0, 0xDE, 0xDF,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3C, 0x7E, 0xE7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3E, 0xDE, 0x6F, 0xB8, 0xDC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x7F, 0xBF, 0x9C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F,
  0x7B, 0x03, 0x03, 0x03, 0x03, 0x03, 0xCF, 0x7F, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x00, 0x7F, 0xFC, 0x70, 0xF1, 0xE1, 0xC3, 0x8F, 0xFF, 0x80,
  0x30, 0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x0F, 0x3C, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x7B, 0xE1, 0xF1, 0xD8,
  0xCC, 0x67, 0x31, 0xB0, 0xD8, 0x6C, 0x16, 0x0E, 0x07, 0x00, 0xE3, 0x0F,
  0x9E, 0x76, 0x79, 0x99, 0xE6, 0x66, 0x99, 0xD2, 0xE3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC1, 0x86, 0x00, 0xE3, 0xB1, 0x8D, 0x86, 0xC1, 0xC0,
  0xE0, 0x78, 0x6C, 0x77, 0x31, 0xB8, 0xE0, 0xE1, 0xF1, 0xD8, 0xCC, 0x67,
  0x31, 0xB0, 0xD8, 0x6C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC1, 0xC0,
  0xC0, 0x7E, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x60, 0xFF, 0xF8, 0x1E,
  0x3C, 0x60, 0xC1, 0x83, 0x06, 0x38, 0xE0, 0x60, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC7, 0x1C, 0x71, 0xC3,
  0x0E, 0x1C, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0xE0, 0x61, 0xF9, 0x9F,
};

const GFXglyph NotoSans_Condensed_SemiBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 11, 0, -14 },
  { 30, 8, 16, 10, 1, -15 },
  { 46, 14, 14, 15, 1, -14 },
  { 71, 11, 14, 12, 1, -14 },
  { 91, 3, 5, 5, 1, -14 },
  { 93, 5, 17, 6, 1, -14 },
  { 104, 5, 17, 6, 0, -14 },
  { 115, 8, 8, 9, 1, -15 },
  { 123, 8, 10, 10, 1, -12 },
  { 133, 3, 5, 5, 1, -2 },
  { 135, 4, 2, 6, 1, -6 },
  { 136, 3, 3, 5, 1, -3 },
  { 138, 8, 14, 8, 0, -14 },
  { 152, 8, 15, 10, 1, -15 },
  { 167, 6, 14, 10, 1, -14 },
  { 178, 8, 14, 10, 1, -14 },
  { 192, 8, 14, 10, 1, -14 },
  { 206, 9, 14, 10, 0, -14 },
  { 222, 8, 14, 10, 1, -14 },
  { 236, 8, 14, 10, 1, -14 },
  { 250, 8, 14, 10, 1, -14 },
  { 264, 8, 14, 10, 1, -14 },
  { 278, 8, 14, 10, 1, -14 },
  { 292, 3, 11, 5, 1, -11 },
  { 297, 3, 14, 5, 1, -11 },
  { 303, 8, 10, 10, 1, -12 },
  { 313, 8, 6, 10, 1, -10 },
  { 319, 8, 10, 10, 1, -12 },
  { 329, 7, 14, 8, 0, -14 },
  { 342, 13, 16, 15, 1, -14 },
  { 368, 11, 14, 11, 0, -14 },
  { 388, 9, 14, 11, 1, -14 },
  { 404, 9, 14, 10, 1, -14 },
  { 420, 10, 14, 12, 1, -14 },
  { 438, 6, 14, 9, 2, -14 },
  { 449, 6, 14, 9, 2, -14 },
  { 460, 10, 14, 12, 1, -14 },
  { 478, 9, 14, 12, 2, -14 },
  { 494, 5, 14, 6, 1, -14 },
  { 503, 5, 18, 5, -1, -14 },
  { 515, 9, 14, 11, 2, -14 },
  { 531, 7, 14, 9, 1, -14 },
  { 544, 13, 14, 16, 2, -14 },
  { 567, 10, 14, 13, 2, -14 },
  { 585, 11, 15, 13, 1, -15 },
  { 606, 9, 14, 10, 1, -14 },
  { 622, 11, 18, 13, 1, -15 },
  { 647, 10, 14, 11, 1, -14 },
  { 665, 7, 14, 9, 1, -14 },
  { 678, 9, 14, 9, 0, -14 },
  { 694, 10, 14, 12, 1, -14 },
  { 712, 11, 14, 11, 0, -14 },
  { 732, 16, 14, 16, 0, -14 },
  { 760, 10, 14, 10, 0, -14 },
  { 778, 10, 14, 10, 0, -14 },
  { 796, 9, 14, 9, 0, -14 },
  { 812, 5, 17, 6, 1, -14 },
  { 823, 8, 14, 8, 0, -14 },
  { 837, 4, 17, 6, 1, -14 },
  { 846, 10, 8, 10, 0, -14 },
  { 856, 8, 1, 8, 0, 2 },
  { 857, 4, 3, 6, 1, -15 },
  { 859, 8, 11, 10, 1, -11 },
  { 870, 9, 15, 11, 1, -15 },
  { 887, 7, 11, 8, 1, -11 },
  { 897, 8, 15, 11, 1, -15 },
  { 912, 8, 11, 10, 1, -11 },
  { 923, 7, 15, 6, 0, -15 },
  { 937, 8, 16, 11, 1, -11 },
  { 953, 8, 15, 11, 1, -15 },
  { 968, 3, 15, 5, 1, -15 },
  { 974, 5, 20, 5, -1, -15 },
  { 987, 9, 15, 10, 1, -15 },
  { 1004, 3, 15, 5, 1, -15 },
  { 1010, 14, 11, 16, 1, -11 },
  { 1030, 8, 11, 11, 1, -11 },
  { 1041, 8, 11, 10, 1, -11 },
  { 1052, 9, 16, 11, 1, -11 },
  { 1070, 8, 16, 11, 1, -11 },
  { 1086, 6, 11, 7, 1, -11 },
  { 1095, 6, 11, 8, 1, -11 },
  { 1104, 6, 13, 7, 0, -13 },
  { 1114, 8, 11, 11, 1, -11 },
  { 1125, 9, 11, 9, 0, -11 },
  { 1138, 14, 11, 14, 0, -11 },
  { 1158, 9, 11, 9, 0, -11 },
  { 1171, 9, 16, 9, 0, -11 },
  { 1189, 7, 11, 8, 0, -11 },
  { 1199, 7, 17, 7, 0, -14 },
  { 1214, 2, 20, 9, 4, -15 },
  { 1219, 6, 17, 7, 1, -14 },
  { 1232, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_SemiBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD20PT7B_H_
