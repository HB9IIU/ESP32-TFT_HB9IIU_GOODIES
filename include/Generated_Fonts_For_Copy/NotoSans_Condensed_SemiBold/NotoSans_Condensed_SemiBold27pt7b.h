#ifndef _NOTOSANS_CONDENSED_SEMIBOLD27PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xF3, 0xB9, 0xDC,
  0xEE, 0x77, 0x3B, 0x1D, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x19, 0xC1,
  0xCC, 0x7F, 0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xCE, 0x06, 0x71, 0xFF,
  0xEF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x81, 0x9C, 0x1C, 0xC0,
  0x04, 0x00, 0x80, 0x10, 0x1F, 0xF7, 0xFC, 0xE9, 0xB9, 0x07, 0x20, 0xF4,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x0B, 0xC1, 0x38, 0x27, 0xC5, 0xFF,
  0xFB, 0xFE, 0x0F, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x00, 0x0F, 0x81,
  0xC1, 0xF8, 0x30, 0x73, 0x0E, 0x0E, 0x61, 0x81, 0x8E, 0x70, 0x31, 0xCC,
  0x06, 0x3B, 0x80, 0xE6, 0x63, 0x9C, 0xCD, 0xF9, 0xFB, 0xBB, 0x3E, 0x66,
  0x71, 0x1D, 0xCE, 0x03, 0x39, 0xC0, 0xE7, 0x38, 0x18, 0xE7, 0x03, 0x0C,
  0xE0, 0xE1, 0x98, 0x18, 0x3F, 0x07, 0x03, 0xC0, 0x06, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x3F,
  0x00, 0x3C, 0x00, 0xF8, 0x73, 0xF8, 0xEF, 0x7B, 0xDC, 0x7F, 0x38, 0x7E,
  0x70, 0x78, 0xF0, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xF8, 0xF0, 0xF7, 0x77,
  0x76, 0x60, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x80, 0xE1,
  0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0xE3, 0x8E, 0x71, 0xCE, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x46, 0x2F, 0xFD,
  0xFF, 0xC7, 0x80, 0xF8, 0x3B, 0x8E, 0x78, 0xC4, 0x00, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x77, 0x76, 0xEE, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00,
  0x04, 0x07, 0xF0, 0xFE, 0x3D, 0xE7, 0x1D, 0xE3, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8F, 0x71, 0xCF,
  0xF8, 0xFE, 0x0F, 0x80, 0x0E, 0x3C, 0xFB, 0xFE, 0xF9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x04, 0x07, 0xF3,
  0xFF, 0x79, 0xE4, 0x1C, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x04, 0x0F, 0xF3, 0xFF, 0x31, 0xE4, 0x1C, 0x03, 0xC0, 0x70, 0x0E,
  0x07, 0x87, 0xE0, 0xFE, 0x07, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x0F, 0x81,
  0xFE, 0xFB, 0xFF, 0x7F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x6E, 0x07, 0x70, 0x37, 0x83, 0xBC, 0x19, 0xE1, 0xCF, 0x0C, 0x78, 0xE3,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x7F,
  0xCF, 0xF8, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x7C, 0x0E, 0xFF, 0xDF,
  0xF1, 0xFC, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x1E, 0x07, 0x80, 0xE0, 0x18,
  0x07, 0x00, 0xEF, 0x9F, 0xFB, 0xE7, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x87, 0x71, 0xEF, 0xF8, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x00, 0x04, 0x07,
  0xF1, 0xFF, 0x38, 0xEF, 0x0F, 0xC1, 0xDC, 0x7B, 0x8E, 0x3F, 0x83, 0xE0,
  0xFE, 0x3D, 0xE7, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF,
  0x1F, 0xC0, 0x04, 0x07, 0xE1, 0xFE, 0x39, 0xEE, 0x1D, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0xC9, 0xF1, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x77, 0x77, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0xEE, 0xC0, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x08, 0x1F, 0xCF, 0xF9,
  0x8F, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x07, 0x03, 0xC0, 0x70, 0x03, 0xFC, 0x03,
  0xFF, 0x81, 0xC0, 0x70, 0xE0, 0x0E, 0x30, 0x01, 0x9C, 0x7E, 0x76, 0x3F,
  0x8D, 0x8C, 0x63, 0xE7, 0x18, 0xF9, 0x86, 0x3E, 0x61, 0x8F, 0x98, 0xE3,
  0xE6, 0x39, 0xF9, 0xCE, 0x66, 0x3E, 0xF9, 0x87, 0x1C, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x40, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x76, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1E,
  0x0F, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x3B, 0xC0, 0x78, 0xFF, 0x8F, 0xFC,
  0xE3, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0x8F, 0xFC,
  0xE3, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF, 0xFC,
  0xFF, 0x80, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xE7, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x7C, 0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x87, 0xFE, 0x3F,
  0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x83, 0xDC, 0x3C, 0xFF, 0xE7,
  0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00,
  0x80, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x3D, 0xC0, 0xF7,
  0x03, 0xDE, 0x0F, 0x3C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x79, 0xFF, 0xF8, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xF3, 0xFF, 0x7E, 0x20, 0xE0, 0xF7, 0x07, 0x38,
  0x79, 0xC7, 0x8E, 0x38, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xFE, 0x07, 0xF8,
  0x3F, 0xC1, 0xEF, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7,
  0x07, 0xB8, 0x1E, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0D,
  0xFF, 0x07, 0x7E, 0xE1, 0xDF, 0xB8, 0x77, 0xEE, 0x19, 0xF9, 0x8E, 0x7E,
  0x73, 0x9F, 0x9C, 0xC7, 0xE7, 0x71, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x8F,
  0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1C, 0x1C, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xB8, 0x7E, 0xE1, 0xFB, 0xC7, 0xE7, 0x1F,
  0x9E, 0x7E, 0x39, 0xF8, 0xF7, 0xE1, 0xDF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xC0, 0x03, 0x00, 0x1F, 0xE0, 0x7F, 0xE1,
  0xE3, 0xC7, 0x83, 0xCE, 0x03, 0x9C, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0x3C, 0x0E,
  0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x1F, 0xFB, 0xFF,
  0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xDF, 0xFB, 0xFE, 0x7F,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xE3, 0xC7, 0x83, 0xCE, 0x03, 0x9C, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEE,
  0x03, 0xDC, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0xFF, 0x8F,
  0xFC, 0xE7, 0xEE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE3, 0xCF,
  0xF8, 0xFF, 0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE,
  0x0F, 0xE0, 0x70, 0x06, 0x0F, 0xF7, 0xFD, 0xE7, 0xF0, 0x38, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xFF, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDE, 0x0E, 0x7F,
  0xF3, 0xFF, 0x07, 0xF0, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x70,
  0x38, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x73, 0xC1, 0xCE, 0x07,
  0x38, 0x0C, 0xE0, 0x3B, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x70, 0x3F, 0x81, 0xE0, 0xE7, 0x07, 0x83, 0x9C, 0x1E,
  0x0E, 0x70, 0xF8, 0x79, 0xC3, 0xF1, 0xC7, 0x8D, 0xC7, 0x0E, 0x37, 0x1C,
  0x39, 0xDC, 0x70, 0xE7, 0x33, 0xC3, 0x9C, 0xEE, 0x0F, 0x63, 0xB8, 0x1D,
  0x8E, 0xE0, 0x7E, 0x1B, 0x81, 0xF8, 0x6E, 0x07, 0xE1, 0xF0, 0x0F, 0x07,
  0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x79, 0xE1, 0xC3, 0x8F,
  0x0F, 0x38, 0x1C, 0xE0, 0x77, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x73, 0x83, 0xCE, 0x0E, 0x3C, 0x78,
  0x71, 0xC1, 0xEF, 0x03, 0xC0, 0xF0, 0x3B, 0x83, 0xDC, 0x1C, 0x71, 0xE3,
  0x8E, 0x1E, 0x70, 0x77, 0x03, 0xB8, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0xFF, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1F, 0xFF, 0xC0, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1B, 0x83, 0x9C,
  0x39, 0xC7, 0x0E, 0x70, 0xEE, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1,
  0xC3, 0x87, 0x0C, 0x1F, 0x1F, 0xE3, 0xFC, 0x87, 0x01, 0xC0, 0x71, 0xFD,
  0xFF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xB7, 0xCC, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xC7, 0xFC, 0xFF, 0xDE, 0x3F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3F, 0xEF,
  0x7F, 0xEC, 0xF8, 0x0F, 0x8F, 0xF7, 0xF9, 0xC0, 0x70, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x7D, 0x8F, 0xE1, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF3, 0xFF, 0x7F, 0xF7,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7,
  0x0F, 0x7B, 0xF7, 0xF7, 0x3E, 0x70, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0xFF,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x8C,
  0x7F, 0x87, 0xF0, 0x07, 0x0F, 0xC7, 0xE7, 0x83, 0x81, 0xC0, 0xFD, 0xFE,
  0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x1F, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0F, 0x7B, 0xF7, 0xFF,
  0x3E, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x61, 0xE7, 0xFC, 0x7F, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xC7, 0xFE, 0xFF, 0xDE,
  0x3B, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1E, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x71, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFB, 0xE0, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x3F, 0x0E, 0xE3, 0x9C, 0xF3, 0x9C, 0x77,
  0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0x38, 0xE7, 0x9C, 0x73, 0x87, 0x70, 0xEE,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xCF, 0x0F, 0x37,
  0xE7, 0xEF, 0xFF, 0xFB, 0xC7, 0x8F, 0xE1, 0xE3, 0xF8, 0x70, 0x7E, 0x1C,
  0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07,
  0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1C, 0xC7, 0x1B, 0xFB, 0xFF, 0x78,
  0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x78, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xE7, 0x0E, 0x79, 0xE3,
  0xFC, 0x1F, 0x80, 0xC7, 0x1F, 0xF3, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0xBD, 0xFF, 0xBB, 0xE7,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x1E, 0x73, 0xF7, 0x7F,
  0xF7, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xF7, 0x0F, 0x7B, 0xF3, 0xFF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xC7, 0xCE, 0xFE, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F, 0xFF, 0xDC, 0x2E,
  0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x7E, 0xFF, 0xFB, 0xF8,
  0x18, 0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3D, 0x3F, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF,
  0xFD, 0xDF, 0x38, 0xE0, 0x7F, 0x07, 0x70, 0xF7, 0x0E, 0x70, 0xE3, 0x8E,
  0x39, 0xC3, 0x9C, 0x39, 0xC1, 0xD8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xE0, 0xE0, 0xFE, 0x1E, 0x3D, 0xC7, 0xC7, 0x38, 0xD8, 0xE7,
  0x1B, 0x1C, 0xE3, 0x63, 0x8E, 0xEE, 0xE1, 0xDD, 0xDC, 0x3B, 0x1B, 0x87,
  0x63, 0x70, 0x6C, 0x6C, 0x0D, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x03,
  0x83, 0x80, 0xF0, 0xF7, 0x0E, 0x39, 0xE3, 0x9C, 0x1F, 0xC1, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0x9C, 0x39, 0xE7, 0x0E, 0xF0,
  0xF0, 0xE0, 0x7F, 0x07, 0x70, 0xF7, 0x0E, 0x78, 0xE3, 0x8E, 0x39, 0xC3,
  0x9C, 0x1D, 0xC1, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0x7F, 0xBF,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0x1F, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38,
  0xF8, 0xE0, 0xF8, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x07,
  0x1F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0x20,
  0x3F, 0x87, 0xFF, 0xC3, 0xF8, 0x08,
};

const GFXglyph NotoSans_Condensed_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 9, 7, 12, 1, -19 },
  { 17, 13, 19, 14, 1, -19 },
  { 48, 11, 23, 13, 1, -21 },
  { 80, 19, 20, 21, 1, -20 },
  { 128, 15, 20, 16, 1, -20 },
  { 166, 4, 7, 6, 1, -19 },
  { 170, 7, 23, 8, 1, -19 },
  { 191, 6, 23, 8, 1, -19 },
  { 209, 11, 11, 12, 1, -21 },
  { 225, 11, 13, 13, 1, -16 },
  { 243, 4, 7, 7, 1, -3 },
  { 247, 6, 3, 8, 1, -9 },
  { 250, 3, 4, 7, 2, -4 },
  { 252, 10, 19, 11, 0, -19 },
  { 276, 11, 20, 13, 1, -20 },
  { 304, 7, 19, 13, 2, -19 },
  { 321, 11, 20, 13, 1, -20 },
  { 349, 11, 20, 13, 1, -20 },
  { 377, 13, 19, 13, 0, -19 },
  { 408, 11, 19, 13, 1, -19 },
  { 435, 11, 20, 13, 1, -20 },
  { 463, 11, 19, 13, 1, -19 },
  { 490, 11, 20, 13, 1, -20 },
  { 518, 11, 20, 13, 1, -20 },
  { 546, 3, 15, 7, 2, -15 },
  { 552, 4, 19, 7, 1, -15 },
  { 562, 11, 13, 13, 1, -16 },
  { 580, 11, 7, 13, 1, -13 },
  { 590, 11, 13, 13, 1, -16 },
  { 608, 10, 20, 10, 0, -20 },
  { 633, 18, 21, 20, 1, -19 },
  { 681, 15, 19, 15, 0, -19 },
  { 717, 12, 19, 15, 2, -19 },
  { 746, 12, 20, 14, 1, -20 },
  { 776, 13, 19, 16, 2, -19 },
  { 807, 9, 19, 13, 2, -19 },
  { 829, 9, 19, 12, 2, -19 },
  { 851, 14, 20, 16, 1, -20 },
  { 886, 13, 19, 17, 2, -19 },
  { 917, 7, 19, 9, 1, -19 },
  { 934, 7, 25, 7, -2, -19 },
  { 956, 13, 19, 14, 2, -19 },
  { 987, 9, 19, 12, 2, -19 },
  { 1009, 18, 19, 22, 2, -19 },
  { 1052, 14, 19, 18, 2, -19 },
  { 1086, 15, 20, 17, 1, -20 },
  { 1124, 11, 19, 14, 2, -19 },
  { 1151, 15, 25, 17, 1, -20 },
  { 1198, 12, 19, 15, 2, -19 },
  { 1227, 10, 20, 12, 1, -20 },
  { 1252, 12, 19, 12, 0, -19 },
  { 1281, 13, 19, 17, 2, -19 },
  { 1312, 14, 19, 14, 0, -19 },
  { 1346, 22, 19, 22, 0, -19 },
  { 1399, 14, 19, 14, 0, -19 },
  { 1433, 13, 19, 13, 0, -19 },
  { 1464, 11, 19, 12, 1, -19 },
  { 1491, 6, 23, 9, 2, -19 },
  { 1509, 10, 19, 11, 0, -19 },
  { 1533, 6, 23, 9, 1, -19 },
  { 1551, 12, 11, 14, 1, -19 },
  { 1568, 11, 2, 11, 0, 2 },
  { 1571, 6, 5, 8, 1, -21 },
  { 1575, 10, 15, 13, 1, -15 },
  { 1594, 11, 21, 14, 2, -21 },
  { 1623, 10, 15, 11, 1, -15 },
  { 1642, 12, 21, 14, 1, -21 },
  { 1674, 11, 15, 13, 1, -15 },
  { 1695, 9, 21, 8, 0, -21 },
  { 1719, 12, 21, 14, 1, -15 },
  { 1751, 11, 21, 14, 2, -21 },
  { 1780, 3, 20, 7, 2, -20 },
  { 1788, 6, 26, 7, -1, -20 },
  { 1808, 11, 21, 13, 2, -21 },
  { 1837, 3, 21, 7, 2, -21 },
  { 1845, 18, 15, 21, 2, -15 },
  { 1879, 11, 15, 14, 2, -15 },
  { 1900, 12, 15, 14, 1, -15 },
  { 1923, 11, 21, 14, 2, -15 },
  { 1952, 12, 21, 14, 1, -15 },
  { 1984, 8, 15, 10, 2, -15 },
  { 1999, 9, 15, 11, 1, -15 },
  { 2016, 8, 18, 9, 0, -18 },
  { 2034, 11, 15, 14, 2, -15 },
  { 2055, 12, 15, 12, 0, -15 },
  { 2078, 19, 15, 19, 0, -15 },
  { 2114, 12, 15, 12, 0, -15 },
  { 2137, 12, 21, 12, 0, -15 },
  { 2169, 9, 15, 10, 1, -15 },
  { 2186, 8, 23, 10, 1, -19 },
  { 2209, 3, 27, 13, 5, -21 },
  { 2220, 8, 23, 10, 1, -19 },
  { 2243, 11, 5, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD27PT7B_H_
