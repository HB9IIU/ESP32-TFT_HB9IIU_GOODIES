#ifndef _NOTOSANS_CONDENSED_SEMIBOLD67PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C, 0x00, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF,
  0x80, 0xFD, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFC,
  0xE1, 0xF1, 0xFF, 0x1C, 0x06, 0x3F, 0xC3, 0x80, 0x07, 0xF8, 0x70, 0x00,
  0xFE, 0x0E, 0x00, 0x1F, 0xC1, 0xC0, 0x03, 0xFC, 0x38, 0x00, 0x7F, 0x87,
  0x00, 0x07, 0xF8, 0xE0, 0x00, 0xFF, 0xDC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x77, 0xFE, 0x00, 0x0E, 0x7F, 0xC0, 0x01, 0xC3,
  0xFC, 0x00, 0x38, 0x7F, 0x80, 0x07, 0x0F, 0xF0, 0x00, 0xE0, 0xFE, 0x00,
  0x1C, 0x3F, 0xE0, 0x03, 0x87, 0xFF, 0x00, 0x70, 0xFE, 0xF8, 0x0E, 0x7F,
  0xDF, 0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x3F, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0xE0,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFF, 0xF0, 0x7F, 0x0F, 0xC7, 0xF1, 0xFF, 0xF8,
  0x3F, 0x1F, 0xC7, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xE3, 0xF9, 0xFC,
  0x1F, 0xFF, 0x8F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0x0F, 0xC7, 0xF0, 0xFE,
  0x0F, 0xFE, 0x1F, 0x87, 0xE0, 0x7E, 0x03, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x00, 0x60, 0x3F, 0x87, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xE7, 0xF8, 0x1F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFC,
  0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0x7F, 0xCF, 0xF0, 0xFF, 0x80, 0xFF, 0x3F,
  0xC3, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xC0,
  0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00,
  0xF8, 0x06, 0x7C, 0x1F, 0x07, 0xCF, 0xF3, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0x38, 0x0E, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC,
  0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xBF, 0xBF, 0xE7, 0xFF, 0xF8, 0xFE, 0xFE,
  0x1F, 0xCF, 0x83, 0xF8, 0xE0, 0xFF, 0x08, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x3F, 0xFC, 0x3F, 0x80, 0x7F, 0xC1, 0xE0, 0x03, 0xFC, 0x0C, 0x00, 0x3F,
  0xC0, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xFC, 0x1E, 0x00, 0x7F, 0xC1, 0xC0, 0x03,
  0xFC, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x80, 0x00,
  0x3F, 0xEF, 0x00, 0x07, 0xFE, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3E, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x7E, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF4, 0x00, 0x07, 0xFC, 0xF0, 0x01, 0xFF, 0x9F, 0xC0, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xFC, 0x07, 0xF1, 0xFF, 0xE0, 0x7F,
  0x3F, 0xFF, 0x87, 0xF7, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF0, 0x7F, 0xEF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF3, 0xFC,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF9, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFC,
  0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xCF, 0xE0, 0x3F, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF0, 0xE0, 0x07, 0x83, 0xF8, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1F, 0xC1, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xC7, 0xFF, 0x3C, 0x01, 0xFF, 0x10, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x38, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xFF, 0x03, 0xF0, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0x87, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7E, 0x3F, 0x01, 0xFF, 0xFF, 0x03, 0xF3, 0xF8, 0x1F, 0xF1,
  0xF8, 0x1F, 0x9F, 0x80, 0xFE, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xE7, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xBF, 0x07, 0xF0, 0x1F, 0x80,
  0xFF, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xEF, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFB, 0xF0, 0x3F,
  0x01, 0xFC, 0x0F, 0xDF, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xE7, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x3F, 0x01, 0xF8, 0x3F,
  0xE1, 0xF8, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xFE, 0x7F,
  0xFC, 0x3F, 0x01, 0xFF, 0xE3, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0x0F, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xFC,
  0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xF9, 0xFE, 0x00, 0x7F,
  0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xFC, 0x0F, 0xFE, 0x00, 0xF0, 0x3F,
  0xF0, 0x00, 0x41, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x08, 0x3F,
  0xF8, 0x00, 0xE0, 0x7F, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0x00, 0x1E, 0x07, 0xFF,
  0x00, 0x01, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xFB, 0xFC, 0x01, 0xFF,
  0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0x87, 0xFF,
  0x00, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFF,
  0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFB, 0x9F, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF,
  0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0xFF, 0xBF, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF7,
  0xFF, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xEF, 0xE0, 0x00, 0x7E, 0xFF, 0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xFF, 0xE7,
  0xF0, 0x00, 0xFE, 0xFF, 0xFE, 0x7F, 0x00, 0x0F, 0xCF, 0xFF, 0xE7, 0xF0,
  0x01, 0xFC, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x01,
  0xF8, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0x8F, 0xFF, 0xF1, 0xF8, 0x03, 0xF8,
  0xFF, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xFF, 0xF1, 0xFC, 0x03, 0xF0, 0xFF,
  0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0xFF,
  0x0F, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x07,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0x07, 0xF0,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xF9, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0x9F, 0x80, 0xFF, 0xFF, 0x03, 0xFB, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x07, 0xFF,
  0xE7, 0xF8, 0x01, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xC0, 0x1F,
  0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0x80,
  0x7F, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0x81, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xFF,
  0x01, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF,
  0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFB, 0xFF,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xA0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xF7, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xE1, 0xFE,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x3E, 0x7F, 0xC0,
  0x03, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0x7E, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x3F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x7E, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xF8,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x3F, 0x8F, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x7E, 0x7F, 0x80, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7E, 0x0F, 0xFC, 0x1C, 0x01,
  0xFF, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xDF, 0xF0, 0x07, 0xF7, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F,
  0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xCF, 0xFF,
  0xF3, 0xF1, 0xFF, 0xF8, 0xFC, 0x3F, 0xFC, 0x3F, 0x07, 0xFE, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE1, 0xFF,
  0x80, 0xFF, 0x3F, 0xFF, 0x07, 0xFB, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00,
  0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF,
  0xF0, 0x07, 0xF9, 0xFF, 0xC0, 0x7F, 0xCF, 0xFF, 0x07, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF,
  0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xF8, 0x0C, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xCF, 0xFC, 0x0F, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0x07, 0xFF,
  0xCF, 0xF0, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF,
  0x3F, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0x7F, 0x01, 0xFF, 0x03,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x0F, 0xFC, 0x01,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xE7, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE, 0x7F,
  0x1F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFE,
  0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF,
  0xF0, 0x7F, 0xFC, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x20, 0x00, 0x3F, 0xE3,
  0xC0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0xFF, 0xF0, 0xFF, 0x3F,
  0xFF, 0x1F, 0xEF, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x7F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x80, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF7, 0xFF, 0xEF, 0xFF,
  0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F,
  0x8F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0x83, 0xFE, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3,
  0xF8, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x07,
  0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0x3F,
  0x8F, 0xFF, 0xC1, 0xFC, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0x1F, 0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0x1F,
  0xE7, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x01,
  0xFE, 0x7F, 0xF0, 0x1F, 0xF3, 0xFF, 0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0xFC, 0x3F, 0xCF, 0xFF, 0xC1, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0x80, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x7F,
  0x07, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xFF, 0x7F, 0xC0, 0x3F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC,
  0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFC, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x03, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xEF, 0xE3, 0xFE, 0xFE, 0x7F, 0xEF,
  0xEF, 0xFE, 0xFE, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x1F, 0xF0, 0x7E, 0x3F, 0xC0, 0x18, 0xFF, 0x00, 0x11, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xDC, 0x00, 0x7F, 0xBF, 0x01,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x1E, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0xC3, 0xFF, 0xDF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE3, 0xFF, 0xF8, 0xFC, 0x3F, 0xFE,
  0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xEF, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x7F, 0x00,
  0x7F, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xC7, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x1F, 0x7E, 0x03, 0xFC, 0x3F, 0x80, 0xFD,
  0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xDF,
  0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x3F, 0x07, 0xF8, 0x1F, 0xC1, 0xF8, 0xFC,
  0x1F, 0xE0, 0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0x8F, 0xC1,
  0xFC, 0x07, 0xF8, 0x7E, 0x3F, 0x0F, 0xF0, 0x0F, 0xE1, 0xF8, 0x7E, 0x3F,
  0xC0, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x07, 0xE3, 0xF8,
  0x03, 0xFC, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xF3, 0xF0, 0x7E, 0x7F, 0x80,
  0x1F, 0xCF, 0xC0, 0xF9, 0xFC, 0x00, 0x7F, 0x3E, 0x03, 0xF7, 0xF0, 0x01,
  0xFD, 0xF8, 0x0F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x3F, 0x7F, 0x00, 0x0F,
  0xDF, 0x80, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF8, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x08, 0xFF, 0xC0, 0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0xC0, 0x03, 0xFF, 0xE4, 0x00, 0x07, 0xFC, 0x20, 0x00, 0x00,
  0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 49, 17, 4, -48 },
  { 57, 21, 17, 29, 4, -48 },
  { 102, 34, 48, 36, 1, -48 },
  { 306, 27, 55, 33, 3, -51 },
  { 492, 48, 50, 52, 2, -49 },
  { 792, 38, 50, 40, 2, -49 },
  { 1030, 8, 17, 16, 4, -48 },
  { 1047, 16, 59, 21, 3, -48 },
  { 1165, 16, 59, 21, 2, -48 },
  { 1283, 27, 27, 31, 2, -51 },
  { 1375, 28, 32, 33, 2, -40 },
  { 1487, 11, 17, 17, 2, -8 },
  { 1511, 16, 8, 20, 2, -22 },
  { 1527, 9, 10, 17, 4, -9 },
  { 1539, 25, 48, 26, 1, -48 },
  { 1689, 28, 50, 33, 2, -49 },
  { 1864, 19, 48, 33, 4, -48 },
  { 1978, 28, 49, 33, 2, -49 },
  { 2150, 28, 50, 33, 2, -49 },
  { 2325, 31, 48, 33, 1, -48 },
  { 2511, 27, 49, 33, 3, -48 },
  { 2677, 28, 49, 33, 2, -48 },
  { 2849, 28, 48, 33, 2, -48 },
  { 3017, 28, 49, 33, 2, -48 },
  { 3189, 28, 49, 33, 2, -48 },
  { 3361, 9, 38, 17, 4, -37 },
  { 3404, 11, 46, 17, 2, -37 },
  { 3468, 28, 32, 33, 2, -40 },
  { 3580, 28, 19, 33, 2, -33 },
  { 3647, 28, 32, 33, 2, -40 },
  { 3759, 24, 50, 26, 0, -49 },
  { 3909, 45, 54, 51, 3, -48 },
  { 4213, 37, 48, 37, 0, -48 },
  { 4435, 29, 48, 37, 5, -48 },
  { 4609, 30, 50, 35, 3, -49 },
  { 4797, 32, 48, 40, 5, -48 },
  { 4989, 23, 48, 31, 5, -48 },
  { 5127, 23, 48, 30, 5, -48 },
  { 5265, 33, 50, 41, 3, -49 },
  { 5472, 32, 48, 42, 5, -48 },
  { 5664, 18, 48, 22, 2, -48 },
  { 5772, 17, 62, 18, -4, -48 },
  { 5904, 31, 48, 36, 5, -48 },
  { 6090, 23, 48, 29, 5, -48 },
  { 6228, 44, 48, 54, 5, -48 },
  { 6492, 34, 48, 44, 5, -48 },
  { 6696, 37, 50, 43, 3, -49 },
  { 6928, 27, 48, 35, 5, -48 },
  { 7090, 37, 60, 43, 3, -49 },
  { 7368, 31, 48, 36, 5, -48 },
  { 7554, 25, 50, 31, 3, -49 },
  { 7711, 29, 48, 31, 1, -48 },
  { 7885, 31, 49, 41, 5, -48 },
  { 8075, 35, 48, 35, 0, -48 },
  { 8285, 54, 48, 54, 0, -48 },
  { 8609, 34, 48, 34, 0, -48 },
  { 8813, 33, 48, 33, 0, -48 },
  { 9011, 28, 48, 30, 1, -48 },
  { 9179, 16, 59, 21, 4, -48 },
  { 9297, 25, 48, 26, 1, -48 },
  { 9447, 15, 59, 21, 2, -48 },
  { 9558, 32, 29, 35, 1, -48 },
  { 9674, 28, 4, 28, 0, 6 },
  { 9688, 15, 10, 21, 3, -51 },
  { 9707, 26, 38, 33, 2, -37 },
  { 9831, 29, 52, 35, 4, -51 },
  { 10020, 23, 38, 28, 3, -37 },
  { 10130, 28, 52, 35, 3, -51 },
  { 10312, 27, 38, 33, 3, -37 },
  { 10441, 22, 51, 21, 1, -51 },
  { 10582, 28, 53, 35, 3, -37 },
  { 10768, 27, 51, 36, 4, -51 },
  { 10941, 9, 50, 17, 4, -50 },
  { 10998, 15, 66, 17, -2, -50 },
  { 11122, 28, 51, 33, 5, -51 },
  { 11301, 8, 51, 16, 4, -51 },
  { 11352, 45, 37, 53, 4, -37 },
  { 11561, 27, 37, 36, 4, -37 },
  { 11686, 29, 38, 35, 3, -37 },
  { 11824, 29, 53, 35, 4, -37 },
  { 12017, 28, 53, 35, 3, -37 },
  { 12203, 20, 37, 24, 4, -37 },
  { 12296, 23, 38, 27, 2, -37 },
  { 12406, 20, 45, 22, 1, -44 },
  { 12519, 27, 37, 36, 4, -36 },
  { 12644, 30, 36, 30, 0, -36 },
  { 12779, 46, 36, 47, 1, -36 },
  { 12986, 29, 36, 30, 1, -36 },
  { 13117, 30, 52, 31, 0, -36 },
  { 13312, 22, 36, 26, 2, -36 },
  { 13411, 21, 59, 24, 1, -48 },
  { 13566, 7, 67, 31, 12, -51 },
  { 13625, 20, 59, 24, 3, -48 },
  { 13773, 29, 11, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_SemiBold67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD67PT7B_H_
