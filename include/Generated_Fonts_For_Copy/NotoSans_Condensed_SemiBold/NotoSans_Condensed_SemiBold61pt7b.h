#ifndef _NOTOSANS_CONDENSED_SEMIBOLD61PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xE7, 0xE0, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7,
  0xF0, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFD, 0xFC, 0xFF, 0x3C, 0x1C, 0xFE, 0x3C, 0x00, 0xFE, 0x3C, 0x00, 0xFC,
  0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFE, 0x3C, 0x00, 0xFE, 0x3C, 0x00, 0xFF,
  0xBC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE, 0x00, 0x3C, 0xFF, 0x00,
  0x3C, 0x7F, 0x00, 0x3C, 0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x7F, 0x80,
  0x3C, 0x7F, 0xC0, 0x3C, 0x7F, 0xF8, 0x3D, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x83, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x07,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x01,
  0xF0, 0x7E, 0x3F, 0x0F, 0xF8, 0x3E, 0x0F, 0xC7, 0xE3, 0xFF, 0x87, 0xE1,
  0xF0, 0xF8, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xC7, 0xE7, 0xF1, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0xFC, 0x3E, 0x1F,
  0x07, 0xC1, 0xFF, 0x8F, 0xC7, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x7E, 0x00,
  0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0x81, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0xFF,
  0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0x0F,
  0xF7, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xE3, 0xF8,
  0xFF, 0x03, 0xFD, 0xFE, 0x3F, 0xC0, 0xFF, 0x7F, 0x0F, 0xE0, 0x1F, 0xFF,
  0xC3, 0xF8, 0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x1F,
  0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x60,
  0x3E, 0x02, 0x7C, 0x3E, 0x1E, 0x7F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F,
  0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0x81, 0xF0, 0x07,
  0x81, 0xE0, 0x01, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x08, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0x06,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F, 0xF8,
  0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFB, 0xE1, 0xFC, 0xE0, 0xFE, 0x20, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFE, 0x0F, 0xF8, 0x7C, 0x03, 0xFE, 0x1C, 0x00,
  0xFF, 0x08, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xF8, 0x78, 0x01, 0xFE, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF7, 0x80,
  0x0F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xCF,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x10, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x80, 0x03,
  0xFE, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x08, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x3F, 0x1F, 0xF8, 0x1F, 0x9F, 0xFF,
  0x1F, 0xDF, 0xFF, 0xCF, 0xEF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0x83,
  0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xF1, 0xFF, 0x07, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x1F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x1F,
  0xE7, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0x03,
  0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xFB, 0xFC, 0x0F, 0xFD, 0xFF, 0x9F, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0xC3, 0xFF, 0xCF,
  0xE0, 0x7F, 0xC7, 0xF0, 0x02, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xF3,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x1F, 0x9F,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x0F, 0xCF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x9F, 0x83,
  0x00, 0x04, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F,
  0x81, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x1F,
  0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0xCE, 0x00, 0xFF, 0x10, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0xF0, 0x7E, 0x3F, 0x01, 0xFF,
  0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xF8, 0x3F,
  0x7E, 0x0F, 0xE0, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0xF8, 0x1F, 0x03, 0xF8, 0x3E, 0xF8, 0x1F,
  0x83, 0xF8, 0x3E, 0xFC, 0x1F, 0x87, 0xF8, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF,
  0xFC, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x7C, 0x07, 0xFF, 0x3F, 0xF8, 0x7E,
  0x03, 0xFE, 0x1F, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xE1, 0xFF, 0xF3, 0xF8, 0x07,
  0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0x3F, 0x80, 0x3F, 0xEF,
  0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xF0, 0xFF, 0xC0,
  0x0C, 0x1F, 0xF0, 0x00, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x04, 0x3F, 0xF8, 0x07, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0xF0, 0xFE,
  0x00, 0xFF, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF9, 0xFC, 0x00,
  0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F,
  0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0xFF, 0x8F, 0xE0, 0x1F, 0xF8, 0x7F, 0x07, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x10,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xF0, 0x01, 0xFC, 0x3F, 0xF0, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xE0, 0x00, 0xFD, 0xFF, 0xEF, 0xC0, 0x01,
  0xFB, 0xFF, 0xDF, 0x80, 0x03, 0xF7, 0xFF, 0xBF, 0x80, 0x0F, 0xCF, 0xFF,
  0x3F, 0x00, 0x1F, 0x9F, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00,
  0xFE, 0x7F, 0xF8, 0xFC, 0x01, 0xF9, 0xFF, 0xF1, 0xF8, 0x03, 0xF3, 0xFF,
  0xE3, 0xF0, 0x07, 0xE7, 0xFF, 0xC7, 0xF0, 0x1F, 0x8F, 0xFF, 0x87, 0xE0,
  0x3F, 0x1F, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0xFE, 0x1F, 0x81, 0xF8, 0x7F,
  0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xFF, 0xF0, 0x7E,
  0x1F, 0xC3, 0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xFF, 0xC0, 0xFC, 0x7E, 0x0F,
  0xFF, 0x81, 0xF8, 0xFC, 0x1F, 0xFF, 0x03, 0xF3, 0xF0, 0x3F, 0xFE, 0x03,
  0xF7, 0xE0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xDF, 0xC0, 0x0F, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0x3F, 0x80, 0x3F,
  0xFE, 0x7F, 0x80, 0x7F, 0xFC, 0x7F, 0x00, 0xFF, 0xF8, 0xFF, 0x01, 0xFF,
  0xF0, 0xFE, 0x03, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF,
  0x83, 0xFC, 0x1F, 0xFF, 0x03, 0xF8, 0x3F, 0xFE, 0x07, 0xF8, 0x7F, 0xFC,
  0x07, 0xF0, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xE0,
  0x1F, 0xE7, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x80, 0x3F, 0xDF, 0xFF, 0x00,
  0x3F, 0xBF, 0xFE, 0x00, 0x7F, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE,
  0x03, 0xFE, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xD0, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0xF8, 0xFE, 0x01, 0xFF,
  0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x07, 0xFC, 0x7F, 0x01,
  0xFF, 0x0F, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFC, 0x7F, 0xC0, 0x3C, 0x7F,
  0x80, 0x08, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0xF0,
  0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xF7, 0xC0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFD, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x7E, 0x03,
  0xFC, 0x07, 0xF0, 0x3F, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE3, 0xF0,
  0x3F, 0x80, 0x7F, 0x07, 0xF1, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x1F,
  0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7E, 0x07,
  0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0x80,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xE0,
  0x3F, 0x3F, 0x80, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0xC0, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0x81, 0xFE, 0x04, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xF8, 0x7F, 0x7F, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x87, 0xFF, 0x7F, 0xFF, 0xBF,
  0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0x3F, 0x1F, 0xFE, 0x3F, 0x0F, 0xF8, 0x1F,
  0x00, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x3F, 0x87, 0xFC,
  0x0F, 0xE7, 0xFF, 0x83, 0xFB, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0x3F, 0xF3, 0xFF, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF8, 0x07, 0xF3, 0xFF, 0x03,
  0xFC, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xF3,
  0xFF, 0xF0, 0xFC, 0x7F, 0xF8, 0x3F, 0x0F, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xCF, 0x8F, 0xF8, 0x04, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x02, 0xFF,
  0x80, 0x63, 0xFF, 0xBF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0x03,
  0xF8, 0x1F, 0xF1, 0xFC, 0x3F, 0xFC, 0xFE, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xEF, 0xF0, 0x1F, 0xF7, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xE3, 0xFF,
  0xF3, 0xF0, 0xFF, 0xF1, 0xF8, 0x1F, 0xF0, 0xFC, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFC, 0x7F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x7F, 0xC0, 0x06, 0x3F,
  0xF0, 0x7E, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFD, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x0F,
  0xC3, 0xFF, 0xC7, 0xE3, 0xFF, 0xF3, 0xF1, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF,
  0xFD, 0xFF, 0x9F, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xFE, 0x3F,
  0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF,
  0x3F, 0x81, 0xFF, 0x1F, 0xC0, 0x38, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x40,
  0x00, 0x7F, 0x38, 0x00, 0xFF, 0x9F, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0x80, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F,
  0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0x3F, 0xF1, 0xFF, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFE,
  0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xCF,
  0xE0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x7E,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x9F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xDF, 0xFF, 0xEF, 0xFD, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x07,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x07, 0x80, 0xFC, 0x3F, 0xF0, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF,
  0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xFC, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x3F, 0x0F, 0xFC, 0x0F, 0xC7, 0xFF, 0x83, 0xF3,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFE, 0x1F, 0xF3,
  0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x03,
  0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x1F, 0xEF, 0xF8, 0x07, 0xF3, 0xFF, 0x03, 0xFC, 0xFF, 0xF7, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xF0, 0xFE, 0x7F, 0xF8,
  0x3F, 0x87, 0xF8, 0x0F, 0xE0, 0x78, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xC3,
  0xFF, 0xC7, 0xE3, 0xFF, 0xF3, 0xF1, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF, 0xFD,
  0xFF, 0x8F, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xFE, 0x7F, 0xF9,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF, 0x3F,
  0x81, 0xFF, 0x1F, 0xC0, 0x38, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x01, 0xEF, 0xE0, 0x04,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x9C, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xBF, 0x3F,
  0xFF, 0x3F, 0x1F, 0xFE, 0x3F, 0x0F, 0xFC, 0x1F, 0x00, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xEF, 0xE0, 0x0F, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xFC, 0x01, 0xF8, 0x7F, 0x01,
  0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xDF,
  0x01, 0xFC, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x7E, 0x0F,
  0xE0, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x1F, 0xC3, 0xE3, 0xE1, 0xFC, 0x03, 0xF8,
  0xFC, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE3, 0xE0,
  0xF8, 0xFE, 0x00, 0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x1F, 0xCF, 0x83, 0xE7,
  0xF0, 0x03, 0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0x81, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x00, 0x1F,
  0xBE, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFB, 0x00, 0x1F,
  0xFC, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 45, 16, 3, -44 },
  { 52, 20, 16, 26, 3, -44 },
  { 92, 30, 44, 33, 1, -44 },
  { 257, 24, 50, 30, 3, -46 },
  { 407, 43, 45, 47, 2, -44 },
  { 649, 34, 45, 36, 2, -44 },
  { 841, 8, 16, 14, 3, -44 },
  { 857, 15, 54, 19, 3, -44 },
  { 959, 15, 54, 19, 1, -44 },
  { 1061, 24, 24, 28, 2, -46 },
  { 1133, 26, 29, 30, 2, -36 },
  { 1228, 10, 15, 15, 2, -7 },
  { 1247, 15, 7, 18, 2, -20 },
  { 1261, 9, 10, 15, 3, -9 },
  { 1273, 22, 44, 24, 1, -44 },
  { 1394, 25, 45, 30, 2, -44 },
  { 1535, 17, 44, 30, 4, -44 },
  { 1629, 25, 44, 30, 2, -44 },
  { 1767, 25, 45, 30, 2, -44 },
  { 1908, 28, 44, 30, 1, -44 },
  { 2062, 24, 45, 30, 3, -44 },
  { 2197, 25, 45, 30, 2, -44 },
  { 2338, 26, 44, 30, 2, -44 },
  { 2481, 26, 45, 30, 2, -44 },
  { 2628, 25, 45, 30, 2, -44 },
  { 2769, 9, 35, 16, 3, -34 },
  { 2809, 10, 42, 16, 2, -34 },
  { 2862, 26, 29, 30, 2, -36 },
  { 2957, 26, 17, 30, 2, -30 },
  { 3013, 26, 29, 30, 2, -36 },
  { 3108, 22, 45, 23, 0, -44 },
  { 3232, 40, 49, 46, 3, -44 },
  { 3477, 33, 44, 34, 0, -44 },
  { 3659, 26, 44, 34, 5, -44 },
  { 3802, 27, 45, 32, 3, -44 },
  { 3954, 29, 44, 37, 5, -44 },
  { 4114, 20, 44, 28, 5, -44 },
  { 4224, 20, 44, 27, 5, -44 },
  { 4334, 30, 45, 37, 3, -44 },
  { 4503, 28, 44, 38, 5, -44 },
  { 4657, 16, 44, 20, 2, -44 },
  { 4745, 16, 56, 17, -4, -44 },
  { 4857, 28, 44, 33, 5, -44 },
  { 5011, 21, 44, 27, 5, -44 },
  { 5127, 39, 44, 49, 5, -44 },
  { 5342, 31, 44, 40, 5, -44 },
  { 5513, 33, 45, 39, 3, -44 },
  { 5699, 24, 44, 31, 5, -44 },
  { 5831, 33, 54, 39, 3, -44 },
  { 6054, 27, 44, 33, 5, -44 },
  { 6203, 24, 45, 28, 2, -44 },
  { 6338, 26, 44, 28, 1, -44 },
  { 6481, 29, 45, 37, 4, -44 },
  { 6645, 32, 44, 32, 0, -44 },
  { 6821, 49, 44, 49, 0, -44 },
  { 7091, 31, 44, 31, 0, -44 },
  { 7262, 30, 44, 30, 0, -44 },
  { 7427, 25, 44, 27, 1, -44 },
  { 7565, 14, 54, 19, 4, -44 },
  { 7660, 22, 44, 24, 1, -44 },
  { 7781, 13, 54, 19, 2, -44 },
  { 7869, 29, 27, 32, 1, -44 },
  { 7967, 26, 4, 26, 0, 5 },
  { 7980, 14, 10, 19, 2, -47 },
  { 7998, 24, 35, 30, 2, -34 },
  { 8103, 26, 47, 32, 4, -46 },
  { 8256, 21, 35, 25, 3, -34 },
  { 8348, 25, 47, 32, 3, -46 },
  { 8495, 24, 35, 30, 3, -34 },
  { 8600, 20, 47, 19, 1, -47 },
  { 8718, 25, 49, 32, 3, -34 },
  { 8872, 24, 46, 32, 4, -46 },
  { 9010, 7, 46, 15, 4, -46 },
  { 9051, 13, 61, 15, -2, -46 },
  { 9151, 26, 46, 30, 4, -46 },
  { 9301, 7, 46, 15, 4, -46 },
  { 9342, 41, 34, 48, 4, -34 },
  { 9517, 24, 34, 32, 4, -34 },
  { 9619, 26, 35, 31, 3, -34 },
  { 9733, 26, 49, 32, 4, -34 },
  { 9893, 25, 49, 32, 3, -34 },
  { 10047, 17, 34, 22, 4, -34 },
  { 10120, 20, 35, 24, 2, -34 },
  { 10208, 18, 41, 20, 1, -40 },
  { 10301, 24, 34, 32, 4, -33 },
  { 10403, 28, 33, 28, 0, -33 },
  { 10519, 43, 33, 43, 0, -33 },
  { 10697, 27, 33, 28, 0, -33 },
  { 10809, 28, 48, 28, 0, -33 },
  { 10977, 20, 33, 23, 2, -33 },
  { 11060, 19, 54, 22, 1, -44 },
  { 11189, 6, 60, 28, 11, -46 },
  { 11234, 19, 54, 22, 2, -44 },
  { 11363, 26, 9, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_SemiBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD61PT7B_H_
