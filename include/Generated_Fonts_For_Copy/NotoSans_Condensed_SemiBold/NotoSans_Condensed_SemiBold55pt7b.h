#ifndef _NOTOSANS_CONDENSED_SEMIBOLD55PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C,
  0x1F, 0x9F, 0x07, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xF3, 0x87, 0x1F, 0x8E, 0x04, 0x7E, 0x38,
  0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0x8E, 0x00, 0x7F, 0x38, 0x01,
  0xFE, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xBF, 0xC0, 0x0E, 0x3F, 0x00, 0x38, 0xFC, 0x00, 0xE3, 0xF0,
  0x03, 0x8F, 0xE0, 0x0E, 0x3F, 0xE0, 0x38, 0xFF, 0xE0, 0xE7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x7C, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x7C, 0x7F, 0xC1, 0xF0, 0xF8, 0xF9,
  0xFF, 0xC3, 0xE3, 0xE3, 0xE3, 0xFF, 0xC7, 0xFF, 0xC7, 0xCF, 0xCF, 0x87,
  0xFF, 0x1F, 0x1F, 0x0F, 0x87, 0xFE, 0x3E, 0x3E, 0x1F, 0x07, 0xF8, 0xF8,
  0xFC, 0x3E, 0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0xFC,
  0x00, 0x0F, 0x87, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x1F,
  0x80, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x3E,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x07, 0xE7,
  0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0x83, 0xFF,
  0xE0, 0x7F, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0xDF, 0xC1, 0xF8, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x1F, 0xCF, 0xE3, 0xF8, 0x1F, 0xDF, 0x87, 0xE0, 0x3F,
  0xFF, 0x0F, 0xC0, 0x3F, 0xFE, 0x1F, 0x80, 0x3F, 0xF8, 0x3F, 0x00, 0x3F,
  0xF0, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFC,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x04, 0x0F, 0x81, 0xBF, 0x3E, 0x3E, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3F,
  0x03, 0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F, 0x03, 0x80, 0x08, 0x0C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03,
  0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80,
  0x7F, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x1F,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x7F, 0xBF,
  0xFF, 0x3F, 0x7E, 0x3F, 0x3C, 0x3F, 0x18, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xE0, 0x7F, 0x8E, 0x00, 0xFE, 0x10, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xC0, 0x7F, 0x8C, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7F, 0x00, 0x1F, 0x3F, 0x80,
  0x0F, 0x9F, 0xC0, 0x0F, 0x8F, 0xE0, 0x07, 0xC7, 0xF0, 0x07, 0xC3, 0xF8,
  0x03, 0xE1, 0xFC, 0x03, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xF8, 0x0F, 0xE0, 0xF8, 0x07, 0xF0, 0x7C, 0x03,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF3, 0xE0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE2, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF7,
  0xC0, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0xC0, 0xFC, 0xFF, 0xE1, 0xFB, 0xFF, 0xE3, 0xF7, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F,
  0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F,
  0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xF9, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x1F, 0xC7, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF9, 0xFC,
  0x07, 0xF3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0x81, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFB, 0xF8, 0x1F, 0xE7, 0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x0F, 0xFF, 0x7E, 0x0F, 0xFC, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0x00, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0x1F, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3C, 0x0F, 0xF3, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x01, 0xFF, 0x03,
  0xE3, 0xF0, 0x3F, 0xFE, 0x1F, 0x1F, 0x03, 0xFF, 0xF0, 0xF8, 0xF8, 0x3F,
  0xFF, 0x83, 0xE7, 0xC1, 0xF8, 0x7C, 0x1F, 0x7C, 0x1F, 0x83, 0xE0, 0xFB,
  0xE0, 0xF8, 0x1F, 0x07, 0xDF, 0x07, 0xC0, 0xF8, 0x3E, 0xF8, 0x7C, 0x07,
  0xC1, 0xF7, 0x83, 0xE0, 0x3E, 0x0F, 0xBC, 0x1F, 0x01, 0xF0, 0x7F, 0xE0,
  0xF8, 0x0F, 0x83, 0xFF, 0x07, 0xC0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xE0,
  0xFF, 0xC1, 0xF0, 0x3F, 0x07, 0xDE, 0x0F, 0x81, 0xF8, 0x3C, 0xF8, 0x7E,
  0x0F, 0xC3, 0xE7, 0xC1, 0xF0, 0xFE, 0x1F, 0x3E, 0x0F, 0xEF, 0x7B, 0xF1,
  0xF0, 0x3F, 0xFB, 0xFF, 0x8F, 0x81, 0xFF, 0x9F, 0xF8, 0x3E, 0x07, 0xF8,
  0x7F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x1E, 0x1F, 0xE0, 0x04, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x02, 0x1F, 0xFC, 0x3E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0xFF, 0x8F, 0xE0, 0x1F, 0xE3,
  0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFE, 0x03, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFE,
  0x01, 0xE0, 0xFF, 0x80, 0x04, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0xF0, 0x7F,
  0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xDF, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0xFB, 0xFF, 0xDF,
  0x80, 0x1F, 0xBF, 0xFD, 0xF8, 0x01, 0xFB, 0xFF, 0xCF, 0x80, 0x1F, 0x3F,
  0xFC, 0xFC, 0x03, 0xF3, 0xFF, 0xCF, 0xC0, 0x3F, 0x3F, 0xFC, 0x7C, 0x03,
  0xE3, 0xFF, 0xC7, 0xC0, 0x3E, 0x3F, 0xFC, 0x7E, 0x07, 0xE3, 0xFF, 0xC7,
  0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xC1, 0xF0, 0xF8, 0x3F, 0xFC, 0x1F, 0x0F,
  0x83, 0xFF, 0xC1, 0xF9, 0xF8, 0x3F, 0xFC, 0x1F, 0x9F, 0x03, 0xFF, 0xC0,
  0xF9, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0xDF, 0xC0, 0x3F, 0xFC,
  0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC7, 0xF0,
  0x3F, 0xFC, 0x3F, 0x03, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xFC, 0x3F, 0xFC, 0x0F, 0xC3, 0xFF, 0xC0, 0xFE, 0x3F, 0xFC, 0x0F,
  0xE3, 0xFF, 0xC0, 0x7F, 0x3F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0, 0x3F, 0xBF,
  0xFC, 0x03, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x0F, 0xCF, 0xE0, 0x0C, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x3F, 0x80,
  0x7F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x1F, 0x80, 0xF9,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x9F, 0x01, 0xF8, 0x1F, 0x80, 0xF9, 0xF0,
  0x1F, 0x81, 0xFC, 0x0F, 0x9F, 0x03, 0xF8, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x00, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x7C, 0x7E, 0x00, 0x7E, 0x3E,
  0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x00, 0x7F, 0x7E, 0x07,
  0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xEF,
  0xC0, 0x03, 0xF7, 0xC0, 0x3E, 0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xEF, 0xC0,
  0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF9, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0x03, 0xFC,
  0x20, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xBE, 0xFF, 0xF9, 0xF3, 0xFF, 0x8F,
  0x8F, 0xF8, 0x3C, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xF8, 0x1F, 0x9F, 0xF8, 0x3F, 0x7F,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xF3, 0xFC, 0x0F,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7C, 0xFF,
  0xF0, 0xF8, 0xFF, 0xE1, 0xF0, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFC,
  0x1C, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x02, 0x3F, 0xC0,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0xC7, 0xE0, 0xFF, 0xCF, 0xC3, 0xFF, 0xDF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0x87, 0xFD, 0xFE, 0x07, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x07, 0xF3,
  0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0x9F, 0x0F,
  0xFE, 0x3E, 0x07, 0xF8, 0x7C, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0,
  0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x04, 0x3F, 0xC0, 0x38, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x02,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFC, 0xC0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0xFC, 0x3E, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0xFF, 0x3F, 0xC3,
  0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFB, 0xF0, 0xFF, 0xE7,
  0xE0, 0x7F, 0x8F, 0xC0, 0x10, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF3, 0x00, 0x1F, 0xC7,
  0xE1, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x7F, 0x83, 0xF3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x03, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7F, 0x8F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xBF, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0,
  0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0x8F, 0xFC, 0x3F, 0xFC, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0x03,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x7F,
  0x83, 0xE3, 0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFE, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC1, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xF8, 0x7F, 0x81, 0xF1, 0xFF, 0x83,
  0xE7, 0xFF, 0x87, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x7F, 0x81, 0xFE, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xEF, 0xFF, 0x0F, 0xCF, 0xFE, 0x1F, 0x8F, 0xF0, 0x3F, 0x01, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x3E, 0x0F, 0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF3, 0xFF, 0xFF,
  0xE7, 0xF8, 0x7F, 0xCF, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0xFF, 0x3F, 0xC3, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFB, 0xF0, 0xFF, 0xE7, 0xE0, 0x7F, 0x8F,
  0xC0, 0x10, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x80,
  0xCF, 0xC0, 0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC1, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xDF, 0x80, 0x7F, 0xBF, 0x81, 0xFF, 0x7F, 0x87, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFD, 0xF9, 0xFF, 0xFB, 0xF1, 0xFF, 0xE7, 0xE0, 0xFF,
  0x0F, 0xC0, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x03,
  0xF7, 0xE0, 0x1F, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0xC0, 0x7F, 0x7F, 0x01,
  0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xFC, 0x07, 0xE3, 0xF0, 0x3E, 0xF0, 0x1F,
  0x8F, 0xC0, 0xFB, 0xE0, 0xFE, 0x3F, 0x83, 0xEF, 0x83, 0xF0, 0x7E, 0x0F,
  0xBE, 0x0F, 0xC1, 0xF8, 0x3C, 0xF8, 0x3F, 0x07, 0xE1, 0xF1, 0xE0, 0xFC,
  0x1F, 0xC7, 0xC7, 0xC7, 0xE0, 0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0xFC, 0x7C,
  0x7C, 0x7E, 0x03, 0xF3, 0xE1, 0xF1, 0xF8, 0x0F, 0xCF, 0x83, 0xCF, 0xC0,
  0x1F, 0x3E, 0x0F, 0xBF, 0x00, 0x7E, 0xF8, 0x3E, 0xFC, 0x01, 0xFB, 0xE0,
  0xFB, 0xF0, 0x07, 0xEF, 0x03, 0xEF, 0x80, 0x1F, 0xBC, 0x0F, 0xBE, 0x00,
  0x3E, 0xF0, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xE3, 0xF8, 0x07,
  0xE3, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xE7, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x02, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x04, 0x00,
  0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x80, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 18, 14, 24, 3, -39 },
  { 73, 27, 39, 29, 1, -39 },
  { 205, 22, 45, 27, 2, -42 },
  { 329, 39, 41, 43, 2, -40 },
  { 529, 31, 41, 33, 2, -40 },
  { 688, 7, 14, 13, 3, -39 },
  { 701, 13, 48, 17, 3, -39 },
  { 779, 14, 48, 17, 1, -39 },
  { 863, 22, 22, 25, 2, -42 },
  { 924, 23, 27, 27, 2, -33 },
  { 1002, 9, 13, 14, 2, -6 },
  { 1017, 13, 6, 17, 2, -18 },
  { 1027, 8, 9, 14, 3, -8 },
  { 1036, 20, 40, 22, 1, -40 },
  { 1136, 23, 41, 27, 2, -40 },
  { 1254, 16, 39, 27, 3, -39 },
  { 1332, 22, 40, 27, 2, -40 },
  { 1442, 22, 41, 27, 2, -40 },
  { 1555, 25, 39, 27, 1, -39 },
  { 1677, 21, 40, 27, 3, -39 },
  { 1782, 23, 41, 27, 2, -40 },
  { 1900, 23, 39, 27, 2, -39 },
  { 2013, 23, 41, 27, 2, -40 },
  { 2131, 23, 41, 27, 2, -40 },
  { 2249, 8, 31, 14, 3, -30 },
  { 2280, 9, 37, 14, 2, -30 },
  { 2322, 23, 26, 27, 2, -33 },
  { 2397, 23, 16, 27, 2, -27 },
  { 2443, 23, 26, 27, 2, -33 },
  { 2518, 20, 41, 21, 0, -40 },
  { 2621, 37, 45, 42, 2, -40 },
  { 2830, 30, 39, 30, 0, -39 },
  { 2977, 24, 39, 30, 4, -39 },
  { 3094, 24, 41, 29, 3, -40 },
  { 3217, 26, 39, 33, 4, -39 },
  { 3344, 19, 39, 25, 4, -39 },
  { 3437, 19, 39, 25, 4, -39 },
  { 3530, 27, 41, 33, 3, -40 },
  { 3669, 26, 39, 34, 4, -39 },
  { 3796, 14, 39, 18, 2, -39 },
  { 3865, 14, 50, 15, -3, -39 },
  { 3953, 26, 39, 29, 4, -39 },
  { 4080, 19, 39, 24, 4, -39 },
  { 4173, 36, 39, 44, 4, -39 },
  { 4349, 28, 39, 36, 4, -39 },
  { 4486, 30, 41, 35, 3, -40 },
  { 4640, 22, 39, 28, 4, -39 },
  { 4748, 30, 49, 35, 3, -40 },
  { 4932, 25, 39, 30, 4, -39 },
  { 5054, 21, 41, 25, 2, -40 },
  { 5162, 23, 39, 25, 1, -39 },
  { 5275, 26, 40, 34, 4, -39 },
  { 5405, 29, 39, 29, 0, -39 },
  { 5547, 44, 39, 44, 0, -39 },
  { 5762, 28, 39, 28, 0, -39 },
  { 5899, 27, 39, 27, 0, -39 },
  { 6031, 22, 39, 25, 1, -39 },
  { 6139, 12, 48, 17, 4, -39 },
  { 6211, 20, 40, 22, 1, -40 },
  { 6311, 13, 48, 17, 1, -39 },
  { 6389, 26, 23, 29, 1, -39 },
  { 6464, 23, 3, 23, 0, 5 },
  { 6473, 13, 9, 17, 2, -42 },
  { 6488, 21, 31, 27, 2, -30 },
  { 6570, 23, 43, 29, 4, -42 },
  { 6694, 20, 31, 23, 2, -30 },
  { 6772, 23, 43, 29, 2, -42 },
  { 6896, 23, 31, 27, 2, -30 },
  { 6986, 18, 42, 17, 1, -42 },
  { 7081, 23, 43, 29, 2, -30 },
  { 7205, 22, 42, 29, 4, -42 },
  { 7321, 7, 41, 14, 3, -41 },
  { 7357, 12, 54, 14, -2, -41 },
  { 7438, 23, 42, 27, 4, -42 },
  { 7559, 6, 42, 14, 4, -42 },
  { 7591, 36, 30, 44, 4, -30 },
  { 7726, 22, 30, 29, 4, -30 },
  { 7809, 24, 31, 28, 2, -30 },
  { 7902, 23, 43, 29, 4, -30 },
  { 8026, 23, 43, 29, 2, -30 },
  { 8150, 15, 30, 20, 4, -30 },
  { 8207, 18, 31, 22, 2, -30 },
  { 8277, 16, 37, 18, 1, -36 },
  { 8351, 23, 31, 29, 3, -30 },
  { 8441, 25, 30, 25, 0, -30 },
  { 8535, 38, 30, 39, 0, -30 },
  { 8678, 24, 30, 25, 0, -30 },
  { 8768, 25, 43, 25, 0, -30 },
  { 8903, 19, 30, 21, 1, -30 },
  { 8975, 17, 48, 20, 1, -39 },
  { 9077, 5, 55, 26, 10, -42 },
  { 9112, 17, 48, 20, 2, -39 },
  { 9214, 23, 9, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_SemiBold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD55PT7B_H_
