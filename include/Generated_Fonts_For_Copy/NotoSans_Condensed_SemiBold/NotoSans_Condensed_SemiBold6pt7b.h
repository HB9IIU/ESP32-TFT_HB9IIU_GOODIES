#ifndef _NOTOSANS_CONDENSED_SEMIBOLD6PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7B, 0xE0, 0x5F, 0x3C, 0xFF, 0x35, 0xE4, 0xAF, 0x80,
  0xEA, 0x40, 0x95, 0x80, 0x5F, 0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A,
  0xF6, 0xA0, 0xD5, 0xE5, 0x70, 0xE8, 0xE0, 0x57, 0x90, 0xD8, 0xE0, 0xDA,
  0xA0, 0xE9, 0x20, 0xEA, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC,
  0x8F, 0x00, 0xDA, 0x7F, 0xFE, 0x4F, 0xD0, 0xFE, 0xF0, 0x72, 0x30, 0xF6,
  0xF0, 0xFB, 0xFA, 0x72, 0xB0, 0xBE, 0xD0, 0xEB, 0xF8, 0xBA, 0xD0, 0x92,
  0x70, 0xDD, 0xFB, 0xDD, 0xBB, 0xE9, 0x96, 0xF7, 0x40, 0xE9, 0x96, 0x20,
  0xFE, 0xD0, 0xF8, 0xE0, 0xE9, 0x20, 0xB6, 0xB0, 0xB5, 0x20, 0xAF, 0x54,
  0xA0, 0xA9, 0x50, 0xA9, 0x20, 0xEA, 0x70, 0xEA, 0xC0, 0x95, 0xD5, 0xC0,
  0x54, 0xE0, 0xC0, 0xFF, 0x80, 0x93, 0xDE, 0xEC, 0x27, 0xDE, 0xFD, 0x80,
  0x6E, 0x80, 0xF7, 0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x93, 0xEA, 0xF8, 0xFB,
  0xB0, 0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xBB,
  0xB7, 0x80, 0xB9, 0x00, 0xBF, 0x50, 0xEA, 0x80, 0xB9, 0x60, 0xDC, 0x59,
  0x40, 0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 2, 0, -3 },
  { 44, 1, 4, 2, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 4, 4, 5, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 2, 4, 3, 0, -4 },
  { 62, 2, 4, 3, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 1, 5, 2, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 4, 4, 5, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 4, 5, 4, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 5, 4, 5, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 0, -4 },
  { 103, 2, 5, 2, 0, -4 },
  { 105, 2, 4, 2, 0, -4 },
  { 106, 2, 5, 2, 0, -4 },
  { 108, 3, 2, 3, 0, -4 },
  { 109, 3, 1, 3, 0, 0 },
  { 110, 2, 1, 2, 0, -5 },
  { 111, 3, 3, 3, 0, -3 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 2, 3, 3, 0, -3 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 2, 5, 2, 0, -5 },
  { 122, 3, 4, 3, 0, -3 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 1, 5, 1, 0, -5 },
  { 127, 1, 6, 1, 0, -5 },
  { 128, 3, 5, 3, 0, -5 },
  { 130, 1, 5, 1, 0, -5 },
  { 131, 4, 3, 5, 0, -3 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 2, 3, 2, 0, -3 },
  { 142, 2, 3, 2, 0, -3 },
  { 143, 2, 4, 2, 0, -4 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 4, 3, 4, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 3, 4, 3, 0, -3 },
  { 154, 2, 3, 2, 0, -3 },
  { 155, 2, 5, 2, 0, -4 },
  { 157, 1, 6, 3, 1, -5 },
  { 158, 2, 5, 2, 0, -4 },
  { 160, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_SemiBold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD6PT7B_H_
