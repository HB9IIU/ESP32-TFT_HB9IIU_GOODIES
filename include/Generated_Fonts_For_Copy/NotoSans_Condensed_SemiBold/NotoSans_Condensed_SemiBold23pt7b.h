#ifndef _NOTOSANS_CONDENSED_SEMIBOLD23PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xE7, 0xE6, 0xE6,
  0x66, 0x66, 0x66, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF,
  0x19, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x98, 0x33, 0x03, 0x30,
  0x33, 0x03, 0x30, 0x08, 0x0F, 0x1F, 0xFF, 0xFE, 0x87, 0x43, 0xA0, 0xF0,
  0x3E, 0x07, 0x82, 0xE1, 0x30, 0x9E, 0x5F, 0xFC, 0xFC, 0x08, 0x04, 0x00,
  0x30, 0x00, 0x78, 0x30, 0xCC, 0x30, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0xC0,
  0xCC, 0xC0, 0xCD, 0x9C, 0xCD, 0xBE, 0x79, 0xB3, 0x33, 0x33, 0x03, 0x33,
  0x06, 0x33, 0x06, 0x33, 0x0C, 0x33, 0x0C, 0x3E, 0x1C, 0x1E, 0x0C, 0x01,
  0xF8, 0x1F, 0xC0, 0xE6, 0x07, 0x30, 0x39, 0x80, 0xDC, 0x07, 0xC0, 0x3C,
  0x03, 0xF3, 0xBB, 0x9D, 0xCF, 0xCE, 0x3E, 0x70, 0xE3, 0x8F, 0x8F, 0xFC,
  0x3E, 0x78, 0xFF, 0xB6, 0xC0, 0x1C, 0xC3, 0x1C, 0x61, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x70, 0xC1, 0x87, 0xE3, 0x1C, 0x63, 0x1C,
  0xE3, 0x18, 0xC6, 0x33, 0x9C, 0xC6, 0x73, 0x39, 0x80, 0x1C, 0x0C, 0x06,
  0x1B, 0x3F, 0xF9, 0xF0, 0xF0, 0xEC, 0x67, 0x11, 0x00, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x76, 0xEE,
  0xCC, 0xFF, 0xC0, 0xEF, 0xE0, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0,
  0x00, 0x1C, 0x1F, 0x1F, 0xCC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1D, 0xDC, 0xFE, 0x3E, 0x00, 0x0E, 0x3C, 0xFF,
  0xF6, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C,
  0x3F, 0xBF, 0xC8, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x03,
  0x83, 0x83, 0x83, 0x81, 0xFF, 0xFF, 0x80, 0x1C, 0x7F, 0xBF, 0xC8, 0x70,
  0x38, 0x1C, 0x0C, 0x7C, 0x3C, 0x1F, 0x80, 0xE0, 0x70, 0x38, 0x1E, 0x1F,
  0xFE, 0xFE, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x37, 0x06,
  0xE1, 0x9C, 0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0,
  0x1C, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x07, 0x03, 0xF9, 0xFE, 0x07, 0x81,
  0xC0, 0xE0, 0x70, 0x3C, 0x3F, 0xFD, 0xFC, 0x07, 0x0F, 0x8F, 0xCE, 0x06,
  0x07, 0x03, 0x91, 0xBE, 0xFF, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x1D, 0xCE,
  0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x1C,
  0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x1C, 0x3F, 0x9F,
  0xFC, 0x7E, 0x3F, 0x1D, 0xDC, 0x7E, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x1E,
  0x0F, 0x8E, 0xFF, 0x3E, 0x00, 0x1C, 0x3F, 0x1F, 0xDC, 0x7E, 0x3E, 0x1F,
  0x07, 0xC7, 0xE3, 0xBE, 0xDF, 0x60, 0x70, 0x38, 0x18, 0x3C, 0xFC, 0x7C,
  0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x6F, 0xF6, 0x00, 0x00,
  0x00, 0x76, 0xEE, 0xCC, 0x00, 0x80, 0xC1, 0xE3, 0xE7, 0x87, 0x03, 0xC0,
  0x78, 0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x80, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x1E, 0x3E, 0x78, 0x70, 0x20,
  0x00, 0x1C, 0xFE, 0x7F, 0x43, 0x03, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x18,
  0x18, 0x00, 0x00, 0x38, 0x38, 0x38, 0x01, 0x80, 0x1F, 0xE0, 0x70, 0xE1,
  0x80, 0x67, 0x00, 0xEC, 0x7C, 0xD9, 0xD9, 0xE7, 0x33, 0xCC, 0x67, 0x98,
  0xCF, 0x31, 0x9E, 0x63, 0x3C, 0xEE, 0xFC, 0xF7, 0x98, 0x00, 0x38, 0x00,
  0x38, 0x10, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x3B,
  0x01, 0xD8, 0x0E, 0xE0, 0x67, 0x07, 0x18, 0x38, 0xE1, 0xFF, 0x0F, 0xF8,
  0xFF, 0xC7, 0x07, 0x38, 0x3B, 0x81, 0xDC, 0x07, 0xFF, 0x3F, 0xEC, 0x3B,
  0x0E, 0xC3, 0xB0, 0xEF, 0xF3, 0xF8, 0xFF, 0xB0, 0xEC, 0x1F, 0x07, 0xC1,
  0xF0, 0xEF, 0xFB, 0xF8, 0x07, 0x07, 0xF3, 0xFD, 0xE1, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x84, 0xFF,
  0x1F, 0xC0, 0xFF, 0x1F, 0xF3, 0x0F, 0x60, 0xEC, 0x1D, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0x60, 0xEC, 0x3D, 0x8F, 0x3F, 0xC7, 0xF0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x03, 0x83, 0xFC, 0xFF, 0xBC, 0x17,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F, 0x81, 0xF0, 0x37, 0x06,
  0xE0, 0xDE, 0x19, 0xFF, 0x0F, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xFD, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xCF, 0xFF, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x19, 0xFF, 0xEE, 0x00, 0xE1, 0xF8, 0xEE, 0x73, 0x9C, 0xEE,
  0x3B, 0x8F, 0xC3, 0xF0, 0xFE, 0x3B, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xEE,
  0x1F, 0x87, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFD, 0x87, 0xFB, 0x0D, 0xF7, 0x1B, 0xE6, 0x37, 0xCC, 0xEF, 0x99,
  0x9F, 0x3B, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0xF1, 0xF0, 0xE3, 0xE1, 0x87,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0xB8, 0xF3, 0x1E, 0x73, 0xC6,
  0x78, 0xEF, 0x0D, 0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x07, 0x00,
  0xFE, 0x0F, 0xF8, 0xE1, 0xE7, 0x07, 0x70, 0x3B, 0x80, 0xDC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xE7, 0x07, 0x38, 0x39, 0xE3, 0x87, 0xFC,
  0x1F, 0x80, 0xFE, 0x7F, 0xB0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x9E, 0xFF,
  0x7E, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x07, 0x00, 0xFE, 0x0F,
  0xF8, 0xE1, 0xE7, 0x07, 0x70, 0x3B, 0x80, 0xDC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xE7, 0x07, 0x38, 0x39, 0xE3, 0x87, 0xFC, 0x1F, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0xFE, 0x3F, 0xCC, 0x3B, 0x0E,
  0xC3, 0xB0, 0xEC, 0x3B, 0xFC, 0xFE, 0x33, 0x8C, 0x63, 0x1C, 0xC3, 0x30,
  0xEC, 0x3B, 0x07, 0x1C, 0x3F, 0xDF, 0xDC, 0x2E, 0x07, 0x03, 0x80, 0xF0,
  0x3E, 0x0F, 0x81, 0xC0, 0x70, 0x38, 0x1F, 0x1D, 0xFE, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xFC,
  0xF7, 0xF8, 0xFC, 0xE0, 0x76, 0x07, 0x60, 0x67, 0x0E, 0x70, 0xE3, 0x0C,
  0x30, 0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x19, 0x81, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0xE0, 0xE0, 0xF8, 0x38, 0x76, 0x1E, 0x1D, 0x87, 0x87,
  0x71, 0xF1, 0x9C, 0x6C, 0x67, 0x3B, 0x38, 0xCE, 0xCE, 0x33, 0x33, 0x8E,
  0xCE, 0xC3, 0xB1, 0xB0, 0x7C, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0x38, 0xF0, 0xE7, 0x1C, 0x39, 0xC3, 0x98, 0x1B, 0x81, 0xF0,
  0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xB8, 0x39, 0xC7, 0x1C,
  0x70, 0xEE, 0x0F, 0xE0, 0xEE, 0x19, 0xC7, 0x18, 0xE3, 0xB8, 0x77, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x7F, 0xDF, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xE0, 0x30,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xF0, 0x06, 0x01, 0xE0, 0x3C, 0x0F,
  0xC1, 0x98, 0x73, 0x8C, 0x33, 0x86, 0xE0, 0x60, 0xFF, 0xFF, 0xF0, 0xE3,
  0x8C, 0x30, 0x1C, 0x3F, 0x9D, 0xC0, 0x70, 0x38, 0xFD, 0xFF, 0xC7, 0xE3,
  0xF1, 0xF9, 0xFF, 0xF7, 0x98, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE6, 0x3B,
  0xEF, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1F,
  0xFE, 0xEF, 0x00, 0x1E, 0x3F, 0x7E, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x71, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x19, 0xDF, 0xF7,
  0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x3D, 0xFF,
  0x3D, 0xC0, 0x1C, 0x1F, 0x9D, 0xFC, 0x7E, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0,
  0x70, 0x1C, 0x2F, 0xF3, 0xF0, 0x0E, 0x1F, 0x3E, 0x38, 0x38, 0x38, 0xFE,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x1F, 0xF7, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77,
  0x3D, 0xFF, 0x3D, 0xC0, 0x70, 0x1E, 0x0E, 0x7F, 0x9F, 0xC0, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3B, 0xEF, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFD, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xC6, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF9, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x1B, 0x1D, 0x9C, 0xDC, 0x6C, 0x3F, 0x1F, 0x8C, 0xE6, 0x33, 0x1D,
  0x86, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x1C,
  0xFF, 0xBE, 0xFF, 0xFF, 0xF1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0x07, 0x3B, 0xEF, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1C, 0x0F, 0xC7, 0xFB, 0x86, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x39, 0xFE, 0x3F, 0x00, 0x06, 0x3B,
  0xEF, 0xFB, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1F,
  0xFE, 0xEF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x18, 0x1F,
  0xF7, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x3D,
  0xFF, 0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xDF,
  0xFF, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x3C, 0xFF,
  0x9E, 0x0E, 0x1E, 0x1F, 0x0F, 0x0E, 0x0E, 0x1F, 0xFF, 0xC0, 0x30, 0x60,
  0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x87, 0xC7, 0x80,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC,
  0xF7, 0xFC, 0xF7, 0xE1, 0xD8, 0x77, 0x1D, 0xC6, 0x33, 0x8C, 0xE3, 0xB0,
  0xEC, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0xE3, 0xC7, 0x63, 0xC7, 0x73, 0xC6,
  0x73, 0xC6, 0x73, 0x6E, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x3E, 0x6C,
  0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xF1, 0xDC, 0xE3, 0xB0, 0xFC, 0x1E,
  0x07, 0x81, 0xE0, 0x7C, 0x3B, 0x0C, 0xE7, 0x1B, 0x87, 0xE1, 0xD8, 0x77,
  0x1D, 0xC6, 0x33, 0x8E, 0xE3, 0xB0, 0x6C, 0x1F, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x78, 0x08, 0x00, 0xFF, 0xFC, 0x30, 0xE1,
  0x87, 0x0C, 0x38, 0x61, 0xC3, 0xFF, 0xF0, 0x0E, 0x3C, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x79, 0xC3, 0xE0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x1C, 0x3C, 0x1C, 0xF9, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xE3, 0xC6,
  0x00, 0x70, 0xFF, 0xE7, 0xF0, 0x60,
};

const GFXglyph NotoSans_Condensed_SemiBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 12, 16, 12, 0, -16 },
  { 39, 9, 18, 11, 1, -17 },
  { 60, 16, 17, 18, 1, -17 },
  { 94, 13, 17, 14, 1, -17 },
  { 122, 3, 6, 5, 1, -16 },
  { 125, 6, 20, 7, 1, -16 },
  { 140, 5, 20, 7, 1, -16 },
  { 153, 9, 10, 11, 1, -18 },
  { 165, 9, 11, 11, 1, -14 },
  { 178, 4, 6, 6, 1, -3 },
  { 181, 5, 2, 7, 1, -7 },
  { 183, 4, 3, 6, 1, -3 },
  { 185, 9, 17, 9, 0, -17 },
  { 205, 9, 17, 11, 1, -17 },
  { 225, 7, 16, 11, 1, -16 },
  { 239, 9, 17, 11, 1, -17 },
  { 259, 9, 17, 11, 1, -17 },
  { 279, 11, 16, 11, 0, -16 },
  { 301, 9, 16, 11, 1, -16 },
  { 319, 9, 17, 11, 1, -17 },
  { 339, 9, 16, 11, 1, -16 },
  { 357, 9, 17, 11, 1, -17 },
  { 377, 9, 17, 11, 1, -17 },
  { 397, 4, 13, 6, 1, -13 },
  { 404, 4, 16, 6, 1, -13 },
  { 412, 9, 11, 11, 1, -14 },
  { 425, 9, 6, 11, 1, -11 },
  { 432, 9, 11, 11, 1, -14 },
  { 445, 8, 17, 9, 0, -17 },
  { 462, 15, 19, 17, 1, -17 },
  { 498, 13, 16, 13, 0, -16 },
  { 524, 10, 16, 13, 2, -16 },
  { 544, 10, 17, 12, 1, -17 },
  { 566, 11, 16, 14, 2, -16 },
  { 588, 8, 16, 11, 2, -16 },
  { 604, 7, 16, 10, 2, -16 },
  { 618, 11, 17, 14, 1, -17 },
  { 642, 11, 16, 14, 2, -16 },
  { 664, 6, 16, 7, 1, -16 },
  { 676, 5, 21, 6, -1, -16 },
  { 690, 10, 16, 12, 2, -16 },
  { 710, 8, 16, 10, 2, -16 },
  { 726, 15, 16, 19, 2, -16 },
  { 756, 11, 16, 15, 2, -16 },
  { 778, 13, 17, 15, 1, -17 },
  { 806, 9, 16, 12, 2, -16 },
  { 824, 13, 21, 15, 1, -17 },
  { 859, 10, 16, 12, 2, -16 },
  { 879, 9, 17, 11, 1, -17 },
  { 899, 10, 16, 11, 0, -16 },
  { 919, 10, 16, 14, 2, -16 },
  { 939, 12, 16, 12, 0, -16 },
  { 963, 18, 16, 18, 0, -16 },
  { 999, 12, 16, 12, 0, -16 },
  { 1023, 11, 16, 11, 0, -16 },
  { 1045, 10, 16, 10, 0, -16 },
  { 1065, 5, 20, 7, 2, -16 },
  { 1078, 9, 17, 9, 0, -17 },
  { 1098, 5, 20, 7, 1, -16 },
  { 1111, 11, 9, 12, 0, -16 },
  { 1124, 10, 2, 10, 0, 2 },
  { 1127, 5, 4, 7, 1, -18 },
  { 1130, 9, 13, 11, 1, -13 },
  { 1145, 10, 17, 12, 1, -17 },
  { 1167, 8, 13, 10, 1, -13 },
  { 1180, 10, 17, 12, 1, -17 },
  { 1202, 9, 13, 11, 1, -13 },
  { 1217, 8, 18, 7, 0, -18 },
  { 1235, 10, 19, 12, 1, -13 },
  { 1259, 10, 17, 12, 1, -17 },
  { 1281, 3, 17, 6, 1, -17 },
  { 1288, 5, 23, 6, -1, -17 },
  { 1303, 9, 17, 11, 2, -17 },
  { 1323, 3, 17, 6, 1, -17 },
  { 1330, 16, 13, 18, 1, -13 },
  { 1356, 10, 13, 12, 1, -13 },
  { 1373, 10, 13, 12, 1, -13 },
  { 1390, 10, 19, 12, 1, -13 },
  { 1414, 10, 19, 12, 1, -13 },
  { 1438, 7, 13, 8, 1, -13 },
  { 1450, 7, 13, 9, 1, -13 },
  { 1462, 7, 15, 8, 0, -15 },
  { 1476, 10, 12, 12, 1, -12 },
  { 1491, 10, 12, 10, 0, -12 },
  { 1506, 16, 12, 16, 0, -12 },
  { 1530, 10, 12, 10, 0, -12 },
  { 1545, 10, 18, 10, 0, -12 },
  { 1568, 7, 12, 9, 1, -12 },
  { 1579, 7, 20, 8, 0, -16 },
  { 1597, 2, 23, 11, 4, -18 },
  { 1603, 7, 20, 8, 1, -16 },
  { 1621, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_SemiBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD23PT7B_H_
