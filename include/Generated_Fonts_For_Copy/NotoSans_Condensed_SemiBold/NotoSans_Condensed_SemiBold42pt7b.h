#ifndef _NOTOSANS_CONDENSED_SEMIBOLD42PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x9E, 0x78, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0x7D, 0xF0,
  0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x0E,
  0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0,
  0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00,
  0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x70, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0,
  0x0E, 0x1E, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0x7C, 0xF9, 0x82, 0x7C, 0xC0,
  0x3E, 0x60, 0x1F, 0x30, 0x0F, 0x98, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x19, 0xF0,
  0x0C, 0x7C, 0x06, 0x3E, 0x03, 0x1F, 0x81, 0x8F, 0x78, 0xCF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFE, 0x01, 0xC0, 0x1E, 0x78, 0x0F, 0x00, 0x78, 0xF0, 0x3C, 0x01, 0xE3,
  0xC1, 0xE0, 0x07, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0xF0, 0x03, 0xC3, 0xC3, 0x80, 0x07, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x78,
  0x00, 0x78, 0xF3, 0xC7, 0xE1, 0xE3, 0xCF, 0x3F, 0xC7, 0x9E, 0x39, 0xFF,
  0x8F, 0xF9, 0xE7, 0x9E, 0x3F, 0xC7, 0x9E, 0x38, 0x7E, 0x3C, 0xF0, 0xF0,
  0x00, 0xF3, 0xC3, 0xC0, 0x07, 0x8F, 0x0F, 0x00, 0x1E, 0x3C, 0x3C, 0x00,
  0x70, 0xF0, 0xF0, 0x03, 0xC3, 0xC3, 0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x78,
  0x3C, 0x3C, 0x01, 0xE0, 0x78, 0xF0, 0x0F, 0x01, 0xE7, 0x80, 0x3C, 0x03,
  0xFE, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x1F, 0x00,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3E, 0x3F, 0xF8, 0x7C,
  0x7E, 0xFC, 0x7C, 0x7C, 0x7E, 0x7C, 0x7C, 0x3E, 0xFC, 0xF8, 0x1F, 0xF8,
  0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xFC, 0x07, 0xF0, 0x7C, 0x07, 0xE0,
  0x7E, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0x7E,
  0x0F, 0xF8, 0x3F, 0xFF, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E, 0x0B, 0x8E, 0x3D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xF7, 0xC0, 0xF9, 0xF0, 0xF8, 0xF8, 0x1C, 0x38, 0x04, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x7C, 0xF9, 0xF3,
  0xCF, 0x9F, 0x3C, 0x79, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x39, 0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x7C, 0x1F, 0x3F, 0x1F,
  0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0x9F, 0x78, 0xF9,
  0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x0C, 0x07, 0xE1,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC7, 0x03, 0xF2, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC1, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x80, 0x3F, 0x60,
  0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0E, 0xF8, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C,
  0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF8, 0x73, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x80, 0x3F, 0x70, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x3F, 0x0F, 0x7F, 0xC7, 0xBF, 0xF3, 0xFF, 0xFD, 0xF8, 0x7E,
  0xF8, 0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x1F, 0x3F, 0x1F, 0x8F, 0xFF, 0x87,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83,
  0xE3, 0xE1, 0xF0, 0x7E, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xCF, 0xC7, 0xE1, 0xF9, 0xF0, 0x3E, 0x78,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x07, 0xE7,
  0xC0, 0xF9, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0x7C, 0x0F, 0xDF, 0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFD, 0xE0, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x79, 0xFF, 0xFF, 0x7D, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFD, 0xF7, 0xC0,
  0x3C, 0x7D, 0xFB, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1, 0xE7,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF7, 0x07, 0xE4, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C,
  0x1F, 0xF1, 0xE7, 0x83, 0xFF, 0x1E, 0x78, 0x7F, 0xF0, 0xE7, 0x0F, 0x8F,
  0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF,
  0x1E, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xE0,
  0xF0, 0xFF, 0x1E, 0x0F, 0x0E, 0xF1, 0xE1, 0xF1, 0xEF, 0x0F, 0x1F, 0x1E,
  0xF0, 0xFF, 0xBF, 0xC7, 0x07, 0xF3, 0xF8, 0x78, 0x3E, 0x1F, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x04,
  0x00, 0xFC, 0x01, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xF8, 0x3F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xFC, 0xF8, 0x7F, 0xBE, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFC, 0x1C, 0x7E, 0x00, 0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x38, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xF8, 0x7F, 0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0xF8, 0x1F, 0xCF, 0x87, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFC, 0x07, 0x1F, 0xC0, 0x10, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0x7D, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xFE, 0x07, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC3, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x82, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x7E, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F,
  0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0x87, 0xC0, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3D, 0xFF, 0xBC, 0x03, 0xDF, 0xFB, 0xC0, 0x7D, 0xFF, 0xBE,
  0x07, 0x9F, 0xF9, 0xE0, 0x79, 0xFF, 0x9E, 0x07, 0x9F, 0xF9, 0xE0, 0xF1,
  0xFF, 0x9F, 0x0F, 0x1F, 0xF8, 0xF0, 0xF1, 0xFF, 0x8F, 0x1F, 0x1F, 0xF8,
  0xF9, 0xE1, 0xFF, 0x87, 0x9E, 0x1F, 0xF8, 0x7B, 0xE1, 0xFF, 0x87, 0xBC,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0x81, 0xFF,
  0x83, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F,
  0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xEF, 0x81, 0xFF, 0xBE, 0x07, 0xFE,
  0x7C, 0x1F, 0xF9, 0xF0, 0x7F, 0xE3, 0xE1, 0xFF, 0x8F, 0x87, 0xFE, 0x1F,
  0x1F, 0xF8, 0x7C, 0x7F, 0xE0, 0xF9, 0xFF, 0x83, 0xE7, 0xFE, 0x07, 0xDF,
  0xF8, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E,
  0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7C, 0x3F, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0x8F, 0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFB, 0xE1, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x8F, 0xF9, 0xF0, 0x3F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0xFE, 0x1C, 0xFC, 0x04, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3E,
  0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF0,
  0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xFE, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0,
  0x3E, 0x7C, 0x03, 0xF0, 0x0F, 0x9F, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x7F,
  0x01, 0xF0, 0xF0, 0x1F, 0xE0, 0x7C, 0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x83,
  0xDE, 0x07, 0xC3, 0xE0, 0xF7, 0x81, 0xF0, 0xF8, 0x3D, 0xF0, 0xF8, 0x1E,
  0x0F, 0x3C, 0x3E, 0x07, 0xC3, 0xCF, 0x0F, 0x81, 0xF1, 0xF3, 0xC3, 0xE0,
  0x7C, 0x78, 0xF0, 0xF0, 0x1F, 0x1E, 0x1E, 0x7C, 0x03, 0xC7, 0x87, 0x9F,
  0x00, 0xFB, 0xE1, 0xE7, 0xC0, 0x3E, 0xF0, 0x79, 0xF0, 0x0F, 0xBC, 0x1E,
  0x78, 0x01, 0xEF, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0xFF, 0x80, 0x1E, 0xF0,
  0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3F,
  0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x0F,
  0x9E, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x83,
  0xC0, 0x7C, 0x3C, 0x03, 0xC7, 0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0E, 0x07, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0x81, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFF, 0xF7, 0xF8, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0xFF, 0xF7, 0xFF, 0x79, 0xFF, 0x3C,
  0x7F, 0x1E, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0xFC, 0x3E,
  0xFF, 0x1E, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xEF, 0xFF, 0xF7, 0xBF, 0xF3, 0xCF, 0xF9, 0xE3, 0xF0, 0x07, 0xF8,
  0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7E, 0x09, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x5F, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xE3,
  0xC7, 0xF9, 0xE7, 0xFE, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xEF, 0x83, 0xF7, 0xFF, 0xF9, 0xFF, 0xBC, 0x7F, 0xDE, 0x1F, 0x8F, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0xFB,
  0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF0,
  0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0x84, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC7, 0x8F, 0xF3,
  0xCF, 0xFD, 0xEF, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x07,
  0xEF, 0xFF, 0xF3, 0xFF, 0x78, 0xFF, 0x3C, 0x3F, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE8, 0x03, 0xF7, 0x03, 0xF3, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0xFC, 0x3C, 0xFF, 0x9E, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1,
  0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0x31, 0xF7, 0xFF, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x06, 0x07, 0xC3, 0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFC, 0xFB, 0xFD, 0xFE,
  0xFE, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F,
  0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xDF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xCF, 0x81,
  0xFB, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF8, 0x3F, 0x8F, 0x3F, 0xC7, 0xFC, 0xF7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x3F, 0xC7, 0xEF, 0xC1, 0xF8, 0x3F, 0xF8, 0x1F, 0x81, 0xFF,
  0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F,
  0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F,
  0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81,
  0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0xF1, 0xF8, 0x79, 0xFF,
  0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0x9F,
  0x03, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xE1, 0xF7,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xDF, 0xFF, 0xEF, 0x7F, 0xE7, 0x9F, 0xF3,
  0xE7, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0x78, 0xFF, 0x3C, 0x3F,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xF1,
  0xFF, 0x3F, 0xF7, 0xFF, 0x7E, 0xFF, 0xEF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xDF, 0xFE, 0x7C, 0x1B, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF6, 0x07, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFE, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0x7C, 0x7F, 0x1E, 0xF8, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0xFB, 0xC0, 0x7E, 0x07,
  0xDF, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x81, 0xE7, 0xC1, 0xFC, 0x0F, 0x1E,
  0x0F, 0xF0, 0xF8, 0xF8, 0x77, 0x87, 0xC7, 0xC7, 0xBC, 0x3E, 0x3E, 0x3C,
  0xE1, 0xE0, 0xF1, 0xE7, 0x9F, 0x07, 0x8F, 0x3C, 0xF8, 0x3E, 0x71, 0xE7,
  0xC1, 0xF7, 0x8F, 0x3C, 0x0F, 0xBC, 0x39, 0xE0, 0x3D, 0xE1, 0xDF, 0x01,
  0xEF, 0x0F, 0xF8, 0x0F, 0x70, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xCF, 0xC1, 0xF8, 0xF8, 0x3E,
  0x1F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0xBF, 0x01, 0xF8,
  0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C,
  0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0,
  0x7C, 0x7C, 0x07, 0x8F, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80,
  0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x3E, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xF0, 0x7F, 0x0F, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xE0, 0x00, 0x1F, 0x00, 0x5F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 30, 11, 2, -30 },
  { 24, 14, 11, 18, 2, -30 },
  { 44, 21, 30, 22, 1, -30 },
  { 123, 17, 34, 21, 2, -32 },
  { 196, 30, 30, 33, 1, -30 },
  { 309, 24, 30, 25, 1, -30 },
  { 399, 6, 11, 10, 2, -30 },
  { 408, 10, 37, 13, 2, -30 },
  { 455, 10, 37, 13, 1, -30 },
  { 502, 17, 17, 19, 1, -32 },
  { 539, 18, 20, 20, 1, -25 },
  { 584, 7, 10, 11, 1, -5 },
  { 593, 10, 5, 13, 1, -14 },
  { 600, 6, 6, 11, 2, -6 },
  { 605, 16, 30, 17, 0, -30 },
  { 665, 17, 30, 20, 2, -30 },
  { 729, 13, 30, 20, 2, -30 },
  { 778, 18, 30, 20, 1, -30 },
  { 846, 17, 30, 20, 2, -30 },
  { 910, 19, 30, 20, 1, -30 },
  { 982, 17, 30, 20, 2, -30 },
  { 1046, 17, 30, 20, 2, -30 },
  { 1110, 18, 30, 20, 1, -30 },
  { 1178, 18, 30, 20, 1, -30 },
  { 1246, 18, 30, 20, 1, -30 },
  { 1314, 6, 23, 11, 2, -23 },
  { 1332, 7, 28, 11, 1, -23 },
  { 1357, 18, 20, 20, 1, -25 },
  { 1402, 18, 12, 20, 1, -21 },
  { 1429, 18, 20, 20, 1, -25 },
  { 1474, 15, 30, 16, 0, -30 },
  { 1531, 28, 33, 32, 2, -30 },
  { 1647, 23, 30, 23, 0, -30 },
  { 1734, 18, 30, 23, 3, -30 },
  { 1802, 19, 30, 22, 2, -30 },
  { 1874, 20, 30, 25, 3, -30 },
  { 1949, 14, 30, 19, 3, -30 },
  { 2002, 14, 30, 19, 3, -30 },
  { 2055, 21, 30, 26, 2, -30 },
  { 2134, 20, 30, 26, 3, -30 },
  { 2209, 11, 30, 14, 1, -30 },
  { 2251, 10, 39, 11, -2, -30 },
  { 2300, 20, 30, 23, 3, -30 },
  { 2375, 15, 30, 18, 3, -30 },
  { 2432, 28, 30, 34, 3, -30 },
  { 2537, 22, 30, 28, 3, -30 },
  { 2620, 23, 30, 27, 2, -30 },
  { 2707, 17, 30, 22, 3, -30 },
  { 2771, 23, 37, 27, 2, -30 },
  { 2878, 19, 30, 23, 3, -30 },
  { 2950, 16, 30, 19, 2, -30 },
  { 3010, 18, 30, 19, 1, -30 },
  { 3078, 20, 30, 26, 3, -30 },
  { 3153, 22, 30, 22, 0, -30 },
  { 3236, 34, 30, 34, 0, -30 },
  { 3364, 21, 30, 21, 0, -30 },
  { 3443, 21, 30, 21, 0, -30 },
  { 3522, 17, 30, 19, 1, -30 },
  { 3586, 9, 37, 13, 3, -30 },
  { 3628, 16, 30, 17, 0, -30 },
  { 3688, 10, 37, 13, 1, -30 },
  { 3735, 20, 18, 22, 1, -30 },
  { 3780, 18, 2, 18, 0, 4 },
  { 3785, 9, 7, 13, 2, -32 },
  { 3793, 17, 23, 20, 1, -23 },
  { 3842, 17, 32, 22, 3, -32 },
  { 3910, 14, 23, 18, 2, -23 },
  { 3951, 17, 32, 22, 2, -32 },
  { 4019, 17, 23, 20, 2, -23 },
  { 4068, 14, 32, 13, 0, -32 },
  { 4124, 17, 33, 22, 2, -23 },
  { 4195, 17, 32, 22, 3, -32 },
  { 4263, 6, 32, 10, 2, -32 },
  { 4287, 9, 42, 10, -1, -32 },
  { 4335, 18, 32, 21, 3, -32 },
  { 4407, 5, 32, 10, 3, -32 },
  { 4427, 28, 23, 33, 3, -23 },
  { 4508, 17, 23, 22, 3, -23 },
  { 4557, 18, 23, 22, 2, -23 },
  { 4609, 17, 33, 22, 3, -23 },
  { 4680, 17, 33, 22, 2, -23 },
  { 4751, 12, 23, 15, 3, -23 },
  { 4786, 14, 23, 17, 1, -23 },
  { 4827, 12, 28, 14, 1, -28 },
  { 4869, 17, 23, 22, 3, -23 },
  { 4918, 19, 23, 19, 0, -23 },
  { 4973, 29, 23, 30, 0, -23 },
  { 5057, 19, 23, 19, 0, -23 },
  { 5112, 19, 33, 19, 0, -23 },
  { 5191, 14, 23, 16, 1, -23 },
  { 5232, 13, 37, 15, 1, -30 },
  { 5293, 4, 42, 19, 8, -32 },
  { 5314, 12, 37, 15, 2, -30 },
  { 5370, 18, 6, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD42PT7B_H_
