#ifndef _NOTOSANS_CONDENSED_SEMIBOLD36PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x73,
  0x80, 0x00, 0x3B, 0xFF, 0xFB, 0xC0, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x0E, 0x70, 0xE7, 0x0E, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x71,
  0xC1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x38, 0x70,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xB1, 0xBC, 0xC0, 0xF3, 0x03,
  0xCC, 0x0F, 0x30, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x0D, 0xF0, 0x33, 0xC0, 0xCF, 0x83, 0x3F, 0x8D, 0xEF, 0xFF,
  0xBF, 0xFC, 0x7F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1F,
  0x00, 0x70, 0x0F, 0xE0, 0x3C, 0x07, 0xF8, 0x0E, 0x01, 0xCF, 0x07, 0x80,
  0x71, 0xC1, 0xC0, 0x3C, 0x70, 0x70, 0x0F, 0x1C, 0x38, 0x03, 0xC7, 0x0E,
  0x00, 0xF1, 0xC7, 0x80, 0x3C, 0x71, 0xC0, 0x0F, 0x1C, 0xF1, 0xC1, 0xC7,
  0x39, 0xFC, 0x73, 0xCE, 0x7F, 0x1F, 0xE7, 0x3D, 0xE3, 0xF9, 0xCE, 0x38,
  0x7C, 0xF3, 0x8E, 0x00, 0x38, 0xE3, 0xC0, 0x1E, 0x78, 0xF0, 0x07, 0x1E,
  0x3C, 0x01, 0xC7, 0x8F, 0x00, 0xE0, 0xE3, 0x80, 0x38, 0x38, 0xE0, 0x1E,
  0x0E, 0x38, 0x07, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0x00, 0xE0, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xE7, 0x80, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x3E, 0x78, 0x01, 0xEF,
  0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x1E, 0x7F,
  0xE1, 0xE7, 0xDF, 0x3E, 0xF8, 0xFB, 0xCF, 0x87, 0xFC, 0xF0, 0x3F, 0xCF,
  0x03, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0x7E, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFB, 0xE1, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x07, 0x0F,
  0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07,
  0x07, 0x83, 0xC3, 0xC1, 0xC1, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x04,
  0x1C, 0x27, 0x3B, 0xDF, 0xFF, 0xBF, 0xFF, 0x87, 0xF0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x7B, 0xC1, 0xE7, 0xC3, 0xC7, 0x01, 0x0C, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1F, 0x78, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x87,
  0x8F, 0xBF, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xE0, 0x7C, 0x1F,
  0x87, 0xF1, 0xFE, 0xFF, 0xFE, 0xFB, 0x9F, 0x23, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xE7, 0xFF, 0xE7, 0x07, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE3, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xFC, 0x3F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x38, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xFC, 0xFF,
  0xF1, 0xEF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7E, 0x03, 0xEF, 0x1F, 0xBF, 0xFC, 0xFF, 0xE1, 0xFF, 0x00,
  0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x81, 0xCF, 0xC7, 0xBF, 0xCF, 0xFF,
  0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0xF7, 0x81, 0xEF, 0x87, 0xCF, 0x9F, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0x83, 0xCF,
  0x07, 0xDE, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0x78, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x03, 0xFE, 0x0F, 0xBE, 0x3E, 0x3E, 0x78, 0x3F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xDF, 0x0F, 0xBF, 0xFE, 0x3F,
  0xF8, 0x1F, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7,
  0xCF, 0x07, 0xBE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xF7, 0x87, 0xEF, 0xFF, 0xCF, 0xFF, 0x9F, 0xEF, 0x0F, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x10, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xFF, 0xFE, 0xF0, 0x39, 0xF7, 0xDF, 0x7C, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF0,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x1F, 0xC3, 0xFF, 0x3F, 0xFC, 0xFF, 0xF6,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF0,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x3F, 0x1E,
  0x70, 0xFF, 0x8E, 0xF1, 0xFF, 0x8E, 0xE1, 0xC3, 0x8E, 0xE3, 0xC3, 0x8F,
  0xE3, 0x83, 0x8F, 0xE3, 0x83, 0x8F, 0xE3, 0x87, 0x8F, 0xE3, 0x87, 0x8E,
  0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x8E, 0xE3, 0xC7, 0x9E, 0xE1, 0xFD, 0xFC,
  0xF1, 0xFD, 0xF8, 0xF0, 0x78, 0xF0, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF0, 0x1E, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xC0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0x3C, 0x7F,
  0x78, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xC0, 0x03, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x06, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0xDE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x07, 0xE7,
  0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F, 0x78, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x03, 0xE7, 0x83, 0xF3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x3F, 0x01, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1F,
  0x7C, 0x07, 0xCF, 0x81, 0xF3, 0xF8, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE3, 0xFE, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0xFF, 0xFB, 0xFD, 0xFC, 0xFC, 0x00, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1,
  0xF0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFB, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xDF, 0xEE, 0x07, 0xBF, 0xDE, 0x0F, 0x7F,
  0xBC, 0x1C, 0xFF, 0x38, 0x39, 0xFE, 0x78, 0xF3, 0xFC, 0xF1, 0xE7, 0xF9,
  0xE3, 0x8F, 0xF1, 0xCF, 0x1F, 0xE3, 0xDE, 0x3F, 0xC7, 0xB8, 0x7F, 0x87,
  0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0x07, 0xF8, 0x3E,
  0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF0, 0x3C, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xF7, 0x83, 0xFD, 0xE0, 0xFF, 0x3C, 0x3F, 0xCF, 0x0F, 0xF1, 0xE3,
  0xFC, 0x78, 0xFF, 0x1F, 0x3F, 0xC3, 0xCF, 0xF0, 0xFB, 0xFC, 0x1E, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF7, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0xBF, 0xFE, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF1, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8,
  0xFE, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0x9E, 0x00, 0xF7, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF0, 0xFC, 0xF0, 0x7C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1F, 0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE, 0x7C, 0x19, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x7F, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xFF, 0x00,
  0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF8, 0x0F, 0x8F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x0F,
  0x00, 0x7F, 0x80, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01,
  0xE7, 0x80, 0xF8, 0x0F, 0x3C, 0x0F, 0xC0, 0x79, 0xE0, 0x7F, 0x07, 0xCF,
  0x83, 0xB8, 0x3C, 0x3C, 0x1D, 0xC1, 0xE1, 0xE1, 0xEE, 0x0F, 0x0F, 0x0F,
  0x78, 0x78, 0x78, 0x7B, 0xC7, 0xC1, 0xE3, 0x9E, 0x3C, 0x0F, 0x3C, 0x71,
  0xE0, 0x79, 0xE3, 0x8F, 0x03, 0xCF, 0x1E, 0xF8, 0x1E, 0x70, 0xF7, 0x80,
  0x7B, 0x83, 0xBC, 0x03, 0xDC, 0x1D, 0xE0, 0x1F, 0xE0, 0xEF, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xDF,
  0x03, 0xE3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1E, 0x1F, 0x07, 0xC7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0xC3, 0xC0,
  0xF1, 0xF0, 0x3E, 0x78, 0x07, 0xBE, 0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01,
  0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0xF8, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x1C, 0xF0,
  0x1E, 0x38, 0x0E, 0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC7, 0x80, 0xE3, 0xC0,
  0x7B, 0xC0, 0x1D, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0x87,
  0xBF, 0x10, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFC, 0xFF, 0xF7,
  0xFF, 0xDF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0xFD,
  0xFF, 0x77, 0xFD, 0xCF, 0xC7, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xE0, 0xF3, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x3E, 0xFC, 0x7C, 0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0x07,
  0xC1, 0xFF, 0x3F, 0xF7, 0xFE, 0x78, 0x2F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x77, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0x9F, 0x3F, 0x9E, 0xFF, 0xBD,
  0xFF, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F,
  0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xBC, 0x7E, 0x78, 0x07, 0x80, 0x7F, 0x83,
  0xFF, 0x1F, 0xBE, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x19, 0xFF, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0xC0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xE7, 0xFE, 0xFF, 0xEF,
  0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x0F, 0x1E, 0x7F, 0x3D, 0xFF, 0x7B, 0xFF, 0xFF, 0x87, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x7C, 0xFE, 0xFF, 0xBC, 0xFF,
  0x78, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x60, 0x7C,
  0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0xF8, 0xF3,
  0xF9, 0xEF, 0xFB, 0xFF, 0xF7, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x78, 0x77,
  0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E,
  0xFE, 0xFE, 0xFC, 0x60, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x7C,
  0xF8, 0x78, 0xF8, 0xF0, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xC0, 0xF7, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF1, 0xE0, 0x78, 0xF7, 0xF9, 0xFE, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3E, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF1, 0xF1, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0xC3,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0x7C,
  0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0xF1, 0xE0, 0xF3, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x3E, 0xFE, 0x7C, 0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x1E, 0x7F, 0x3D, 0xFF, 0x7B, 0xFF,
  0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x7C,
  0xFE, 0xFF, 0xBC, 0xFF, 0x78, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0xF1, 0xFE, 0x7F, 0xDF, 0x7F, 0xEF, 0xF5, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0xDE, 0xF0, 0x2F,
  0x00, 0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x4F, 0xF1, 0xFC, 0x7F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0xFE,
  0xFF, 0xFC, 0xFF, 0x78, 0xFC, 0xF0, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F,
  0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF0, 0x3E,
  0x07, 0xBC, 0x1F, 0x03, 0xDE, 0x0F, 0x81, 0xEF, 0x07, 0xE1, 0xE7, 0x87,
  0xF0, 0xF3, 0xE3, 0xB8, 0x78, 0xF1, 0xDC, 0x3C, 0x78, 0xEF, 0x3C, 0x3C,
  0x73, 0x9E, 0x1E, 0x79, 0xCF, 0x07, 0xB8, 0xE7, 0x83, 0xDC, 0x73, 0x81,
  0xEE, 0x3B, 0xC0, 0xF7, 0x0F, 0xE0, 0x3B, 0x87, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F,
  0x00, 0x78, 0x1F, 0x7C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E,
  0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78, 0x1F, 0x78,
  0x1E, 0x7C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0xFC,
  0x3F, 0x87, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x3F, 0x87, 0xE0, 0xF8, 0x1F, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFE, 0x1F, 0xC1, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1F, 0x83, 0xF8, 0x7F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xF8, 0x1F, 0x03, 0xE1, 0xFC, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0x00, 0x7F, 0x03, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xF8, 0x07,
  0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 12, 10, 15, 2, -26 },
  { 33, 18, 26, 19, 1, -26 },
  { 92, 14, 29, 18, 2, -27 },
  { 143, 26, 26, 28, 1, -26 },
  { 228, 20, 26, 21, 1, -26 },
  { 293, 4, 10, 8, 2, -26 },
  { 298, 8, 32, 11, 2, -26 },
  { 330, 9, 32, 11, 1, -26 },
  { 366, 15, 14, 17, 1, -27 },
  { 393, 15, 17, 18, 1, -21 },
  { 425, 6, 9, 9, 1, -4 },
  { 432, 9, 4, 11, 1, -12 },
  { 437, 5, 5, 9, 2, -5 },
  { 441, 14, 26, 14, 0, -26 },
  { 487, 15, 26, 18, 1, -26 },
  { 536, 11, 26, 18, 2, -26 },
  { 572, 15, 26, 18, 1, -26 },
  { 621, 15, 26, 18, 1, -26 },
  { 670, 16, 26, 18, 1, -26 },
  { 722, 14, 26, 18, 2, -26 },
  { 768, 15, 26, 18, 1, -26 },
  { 817, 15, 26, 18, 1, -26 },
  { 866, 15, 26, 18, 1, -26 },
  { 915, 15, 26, 18, 1, -26 },
  { 964, 5, 20, 9, 2, -20 },
  { 977, 6, 25, 9, 1, -20 },
  { 996, 15, 18, 18, 1, -22 },
  { 1030, 15, 11, 18, 1, -18 },
  { 1051, 15, 18, 18, 1, -22 },
  { 1085, 13, 26, 14, 0, -26 },
  { 1128, 24, 29, 27, 2, -26 },
  { 1215, 20, 26, 20, 0, -26 },
  { 1280, 15, 26, 20, 3, -26 },
  { 1329, 16, 26, 19, 2, -26 },
  { 1381, 17, 26, 22, 3, -26 },
  { 1437, 12, 26, 17, 3, -26 },
  { 1476, 12, 26, 16, 3, -26 },
  { 1515, 18, 26, 22, 2, -26 },
  { 1574, 17, 26, 22, 3, -26 },
  { 1630, 10, 26, 12, 1, -26 },
  { 1663, 9, 33, 10, -2, -26 },
  { 1701, 16, 26, 19, 3, -26 },
  { 1753, 12, 26, 16, 3, -26 },
  { 1792, 23, 26, 29, 3, -26 },
  { 1867, 18, 26, 24, 3, -26 },
  { 1926, 19, 26, 23, 2, -26 },
  { 1988, 14, 26, 19, 3, -26 },
  { 2034, 19, 32, 23, 2, -26 },
  { 2110, 16, 26, 19, 3, -26 },
  { 2162, 14, 26, 17, 1, -26 },
  { 2208, 16, 26, 17, 0, -26 },
  { 2260, 16, 26, 22, 3, -26 },
  { 2312, 19, 26, 19, 0, -26 },
  { 2374, 29, 26, 29, 0, -26 },
  { 2469, 18, 26, 18, 0, -26 },
  { 2528, 18, 26, 18, 0, -26 },
  { 2587, 14, 26, 16, 1, -26 },
  { 2633, 8, 32, 11, 2, -26 },
  { 2665, 14, 26, 14, 0, -26 },
  { 2711, 8, 32, 11, 1, -26 },
  { 2743, 17, 16, 19, 1, -26 },
  { 2777, 15, 3, 15, 0, 3 },
  { 2783, 9, 6, 11, 1, -28 },
  { 2790, 14, 20, 18, 1, -20 },
  { 2825, 16, 27, 19, 2, -27 },
  { 2879, 12, 20, 15, 2, -20 },
  { 2909, 15, 27, 19, 2, -27 },
  { 2960, 14, 20, 17, 2, -20 },
  { 2995, 12, 28, 11, 0, -28 },
  { 3037, 15, 29, 19, 2, -20 },
  { 3092, 15, 27, 19, 2, -27 },
  { 3143, 5, 27, 9, 2, -27 },
  { 3160, 8, 36, 9, -1, -27 },
  { 3196, 16, 27, 18, 2, -27 },
  { 3250, 5, 27, 9, 2, -27 },
  { 3267, 24, 20, 29, 2, -20 },
  { 3327, 15, 20, 19, 2, -20 },
  { 3365, 15, 20, 19, 2, -20 },
  { 3403, 16, 29, 19, 2, -20 },
  { 3461, 15, 29, 19, 2, -20 },
  { 3516, 11, 20, 13, 2, -20 },
  { 3544, 12, 20, 14, 1, -20 },
  { 3574, 10, 24, 12, 1, -24 },
  { 3604, 15, 20, 19, 2, -20 },
  { 3642, 16, 20, 16, 0, -20 },
  { 3682, 25, 20, 25, 0, -20 },
  { 3745, 16, 20, 16, 0, -20 },
  { 3785, 16, 29, 16, 0, -20 },
  { 3843, 12, 20, 14, 1, -20 },
  { 3873, 11, 32, 13, 1, -26 },
  { 3917, 3, 35, 17, 7, -27 },
  { 3931, 11, 32, 13, 1, -26 },
  { 3975, 15, 5, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD36PT7B_H_
