#ifndef _NOTOSANS_CONDENSED_SEMIBOLD9PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xEC, 0x77, 0xD5, 0xE6, 0x30, 0x27, 0xA6, 0x3B, 0x62, 0x41,
  0x52, 0xA5, 0xE5, 0xA5, 0x4B, 0x00, 0x22, 0x94, 0xCE, 0xC9, 0xE0, 0xD0,
  0x6A, 0x48, 0x98, 0xD5, 0x5C, 0x2F, 0x67, 0x2F, 0x22, 0x60, 0xC0, 0xC0,
  0x25, 0x25, 0x00, 0x27, 0x99, 0x9D, 0x60, 0xF5, 0x50, 0x2F, 0x13, 0x24,
  0xF0, 0x6B, 0x16, 0x11, 0xF0, 0x35, 0x7B, 0xF3, 0x74, 0x71, 0x1E, 0x34,
  0x8F, 0x9D, 0x70, 0xF1, 0x22, 0x64, 0x25, 0xD6, 0x59, 0x70, 0x27, 0x9D,
  0x71, 0x60, 0x88, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x54, 0xB4,
  0x10, 0x7D, 0x7A, 0xEB, 0xBD, 0x03, 0x80, 0x22, 0x94, 0xED, 0xC4, 0xEA,
  0xEA, 0xBE, 0x27, 0x4C, 0xC4, 0x70, 0xE9, 0x99, 0xBE, 0xF3, 0xC9, 0xC0,
  0xF3, 0xC9, 0x00, 0x13, 0x51, 0xBC, 0xA5, 0xE0, 0x99, 0xF9, 0x99, 0xE9,
  0x25, 0xC0, 0x24, 0x92, 0x4E, 0xBE, 0xCE, 0xAB, 0x92, 0x49, 0xC0, 0x8F,
  0x5D, 0x75, 0xA6, 0x90, 0x9D, 0xDB, 0xB9, 0x22, 0xD3, 0x9C, 0xA5, 0xC0,
  0xF6, 0xE9, 0x00, 0x22, 0xD3, 0x9C, 0xA5, 0xC2, 0x08, 0xEA, 0xAE, 0xAB,
  0x25, 0xC6, 0x31, 0xE0, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x9E, 0x9A, 0x94,
  0xA6, 0x10, 0x93, 0x35, 0xAB, 0x66, 0xCD, 0x80, 0xD3, 0x08, 0xC5, 0x4C,
  0x95, 0x62, 0x22, 0xF2, 0x24, 0x4F, 0xEA, 0xAC, 0x89, 0x12, 0x40, 0xD5,
  0x5C, 0x25, 0xD0, 0xF0, 0xD0, 0x61, 0x79, 0x70, 0x93, 0xDB, 0x78, 0x74,
  0x8C, 0x60, 0x11, 0x7D, 0x9D, 0x70, 0x6D, 0xFC, 0x70, 0x6B, 0xA4, 0x90,
  0x7D, 0x9D, 0x71, 0x70, 0x93, 0xDB, 0x68, 0xBE, 0x45, 0x55, 0x80, 0x92,
  0xED, 0xE8, 0xFE, 0xFA, 0xBA, 0x69, 0xA4, 0xF6, 0xDA, 0x7D, 0x9D, 0x70,
  0xF6, 0xDF, 0x20, 0x7D, 0x9D, 0x71, 0x10, 0xEA, 0x80, 0x71, 0x9E, 0x5D,
  0x24, 0xC0, 0xB6, 0xDE, 0x99, 0x66, 0x60, 0x96, 0xD7, 0x5A, 0x48, 0x96,
  0x66, 0x90, 0x9D, 0x66, 0x64, 0xC0, 0xE5, 0x2E, 0x69, 0x44, 0x98, 0xFF,
  0x80, 0xC9, 0x14, 0xB0, 0xF9,
};

const GFXglyph NotoSans_Condensed_SemiBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 3, 2, 4, 0, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 7, 7, 7, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 2, 2, 2, 0, -6 },
  { 24, 3, 7, 3, 0, -6 },
  { 27, 2, 7, 3, 0, -6 },
  { 29, 4, 4, 4, 0, -7 },
  { 31, 4, 4, 4, 0, -5 },
  { 33, 2, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 2, 1, 2, 0, -1 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 2, 6, 4, 1, -6 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 1, 5, 2, 1, -5 },
  { 75, 2, 6, 2, 0, -5 },
  { 77, 4, 4, 4, 0, -5 },
  { 79, 4, 2, 4, 0, -4 },
  { 80, 4, 4, 4, 0, -5 },
  { 82, 3, 7, 3, 0, -7 },
  { 85, 6, 7, 7, 0, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 4, 7, 5, 0, -7 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 3, 6, 4, 1, -6 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 4, 6, 6, 1, -6 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 3, 8, 2, -1, -6 },
  { 125, 4, 6, 5, 1, -6 },
  { 128, 3, 6, 4, 1, -6 },
  { 131, 6, 6, 7, 1, -6 },
  { 136, 4, 6, 6, 1, -6 },
  { 139, 5, 7, 6, 0, -7 },
  { 144, 3, 6, 5, 1, -6 },
  { 147, 5, 9, 6, 0, -7 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 4, 7, 4, 0, -7 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 4, 6, 6, 1, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 7, 6, 7, 0, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 6, 4, 0, -6 },
  { 183, 4, 6, 4, 0, -6 },
  { 186, 2, 7, 3, 1, -6 },
  { 188, 3, 6, 4, 0, -6 },
  { 191, 2, 7, 3, 0, -6 },
  { 193, 4, 3, 5, 0, -6 },
  { 195, 4, 1, 4, 0, 1 },
  { 196, 2, 2, 3, 0, -7 },
  { 197, 4, 5, 4, 0, -5 },
  { 200, 3, 7, 5, 1, -7 },
  { 203, 4, 5, 4, 0, -5 },
  { 206, 4, 7, 5, 0, -7 },
  { 210, 4, 5, 4, 0, -5 },
  { 213, 3, 7, 3, 0, -7 },
  { 216, 4, 7, 5, 0, -5 },
  { 220, 3, 7, 5, 1, -7 },
  { 223, 1, 7, 2, 1, -7 },
  { 224, 2, 9, 2, 0, -7 },
  { 227, 3, 7, 4, 1, -7 },
  { 230, 1, 7, 2, 1, -7 },
  { 231, 6, 5, 7, 1, -5 },
  { 235, 3, 5, 5, 1, -5 },
  { 237, 4, 5, 5, 0, -5 },
  { 240, 3, 7, 5, 1, -5 },
  { 243, 4, 7, 5, 0, -5 },
  { 247, 2, 5, 3, 1, -5 },
  { 249, 3, 5, 4, 0, -5 },
  { 251, 3, 6, 3, 0, -6 },
  { 254, 3, 5, 5, 1, -5 },
  { 256, 4, 5, 4, 0, -5 },
  { 259, 6, 5, 6, 0, -5 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 4, 7, 4, 0, -5 },
  { 270, 3, 5, 3, 0, -5 },
  { 272, 3, 7, 3, 0, -6 },
  { 275, 1, 9, 4, 2, -7 },
  { 277, 3, 7, 3, 0, -6 },
  { 280, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_SemiBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD9PT7B_H_
