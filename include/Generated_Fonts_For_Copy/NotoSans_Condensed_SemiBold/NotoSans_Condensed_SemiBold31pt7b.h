#ifndef _NOTOSANS_CONDENSED_SEMIBOLD31PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0xFF, 0xFF,
  0xF3, 0xF8, 0xFE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0x07, 0x38,
  0x0C, 0x70, 0x18, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0xC6, 0x1F, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFE, 0x38, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x1F, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0x38, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03,
  0x9C, 0x06, 0x38, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xC3, 0xFF,
  0x3F, 0xF9, 0xE8, 0xDE, 0x40, 0xF2, 0x03, 0x90, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x4F, 0x02, 0x78, 0x13, 0xE0, 0x9F, 0xE5,
  0xEF, 0xFF, 0x3F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x3E,
  0x03, 0x81, 0xFC, 0x0C, 0x07, 0x70, 0x70, 0x38, 0xE1, 0xC0, 0xE3, 0x8E,
  0x03, 0x8E, 0x38, 0x0E, 0x39, 0xC0, 0x38, 0xE7, 0x00, 0xE3, 0x98, 0x43,
  0x8E, 0xE7, 0xC7, 0x73, 0xBF, 0x9F, 0xDC, 0xEE, 0x3E, 0x77, 0x1C, 0x03,
  0x9C, 0x70, 0x0E, 0x71, 0xC0, 0x31, 0xC7, 0x01, 0xC7, 0x1C, 0x07, 0x1C,
  0x70, 0x38, 0x31, 0xC0, 0xE0, 0xEE, 0x07, 0x03, 0xF8, 0x1C, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0x1E, 0x03, 0x8F, 0x01, 0xC7,
  0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x27,
  0xF0, 0xE7, 0xBC, 0xF7, 0x8F, 0x7B, 0xC7, 0xBD, 0xE1, 0xFC, 0xF0, 0x7E,
  0x78, 0x1E, 0x3E, 0x1F, 0x8F, 0xFF, 0xC7, 0xFE, 0xF0, 0xFE, 0x3C, 0xFE,
  0xEE, 0xEE, 0xEE, 0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78,
  0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0xE1, 0xE1, 0xC3, 0x83, 0x87,
  0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xE1,
  0xC7, 0x8E, 0x1C, 0x70, 0xE3, 0x80, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xE6, 0x7F, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xDC, 0x39, 0xE7, 0x8E,
  0x10, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x1F, 0xC1, 0xFF, 0x0F,
  0xF8, 0xF1, 0xE7, 0x8F, 0x38, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x73,
  0xC7, 0x9E, 0x3C, 0x7F, 0xC3, 0xFE, 0x0F, 0xC0, 0x07, 0x87, 0xC7, 0xE7,
  0xF7, 0xFF, 0xBD, 0x9E, 0x8F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0xC3, 0xFF,
  0x3F, 0xFC, 0xE1, 0xE2, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF,
  0x1F, 0xFC, 0xC1, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xF0, 0x3D, 0xFF, 0xEF, 0xFE, 0x3F, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x1C,
  0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x83, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0x0F, 0xFC, 0xFF, 0xE4, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x83, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x07, 0xF0, 0xFF,
  0x87, 0xFC, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF7, 0xC7,
  0xFF, 0x3F, 0xFD, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70,
  0x7B, 0xC3, 0xDE, 0x3C, 0x7F, 0xE3, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x1F, 0xC1, 0xFF,
  0x1F, 0x7C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x1E, 0x3D, 0xE0,
  0xFE, 0x03, 0xE0, 0x7F, 0x87, 0xDF, 0x3C, 0x7B, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xE7, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFF,
  0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x7B, 0xDE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3D, 0xEF, 0x7B, 0x9D, 0xCE, 0x00, 0x00, 0x08, 0x00, 0xC0,
  0x1E, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC0, 0x78, 0x03, 0x00,
  0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0xA0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xE0, 0xF0, 0x3C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x38,
  0xC3, 0xF8, 0xCE, 0x3F, 0xC7, 0x71, 0xC6, 0x3B, 0x1C, 0x71, 0xD8, 0xE3,
  0x8F, 0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x8E, 0x38, 0xEC,
  0x71, 0xCE, 0x71, 0xFB, 0xF3, 0x8F, 0x9F, 0x1C, 0x10, 0x20, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x20, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x38, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xC1, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x38, 0x0E, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0x7F, 0x80,
  0x3C, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0xF0, 0x7B,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBF, 0xFE,
  0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF8, 0x27, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x06, 0x7F,
  0xF1, 0xFF, 0x87, 0xF8, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xCF,
  0x07, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1E, 0xF0, 0x3D,
  0xE0, 0xFB, 0xC7, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFB,
  0xFF, 0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF3, 0xF0, 0x27, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xF0, 0x3D, 0xF0, 0x79,
  0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0,
  0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE,
  0xFE, 0xFC, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E,
  0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x81, 0xEE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0x78, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC1, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFE, 0xE0, 0xEF,
  0xF7, 0x07, 0x7F, 0xB8, 0x3B, 0xFD, 0xE3, 0x9F, 0xE7, 0x1C, 0xFF, 0x38,
  0xE7, 0xF9, 0xCE, 0x3F, 0xC7, 0x71, 0xFE, 0x3B, 0x8F, 0xF1, 0xF8, 0x7F,
  0x8F, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x07, 0xF8, 0x38,
  0x3C, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xF7, 0x87, 0xF7, 0x87, 0xF3, 0x87, 0xF3, 0xC7, 0xF1,
  0xC7, 0xF1, 0xE7, 0xF0, 0xE7, 0xF0, 0xF7, 0xF0, 0x77, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0xFD, 0xFF,
  0xCF, 0xFC, 0x7F, 0x83, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC3, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xCF, 0x0F,
  0x1E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x3F,
  0xC0, 0xF0, 0x1F, 0xE3, 0xFF, 0x7F, 0xE7, 0x86, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xE1, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x79,
  0xE0, 0xF3, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C,
  0x3C, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78,
  0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F,
  0x81, 0xCE, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF3, 0xC3, 0xF0, 0x79, 0xE1,
  0xDC, 0x38, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x1E, 0x1E, 0x3B, 0x8F, 0x0F,
  0x39, 0xC7, 0x87, 0x9C, 0x73, 0x81, 0xCE, 0x39, 0xC0, 0xE7, 0x1D, 0xE0,
  0x7F, 0x8E, 0xF0, 0x3F, 0x87, 0x78, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78, 0x3C,
  0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x3D, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0x87, 0x8F, 0x07, 0x1C, 0x0F, 0x78,
  0x0E, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x1E,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x73, 0x81, 0xCE, 0x0E, 0x1C, 0x38,
  0x71, 0xE1, 0xE7, 0x03, 0xBC, 0x0F, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0x1F, 0xC7, 0xFE, 0x3F, 0xF2, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x71, 0xFF, 0x7F, 0xF7, 0x87, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xFF, 0xF7, 0xF7, 0x3E, 0x70, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF8, 0xFF, 0xE7, 0xFF, 0xBE,
  0x3D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0x7F, 0xFB, 0xBF, 0x9C, 0xF8, 0x0F, 0xC3,
  0xFC, 0xFF, 0xBE, 0x27, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x4F, 0xF9, 0xFF, 0x1F, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE3, 0xE7, 0x3F,
  0xBB, 0xFF, 0xDE, 0x3E, 0xF0, 0xF7, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0xF7, 0x87, 0xBF, 0xFC, 0xFE, 0xE3,
  0xE7, 0x0F, 0x80, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0x38, 0x3F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x08,
  0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x03, 0x81, 0xFC, 0x7F, 0x0F, 0x21, 0xC0,
  0x38, 0x07, 0x01, 0xFC, 0xFF, 0x9F, 0xF0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1F, 0x39, 0xFD, 0xCF, 0xFE, 0xF1, 0xF7, 0x87, 0xB8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x87, 0xBC,
  0x3D, 0xFF, 0xE7, 0xF7, 0x1F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF4, 0x07,
  0xBF, 0xF9, 0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x7C, 0xEF, 0xEF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xF6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0x60, 0x00, 0x07, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xEF, 0xDF, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0xF0, 0xF7, 0x8F,
  0x3C, 0x71, 0xE7, 0x8F, 0x78, 0x7B, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87,
  0x9E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x7B, 0xC3, 0xDE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xC3, 0xE7, 0x7F, 0x7F, 0xBF, 0xFF, 0xFD, 0xF1, 0xF1, 0xEF, 0x0F, 0x87,
  0xF8, 0x78, 0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F, 0x83,
  0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38, 0x3F,
  0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x78, 0xE7, 0xCE, 0xFE, 0xFF,
  0xFF, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x0F, 0xC0,
  0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x79, 0xC0, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0E, 0x78, 0x79, 0xE1, 0xE3, 0xFF,
  0x07, 0xF8, 0x0F, 0xC0, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xF1, 0xEF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x7B, 0xFF, 0xDD, 0xFC, 0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x39, 0xFD, 0xCF, 0xFE,
  0xF1, 0xF7, 0x87, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x77, 0x07, 0xBC, 0x3D, 0xFF, 0xE7, 0xF7, 0x1F, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE7, 0xF7,
  0xFB, 0xFF, 0xFF, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x1F, 0x9F, 0xFF, 0xFF, 0xC2, 0xF0,
  0x3C, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7C, 0x07, 0x01, 0xE0, 0x7F,
  0xFF, 0xFE, 0xFF, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0xFE, 0xFF, 0xBF, 0xE3,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0xF1, 0xFC, 0x3F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x3E, 0x70, 0xF0, 0x3F, 0xC0, 0xF7, 0x03,
  0x9E, 0x1E, 0x78, 0x78, 0xE1, 0xC3, 0x87, 0x0F, 0x3C, 0x1C, 0xF0, 0x73,
  0x81, 0xCE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x78, 0x3D, 0xC1, 0xE0, 0xE7, 0x0F, 0x83, 0x9E, 0x3F, 0x1E,
  0x78, 0xFC, 0x79, 0xE3, 0x71, 0xC3, 0x8C, 0xC7, 0x0E, 0x73, 0x3C, 0x3D,
  0xCE, 0xF0, 0xF7, 0x3B, 0x81, 0xDC, 0xEE, 0x07, 0x61, 0xB8, 0x1D, 0x86,
  0xE0, 0x7E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0,
  0xF8, 0x7D, 0xE1, 0xE3, 0xC7, 0x0F, 0x3C, 0x1C, 0xE0, 0x7F, 0x80, 0xFC,
  0x03, 0xF0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1C, 0xE0, 0xF3,
  0xC3, 0x87, 0x1E, 0x1E, 0xF0, 0x3C, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9E,
  0x1E, 0x78, 0x78, 0xE1, 0xC3, 0xC7, 0x0F, 0x3C, 0x1C, 0xF0, 0x73, 0x81,
  0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x87,
  0xC7, 0xE3, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x8F,
  0x87, 0x83, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x3C, 0x1F, 0x87, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0xC0, 0xF0, 0xFC,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0xFC,
  0x3E, 0x0F, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 10, 8, 13, 2, -22 },
  { 22, 15, 22, 17, 1, -22 },
  { 64, 13, 26, 15, 1, -24 },
  { 107, 22, 22, 24, 1, -22 },
  { 168, 17, 22, 18, 1, -22 },
  { 215, 4, 8, 7, 2, -22 },
  { 219, 8, 27, 10, 1, -22 },
  { 246, 7, 27, 10, 1, -22 },
  { 270, 12, 13, 14, 1, -24 },
  { 290, 13, 14, 15, 1, -18 },
  { 313, 5, 8, 8, 1, -4 },
  { 318, 7, 3, 9, 1, -10 },
  { 321, 4, 4, 8, 2, -4 },
  { 323, 12, 22, 12, 0, -22 },
  { 356, 13, 22, 15, 1, -22 },
  { 392, 9, 22, 15, 2, -22 },
  { 417, 13, 22, 15, 1, -22 },
  { 453, 13, 22, 15, 1, -22 },
  { 489, 14, 22, 15, 1, -22 },
  { 528, 12, 22, 15, 2, -22 },
  { 561, 13, 22, 15, 1, -22 },
  { 597, 13, 22, 15, 1, -22 },
  { 633, 13, 22, 15, 1, -22 },
  { 669, 13, 22, 15, 1, -22 },
  { 705, 4, 17, 8, 2, -17 },
  { 714, 5, 21, 8, 1, -17 },
  { 728, 13, 15, 15, 1, -19 },
  { 753, 13, 9, 15, 1, -15 },
  { 768, 13, 15, 15, 1, -19 },
  { 793, 11, 22, 12, 0, -22 },
  { 824, 21, 25, 23, 1, -22 },
  { 890, 17, 22, 17, 0, -22 },
  { 937, 14, 22, 17, 2, -22 },
  { 976, 13, 22, 16, 2, -22 },
  { 1012, 15, 22, 19, 2, -22 },
  { 1054, 11, 22, 14, 2, -22 },
  { 1085, 11, 22, 14, 2, -22 },
  { 1116, 15, 22, 19, 2, -22 },
  { 1158, 15, 22, 19, 2, -22 },
  { 1200, 8, 22, 10, 1, -22 },
  { 1222, 8, 28, 8, -2, -22 },
  { 1250, 15, 22, 17, 2, -22 },
  { 1292, 11, 22, 14, 2, -22 },
  { 1323, 21, 22, 25, 2, -22 },
  { 1381, 16, 22, 21, 2, -22 },
  { 1425, 16, 22, 20, 2, -22 },
  { 1469, 13, 22, 16, 2, -22 },
  { 1505, 16, 27, 20, 2, -22 },
  { 1559, 14, 22, 17, 2, -22 },
  { 1598, 12, 22, 14, 1, -22 },
  { 1631, 14, 22, 14, 0, -22 },
  { 1670, 15, 22, 19, 2, -22 },
  { 1712, 16, 22, 16, 0, -22 },
  { 1756, 25, 22, 25, 0, -22 },
  { 1825, 16, 22, 16, 0, -22 },
  { 1869, 15, 22, 15, 0, -22 },
  { 1911, 12, 22, 14, 1, -22 },
  { 1944, 7, 27, 10, 2, -22 },
  { 1968, 12, 22, 12, 0, -22 },
  { 2001, 7, 27, 10, 1, -22 },
  { 2025, 14, 13, 16, 1, -22 },
  { 2048, 13, 2, 13, 0, 3 },
  { 2052, 7, 5, 9, 1, -24 },
  { 2057, 12, 17, 15, 1, -17 },
  { 2083, 13, 24, 16, 2, -24 },
  { 2122, 11, 17, 13, 1, -17 },
  { 2146, 13, 24, 16, 1, -24 },
  { 2185, 13, 17, 15, 1, -17 },
  { 2213, 11, 24, 10, 0, -24 },
  { 2246, 13, 24, 16, 1, -17 },
  { 2285, 12, 24, 16, 2, -24 },
  { 2321, 4, 23, 8, 2, -23 },
  { 2333, 7, 30, 8, -1, -23 },
  { 2360, 13, 24, 15, 2, -24 },
  { 2399, 4, 24, 8, 2, -24 },
  { 2411, 21, 17, 25, 2, -17 },
  { 2456, 12, 17, 16, 2, -17 },
  { 2482, 14, 17, 16, 1, -17 },
  { 2512, 13, 24, 16, 2, -17 },
  { 2551, 13, 24, 16, 1, -17 },
  { 2590, 9, 17, 11, 2, -17 },
  { 2610, 10, 17, 12, 1, -17 },
  { 2632, 10, 20, 10, 0, -20 },
  { 2657, 12, 17, 16, 2, -17 },
  { 2683, 14, 17, 14, 0, -17 },
  { 2713, 22, 17, 22, 0, -17 },
  { 2760, 14, 17, 14, 0, -17 },
  { 2790, 14, 24, 14, 0, -17 },
  { 2832, 10, 17, 12, 1, -17 },
  { 2854, 9, 27, 11, 1, -22 },
  { 2885, 3, 31, 14, 6, -24 },
  { 2897, 10, 27, 11, 1, -22 },
  { 2931, 13, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_SemiBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD31PT7B_H_
