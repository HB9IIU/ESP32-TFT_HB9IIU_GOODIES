#ifndef _NOTOSANS_CONDENSED_SEMIBOLD10PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF4, 0x39, 0xBE, 0xAF, 0xA9, 0x40, 0x27, 0xF6, 0x33, 0xF2,
  0x20, 0x65, 0x52, 0xA3, 0xB1, 0x64, 0xC9, 0x80, 0x71, 0x47, 0x1B, 0xDB,
  0x67, 0xC0, 0xC0, 0x69, 0x6C, 0x92, 0x20, 0xC9, 0x12, 0xD2, 0x80, 0x2B,
  0xF5, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0, 0x80, 0x12, 0x24, 0x44, 0x80,
  0x75, 0xDD, 0xD5, 0x70, 0x75, 0x54, 0xF1, 0x13, 0x24, 0xF0, 0xF1, 0x17,
  0x11, 0xF0, 0x31, 0x94, 0xA9, 0x7C, 0x40, 0x74, 0x67, 0x11, 0xF0, 0x72,
  0x39, 0xAD, 0xA9, 0xC0, 0xF8, 0x84, 0x42, 0x11, 0x00, 0x72, 0x94, 0xED,
  0x4D, 0xC0, 0x7D, 0x97, 0x11, 0x60, 0xC4, 0x50, 0x1C, 0x09, 0xB0, 0x60,
  0x80, 0xF8, 0x3E, 0x83, 0x06, 0xC8, 0x00, 0xE3, 0x26, 0x40, 0x40, 0x3C,
  0x85, 0x6D, 0x5A, 0xAA, 0x90, 0x1E, 0x31, 0x94, 0xB7, 0xE6, 0x20, 0xF9,
  0x9E, 0x99, 0xE0, 0x7A, 0x11, 0x84, 0x20, 0xE0, 0xF4, 0xA5, 0x39, 0x4B,
  0x80, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x78, 0x8B, 0x99, 0x70, 0x99,
  0x9F, 0x99, 0x90, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xC0, 0x9A, 0xEE,
  0xAB, 0x90, 0x92, 0x49, 0x38, 0xCF, 0x3C, 0xF3, 0xB6, 0xDB, 0x40, 0xCE,
  0x73, 0x5A, 0xCE, 0x60, 0x79, 0x34, 0x71, 0x45, 0x33, 0x80, 0xE9, 0x9E,
  0x88, 0x80, 0x79, 0x34, 0x71, 0x45, 0x33, 0x82, 0x0C, 0xE9, 0x9E, 0xAB,
  0x90, 0x7C, 0x47, 0x11, 0xF0, 0xF2, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99,
  0xF0, 0x8E, 0x56, 0xA5, 0x18, 0x80, 0x99, 0x9B, 0x5A, 0x5A, 0x66, 0x66,
  0x66, 0xDA, 0x9C, 0x45, 0x2B, 0x60, 0xDA, 0x94, 0x42, 0x10, 0x80, 0xF1,
  0x22, 0x44, 0xF0, 0xEA, 0xAA, 0xC0, 0x84, 0x46, 0x22, 0x10, 0xED, 0xB6,
  0xDB, 0xE0, 0x22, 0x95, 0x90, 0xF0, 0xCC, 0x25, 0x17, 0xD7, 0x88, 0xAF,
  0x99, 0x9E, 0x25, 0xCC, 0x47, 0x18, 0xCE, 0xBD, 0xED, 0x6D, 0x25, 0xDF,
  0x47, 0x29, 0x74, 0x92, 0x22, 0xF7, 0xB5, 0xBC, 0x6E, 0x88, 0xAF, 0x99,
  0x99, 0xDF, 0x51, 0x55, 0x70, 0x88, 0x9A, 0xCE, 0xAB, 0xFF, 0x2B, 0xDB,
  0x6D, 0xB6, 0xD0, 0x2F, 0x99, 0x99, 0x22, 0xB7, 0x95, 0xB8, 0x2F, 0x99,
  0x9E, 0x88, 0x22, 0xF7, 0xB5, 0xBC, 0x63, 0x3A, 0x49, 0x00, 0x2D, 0xC6,
  0x1E, 0x4B, 0xA4, 0x98, 0xBB, 0xBB, 0xD0, 0x9A, 0x94, 0xC6, 0x00, 0x92,
  0xDD, 0xB3, 0x66, 0xC0, 0xD6, 0x67, 0xD0, 0x9A, 0x94, 0xC2, 0x13, 0x00,
  0xF2, 0x44, 0xF0, 0x69, 0x2C, 0x93, 0x20, 0xFF, 0xC0, 0xC9, 0x32, 0x92,
  0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 4, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 7, 7, 8, 0, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 2, 2, 1, -7 },
  { 27, 3, 9, 3, 0, -7 },
  { 31, 3, 9, 3, 0, -7 },
  { 35, 4, 4, 5, 0, -8 },
  { 37, 5, 5, 5, 0, -6 },
  { 41, 2, 2, 3, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 1, 1, 3, 1, -1 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 4, 7, 5, 0, -7 },
  { 52, 2, 7, 5, 1, -7 },
  { 54, 4, 7, 5, 0, -7 },
  { 58, 4, 7, 5, 0, -7 },
  { 62, 5, 7, 5, 0, -7 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 5, 7, 5, 0, -7 },
  { 86, 4, 7, 5, 0, -7 },
  { 90, 1, 6, 3, 1, -6 },
  { 91, 2, 7, 3, 0, -6 },
  { 93, 5, 5, 5, 0, -6 },
  { 97, 5, 3, 5, 0, -5 },
  { 99, 5, 5, 5, 0, -6 },
  { 103, 4, 7, 4, 0, -7 },
  { 107, 7, 8, 8, 0, -7 },
  { 114, 5, 7, 6, 0, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 5, 7, 6, 1, -7 },
  { 133, 3, 7, 5, 1, -7 },
  { 136, 3, 7, 5, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 3, 7, 3, 0, -7 },
  { 150, 3, 9, 3, -1, -7 },
  { 154, 4, 7, 5, 1, -7 },
  { 158, 3, 7, 4, 1, -7 },
  { 161, 6, 7, 8, 1, -7 },
  { 167, 5, 7, 7, 1, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 4, 7, 5, 1, -7 },
  { 182, 6, 9, 6, 0, -7 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 4, 7, 5, 0, -7 },
  { 197, 4, 7, 5, 0, -7 },
  { 201, 4, 7, 6, 1, -7 },
  { 205, 5, 7, 5, 0, -7 },
  { 210, 8, 7, 8, 0, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 5, 7, 5, 0, -7 },
  { 227, 4, 7, 4, 0, -7 },
  { 231, 2, 9, 3, 1, -7 },
  { 234, 4, 7, 4, 0, -7 },
  { 238, 3, 9, 3, 0, -7 },
  { 242, 5, 4, 5, 0, -7 },
  { 245, 4, 1, 4, 0, 1 },
  { 246, 3, 2, 3, 0, -8 },
  { 247, 4, 6, 5, 0, -6 },
  { 250, 4, 8, 5, 1, -8 },
  { 254, 4, 6, 4, 0, -6 },
  { 257, 5, 8, 5, 0, -8 },
  { 262, 4, 6, 5, 0, -6 },
  { 265, 3, 8, 3, 0, -8 },
  { 268, 5, 8, 5, 0, -6 },
  { 273, 4, 8, 5, 1, -8 },
  { 277, 1, 8, 2, 1, -8 },
  { 278, 2, 10, 2, 0, -8 },
  { 281, 4, 8, 5, 1, -8 },
  { 285, 1, 8, 2, 1, -8 },
  { 286, 6, 6, 8, 1, -6 },
  { 291, 4, 6, 5, 1, -6 },
  { 294, 5, 6, 5, 0, -6 },
  { 298, 4, 8, 5, 1, -6 },
  { 302, 5, 8, 5, 0, -6 },
  { 307, 3, 6, 4, 1, -6 },
  { 310, 4, 6, 4, 0, -6 },
  { 313, 3, 7, 3, 0, -7 },
  { 316, 4, 5, 5, 1, -5 },
  { 319, 5, 5, 5, 0, -5 },
  { 323, 7, 5, 7, 0, -5 },
  { 328, 4, 5, 5, 0, -5 },
  { 331, 5, 7, 5, 0, -5 },
  { 336, 4, 5, 4, 0, -5 },
  { 339, 3, 9, 4, 0, -7 },
  { 343, 1, 10, 5, 2, -8 },
  { 345, 3, 9, 4, 0, -7 },
  { 349, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD10PT7B_H_
