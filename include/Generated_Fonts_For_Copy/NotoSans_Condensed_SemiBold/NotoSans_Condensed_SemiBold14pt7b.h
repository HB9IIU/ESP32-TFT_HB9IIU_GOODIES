#ifndef _NOTOSANS_CONDENSED_SEMIBOLD14PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0xF0, 0xF9, 0x99, 0x14, 0x68, 0x93, 0xF2, 0xC5, 0xBF,
  0x94, 0x68, 0x90, 0x21, 0x3F, 0x4A, 0x70, 0xE5, 0xAF, 0xC8, 0x40, 0x71,
  0x14, 0xCD, 0x21, 0x58, 0x55, 0xDD, 0x50, 0xB4, 0x2D, 0x19, 0x44, 0x70,
  0x38, 0x6C, 0x6C, 0x68, 0x30, 0x7B, 0x4B, 0xCE, 0x6E, 0x7B, 0xEA, 0x6B,
  0x49, 0x24, 0x99, 0x30, 0xC6, 0x22, 0x33, 0x33, 0x22, 0x6C, 0x30, 0x47,
  0xEC, 0x39, 0xA0, 0x10, 0x4F, 0xFF, 0x10, 0x40, 0x6D, 0x60, 0xFF, 0xF0,
  0x08, 0xC4, 0x23, 0x11, 0x8C, 0x46, 0x00, 0x76, 0xE7, 0x18, 0xC6, 0x33,
  0xDB, 0x80, 0x37, 0xF3, 0x33, 0x33, 0x33, 0x7B, 0x30, 0xC3, 0x0C, 0x63,
  0x08, 0x43, 0xF0, 0xF9, 0x30, 0xC3, 0x38, 0xF0, 0xC3, 0x8D, 0xE0, 0x0C,
  0x38, 0x71, 0x66, 0xC9, 0xB3, 0x7F, 0x0C, 0x18, 0xFE, 0x21, 0x0F, 0x0C,
  0x63, 0x9F, 0x80, 0x7E, 0x31, 0x0F, 0xCE, 0x31, 0xDB, 0x80, 0xFC, 0x10,
  0xC2, 0x18, 0x61, 0x0C, 0x31, 0x80, 0x79, 0xB4, 0xDB, 0x39, 0xE4, 0xF1,
  0x4D, 0xE0, 0x39, 0xB4, 0xF1, 0x4D, 0xF0, 0x43, 0x19, 0xC0, 0xB0, 0x0F,
  0x4C, 0x00, 0x1B, 0x58, 0x04, 0x66, 0x38, 0x18, 0x10, 0xFC, 0x00, 0x3F,
  0xC1, 0xC1, 0xC3, 0x73, 0x00, 0xF4, 0xC6, 0x33, 0x10, 0x80, 0x63, 0x00,
  0x3E, 0x31, 0xB0, 0x73, 0x9B, 0x4D, 0x26, 0x93, 0x76, 0x80, 0x21, 0x0F,
  0x80, 0x18, 0x38, 0x3C, 0x2C, 0x24, 0x64, 0x7E, 0x46, 0xC6, 0xC3, 0xFB,
  0x7C, 0xF3, 0xFB, 0x7C, 0xF3, 0xCF, 0xE0, 0x7D, 0x9C, 0x30, 0x82, 0x0C,
  0x30, 0xE5, 0xF0, 0xF9, 0xBB, 0x36, 0x3C, 0x78, 0xF1, 0xE6, 0xDD, 0xF0,
  0xFE, 0x31, 0x8F, 0xFF, 0x18, 0xC7, 0xC0, 0xFE, 0x31, 0x8F, 0xFF, 0x18,
  0xC6, 0x00, 0x3E, 0xCB, 0x06, 0x08, 0x13, 0xF1, 0xE3, 0x66, 0xFC, 0xC7,
  0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xF6, 0x66, 0x66, 0x66,
  0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xE0, 0xCF, 0x9B, 0x67, 0x8F,
  0x1E, 0x36, 0x6C, 0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xC0,
  0xE1, 0xF1, 0xF8, 0xFC, 0x5F, 0x2E, 0xB7, 0x53, 0xB9, 0xDC, 0xE4, 0x40,
  0xC3, 0xC7, 0x8F, 0x9D, 0x3B, 0x72, 0xE7, 0xCF, 0x8C, 0x7D, 0xDF, 0x1E,
  0x38, 0x30, 0x71, 0xE3, 0xEC, 0xF8, 0xFB, 0x6C, 0xF3, 0xCB, 0xEC, 0x30,
  0xC3, 0x00, 0x7D, 0xDF, 0x1E, 0x38, 0x30, 0x71, 0xE3, 0xEE, 0xF8, 0x30,
  0x70, 0xFB, 0x7C, 0xF3, 0xDB, 0xCD, 0xB6, 0xCF, 0x30, 0x7E, 0xA1, 0x8E,
  0x18, 0x63, 0x9F, 0x80, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCC, 0xF0, 0xC3, 0x8D, 0x1B,
  0x26, 0x45, 0x8B, 0x1C, 0x38, 0x30, 0xC4, 0x78, 0xCF, 0x39, 0xA5, 0x26,
  0xA4, 0xD7, 0x9E, 0xF1, 0xCE, 0x31, 0x86, 0x30, 0xC6, 0xD9, 0xB1, 0xC3,
  0x87, 0x0A, 0x36, 0x6D, 0x8C, 0xC6, 0x89, 0xB3, 0x43, 0x87, 0x04, 0x08,
  0x10, 0x20, 0xFC, 0x30, 0x86, 0x10, 0xC6, 0x18, 0xC3, 0xF0, 0xF2, 0x49,
  0x24, 0x92, 0x70, 0xC2, 0x18, 0xC2, 0x18, 0x42, 0x18, 0x40, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC, 0xC8,
  0x80, 0x39, 0xF0, 0xCF, 0x6F, 0x34, 0xDD, 0xC3, 0x0C, 0x3C, 0xFB, 0x3C,
  0xF3, 0xCF, 0x2B, 0x80, 0x7F, 0xC8, 0x88, 0xD7, 0x08, 0x42, 0xDF, 0xC6,
  0x31, 0x8E, 0xDE, 0x77, 0xE3, 0xFF, 0xC3, 0x2F, 0x3B, 0x98, 0xEF, 0x31,
  0x8C, 0x63, 0x18, 0x6F, 0xE3, 0x18, 0xC7, 0x6D, 0x0C, 0xFE, 0xC3, 0x0C,
  0x3C, 0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xB3, 0xFF, 0xFC, 0x4C, 0x36,
  0xDB, 0x6D, 0xB7, 0x80, 0xC3, 0x0C, 0x33, 0xDB, 0xCE, 0x3C, 0xD3, 0x6C,
  0xC0, 0xFF, 0xFF, 0xFC, 0xB3, 0x7F, 0xF3, 0x39, 0x1C, 0x8E, 0x47, 0x23,
  0x91, 0xB3, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0x73, 0xE8, 0xA3, 0x8E, 0x3D,
  0x9C, 0xB3, 0xEC, 0xF3, 0xCF, 0x3C, 0xAE, 0xC3, 0x0C, 0x00, 0x6F, 0xE3,
  0x18, 0xC7, 0x6D, 0x08, 0x42, 0xBB, 0xCC, 0xCC, 0xCC, 0x33, 0xF0, 0xC3,
  0x8E, 0x7F, 0x67, 0xF6, 0x66, 0x66, 0x70, 0xCF, 0x3C, 0xF3, 0xCF, 0x3D,
  0xFF, 0xC7, 0x34, 0xDA, 0x68, 0xE3, 0x8C, 0xCC, 0xF3, 0x24, 0xC9, 0x7E,
  0x77, 0x9C, 0xE3, 0x30, 0xCC, 0xCD, 0xB7, 0x8C, 0x31, 0xE6, 0xB3, 0xC7,
  0x34, 0xDA, 0x68, 0xE3, 0x8C, 0x30, 0xCE, 0x00, 0x7B, 0xC4, 0x62, 0x31,
  0x1F, 0x39, 0x88, 0x42, 0x73, 0x84, 0x21, 0x08, 0x70, 0xFF, 0xFC, 0xCC,
  0x44, 0x47, 0x74, 0x44, 0x4C, 0x76, 0x70,
};

const GFXglyph NotoSans_Condensed_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 7, 10, 7, 0, -10 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 10, 10, 11, 0, -10 },
  { 36, 8, 10, 8, 0, -10 },
  { 46, 2, 4, 3, 1, -10 },
  { 47, 3, 12, 4, 1, -10 },
  { 52, 4, 12, 4, 0, -10 },
  { 58, 6, 6, 6, 0, -11 },
  { 63, 6, 6, 7, 0, -8 },
  { 68, 3, 4, 4, 0, -2 },
  { 70, 4, 2, 4, 0, -5 },
  { 71, 2, 2, 4, 1, -2 },
  { 72, 5, 10, 6, 0, -10 },
  { 79, 5, 10, 7, 1, -10 },
  { 86, 4, 10, 7, 1, -10 },
  { 91, 6, 10, 7, 0, -10 },
  { 99, 6, 10, 7, 0, -10 },
  { 107, 7, 10, 7, 0, -10 },
  { 116, 5, 10, 7, 1, -10 },
  { 123, 5, 10, 7, 1, -10 },
  { 130, 6, 10, 7, 0, -10 },
  { 138, 6, 10, 7, 0, -10 },
  { 146, 6, 10, 7, 0, -10 },
  { 154, 2, 8, 4, 1, -8 },
  { 156, 3, 10, 4, 0, -8 },
  { 160, 6, 6, 7, 0, -8 },
  { 165, 6, 4, 7, 0, -7 },
  { 168, 6, 6, 7, 0, -8 },
  { 173, 5, 10, 5, 0, -10 },
  { 180, 9, 11, 11, 1, -10 },
  { 193, 8, 10, 8, 0, -10 },
  { 203, 6, 10, 8, 1, -10 },
  { 211, 6, 10, 7, 1, -10 },
  { 219, 7, 10, 8, 1, -10 },
  { 228, 5, 10, 6, 1, -10 },
  { 235, 5, 10, 6, 1, -10 },
  { 242, 7, 10, 9, 1, -10 },
  { 251, 7, 10, 9, 1, -10 },
  { 260, 4, 10, 5, 0, -10 },
  { 265, 4, 13, 4, -1, -10 },
  { 272, 7, 10, 8, 1, -10 },
  { 281, 5, 10, 6, 1, -10 },
  { 288, 9, 10, 11, 1, -10 },
  { 300, 7, 10, 9, 1, -10 },
  { 309, 7, 10, 9, 1, -10 },
  { 318, 6, 10, 7, 1, -10 },
  { 326, 7, 12, 9, 1, -10 },
  { 337, 6, 10, 8, 1, -10 },
  { 345, 5, 10, 6, 1, -10 },
  { 352, 6, 10, 6, 0, -10 },
  { 360, 7, 10, 9, 1, -10 },
  { 369, 7, 10, 7, 0, -10 },
  { 378, 11, 10, 11, 0, -10 },
  { 392, 7, 10, 7, 0, -10 },
  { 401, 7, 10, 7, 0, -10 },
  { 410, 6, 10, 6, 0, -10 },
  { 418, 3, 12, 4, 1, -10 },
  { 423, 5, 10, 6, 0, -10 },
  { 430, 4, 12, 4, 0, -10 },
  { 436, 7, 6, 7, 0, -10 },
  { 442, 6, 1, 6, 0, 1 },
  { 443, 3, 3, 4, 1, -11 },
  { 445, 6, 8, 7, 0, -8 },
  { 451, 6, 11, 7, 1, -11 },
  { 460, 4, 8, 6, 1, -8 },
  { 464, 5, 11, 7, 1, -11 },
  { 471, 5, 8, 7, 1, -8 },
  { 476, 5, 11, 4, 0, -11 },
  { 483, 5, 11, 7, 1, -8 },
  { 490, 6, 11, 7, 1, -11 },
  { 499, 2, 11, 3, 1, -11 },
  { 502, 3, 14, 3, 0, -11 },
  { 508, 6, 11, 7, 1, -11 },
  { 517, 2, 11, 3, 1, -11 },
  { 520, 9, 8, 11, 1, -8 },
  { 529, 6, 8, 7, 1, -8 },
  { 535, 6, 8, 7, 1, -8 },
  { 541, 6, 11, 7, 1, -8 },
  { 550, 5, 11, 7, 1, -8 },
  { 557, 4, 8, 5, 1, -8 },
  { 561, 5, 8, 6, 0, -8 },
  { 566, 4, 9, 5, 0, -9 },
  { 571, 6, 8, 7, 1, -8 },
  { 577, 6, 8, 6, 0, -8 },
  { 583, 10, 8, 10, 0, -8 },
  { 593, 6, 8, 6, 0, -8 },
  { 599, 6, 11, 6, 0, -8 },
  { 608, 5, 8, 5, 0, -8 },
  { 613, 5, 12, 5, 0, -10 },
  { 621, 1, 14, 7, 3, -11 },
  { 623, 4, 12, 5, 1, -10 },
  { 629, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD14PT7B_H_
