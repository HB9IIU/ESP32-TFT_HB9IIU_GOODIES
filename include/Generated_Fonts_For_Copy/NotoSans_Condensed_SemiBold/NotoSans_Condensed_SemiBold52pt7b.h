#ifndef _NOTOSANS_CONDENSED_SEMIBOLD52PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0xFC,
  0x3F, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x3E, 0xFC, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0x81, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x03,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xF3, 0x83, 0x1F, 0x9C, 0x01, 0xF8, 0xE0, 0x0F,
  0xC7, 0x00, 0x7E, 0x38, 0x01, 0xF9, 0xC0, 0x0F, 0xEE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x73, 0xF8, 0x03, 0x8F,
  0xC0, 0x1C, 0x7E, 0x00, 0xE1, 0xF0, 0x07, 0x1F, 0xC0, 0x38, 0xFF, 0xC1,
  0xCF, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1E,
  0x00, 0x7F, 0xF8, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x3C, 0x00, 0xF8, 0x7C,
  0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xC0, 0xF8, 0x00, 0xF8, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC1, 0xF0,
  0x00, 0xF8, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC3, 0xE0, 0x00, 0xF8, 0x3C,
  0x3E, 0x00, 0x0F, 0x83, 0xC7, 0xC1, 0xE0, 0xF8, 0x7C, 0x7C, 0x7F, 0x8F,
  0x87, 0xC7, 0x8F, 0xFC, 0x7C, 0x7C, 0xF9, 0xFF, 0xE7, 0xFF, 0x8F, 0x1F,
  0xFE, 0x3F, 0xF9, 0xF1, 0xE1, 0xF3, 0xFF, 0x1F, 0x3E, 0x1F, 0x1F, 0xE3,
  0xE3, 0xE1, 0xF0, 0x30, 0x3E, 0x3E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0xF0,
  0x00, 0x7C, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0x00, 0xF8, 0x3E,
  0x0F, 0x00, 0x0F, 0x83, 0xE0, 0xF0, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x1F,
  0x03, 0xE1, 0xF0, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x3E, 0x03, 0xE1, 0xF0,
  0x03, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xC3, 0xFF,
  0xE0, 0x7E, 0x1F, 0xFF, 0x83, 0xF1, 0xFC, 0xFC, 0x3F, 0x9F, 0xC7, 0xF1,
  0xF8, 0xFE, 0x1F, 0xCF, 0xC7, 0xE0, 0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0xE1,
  0xF8, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0x7E, 0x00, 0xFF, 0x83, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0xF8, 0xFF,
  0x03, 0xFF, 0x03, 0xFC, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x78, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0x03, 0xC0, 0xDF, 0x9E, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xD0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x1C, 0x0F, 0x00, 0x60, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x0C, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFE, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE,
  0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F,
  0xFC, 0xFD, 0xF1, 0xF9, 0xC3, 0xF1, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xF0, 0x3F, 0xC7,
  0x00, 0xFE, 0x10, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xE0, 0x1F, 0xC6, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0xE0, 0x0F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80,
  0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF8, 0x03,
  0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE2, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x80, 0x0F, 0xEE, 0x01, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x1F, 0x9F, 0xF0, 0xFD, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xE0, 0x7F, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8,
  0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0xFE, 0x1F,
  0xC1, 0xFC, 0xFE, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFE, 0x03, 0xF9, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFC, 0x1F, 0x8F, 0xC0, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0xFF, 0x1F,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xF7, 0xE1, 0xFF, 0x3F, 0x03,
  0xE1, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8E, 0x03, 0xF9, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x06, 0x00, 0xF0, 0xF8,
  0x0F, 0xFE, 0x1F, 0x1F, 0x03, 0xFF, 0xE3, 0xE3, 0xC0, 0xFF, 0xFC, 0x3C,
  0xF8, 0x3F, 0x0F, 0x07, 0xDF, 0x07, 0xC1, 0xE0, 0xFB, 0xE1, 0xF0, 0x3C,
  0x1F, 0x78, 0x3E, 0x07, 0x83, 0xEF, 0x07, 0x80, 0xF0, 0x7F, 0xE0, 0xF0,
  0x3E, 0x0F, 0xFC, 0x3E, 0x07, 0xC1, 0xFF, 0x87, 0xC0, 0xF8, 0x3F, 0xF0,
  0xF8, 0x1F, 0x07, 0xFE, 0x1F, 0x03, 0xE0, 0xFF, 0xC3, 0xE0, 0x7C, 0x1E,
  0xF8, 0x3C, 0x0F, 0x83, 0xCF, 0x07, 0xC3, 0xF0, 0xF9, 0xE0, 0xF8, 0x7F,
  0x1E, 0x3E, 0x0F, 0xFF, 0xFF, 0xC7, 0xC1, 0xFF, 0x9F, 0xF0, 0xF8, 0x1F,
  0xE3, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0x3F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x01,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFF, 0x7E,
  0x03, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF8,
  0x0E, 0x1F, 0xE0, 0x04, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x02, 0x1F, 0xF0, 0x38, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x87, 0xE0, 0xFF, 0xC3, 0xF0, 0x0F, 0xF1, 0xF8, 0x03, 0xFC, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80,
  0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x1F, 0xF1, 0xF8,
  0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0x3C, 0x7F, 0x80, 0x04, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x3F,
  0x1F, 0xE0, 0x1F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFE, 0x07, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFB, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFF, 0x00, 0x3E, 0xFF, 0xF7, 0xC0,
  0x0F, 0xBF, 0xFD, 0xF0, 0x07, 0xEF, 0xFF, 0x7E, 0x01, 0xF3, 0xFF, 0xCF,
  0x80, 0x7C, 0xFF, 0xF3, 0xE0, 0x1F, 0x3F, 0xFC, 0xF8, 0x0F, 0x8F, 0xFF,
  0x3F, 0x03, 0xE3, 0xFF, 0xC7, 0xC0, 0xF8, 0xFF, 0xF1, 0xF0, 0x7C, 0x3F,
  0xFC, 0x7E, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xC3, 0xFF, 0xC3, 0xE3, 0xF0,
  0xFF, 0xF0, 0xF8, 0xF8, 0x3F, 0xFC, 0x3F, 0x3E, 0x0F, 0xFF, 0x07, 0xCF,
  0x83, 0xFF, 0xC1, 0xF7, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFE, 0xFC, 0x01, 0xFF, 0xBF, 0x80,
  0x7F, 0xF7, 0xE0, 0x1F, 0xFD, 0xFC, 0x07, 0xFF, 0x3F, 0x01, 0xFF, 0xCF,
  0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xFC, 0x7F, 0x07, 0xFF, 0x0F, 0xC1, 0xFF,
  0xC3, 0xF8, 0x7F, 0xF0, 0x7E, 0x1F, 0xFC, 0x1F, 0x87, 0xFF, 0x03, 0xF1,
  0xFF, 0xC0, 0xFC, 0x7F, 0xF0, 0x1F, 0x9F, 0xFC, 0x07, 0xE7, 0xFF, 0x00,
  0xFD, 0xFF, 0xC0, 0x3F, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE0, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x0F, 0xFB, 0xF0,
  0x1F, 0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7E, 0xFC, 0x07, 0xF7, 0xE0, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xF0,
  0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x00, 0x38, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x83, 0xC7, 0xE0, 0x04, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xFE, 0x00, 0x7E, 0xFC, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x0F, 0xE7,
  0xE0, 0x07, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x7C,
  0x07, 0xF0, 0xFC, 0x07, 0xDF, 0x01, 0xF8, 0x1F, 0x81, 0xF7, 0xC0, 0x7E,
  0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xCF, 0x83, 0xF0, 0x1F, 0x83, 0xF3, 0xE0, 0xFC, 0x03, 0xF0, 0xF8,
  0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x87, 0xC7,
  0xF0, 0x0F, 0xC7, 0xE1, 0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x7C, 0x7E, 0x00,
  0x7E, 0x7C, 0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x03, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0xF9, 0xF0, 0x01, 0xFB, 0xF0, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x0F,
  0xBF, 0x00, 0x0F, 0xBE, 0x01, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xE0, 0xFE, 0x08, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x3F, 0xF7, 0xFF, 0xDF, 0x7F, 0xFD, 0xF3, 0xFF, 0x9F, 0x1F,
  0xE0, 0xF0, 0x30, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0x80, 0xFC, 0x7F, 0x83, 0xF3, 0xFF, 0x8F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xEF, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xEF, 0xF8, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF,
  0x8F, 0xCF, 0xFC, 0x3E, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFB, 0xE3, 0xF8,
  0x09, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x78, 0x3F, 0x07, 0xF8, 0xFC, 0x3F, 0xFB, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xCF, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80, 0x7F,
  0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F,
  0xF9, 0xF0, 0xFF, 0xE7, 0xC1, 0xFE, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x06, 0x3F, 0xE3, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0x30, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF1, 0xF0,
  0xFF, 0xE7, 0xC7, 0xFF, 0x9F, 0x3F, 0xFF, 0xFC, 0xFF, 0x3F, 0xF7, 0xF0,
  0x3F, 0xDF, 0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF, 0x3F, 0x07,
  0xF8, 0xFC, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF4, 0x00, 0x1F, 0x8E, 0x01, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1C, 0x0F, 0xC7, 0xFC, 0x7E, 0x7F, 0xF3,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7D, 0xFB, 0xFF, 0xFF,
  0xEF, 0x8E, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFB,
  0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0,
  0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xFE, 0x03, 0xE3, 0xF0,
  0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x7C,
  0x1F, 0x0F, 0xF8, 0x3F, 0xE3, 0xE7, 0xFF, 0x8F, 0xFE, 0x7E, 0xFF, 0xF3,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC1,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7E,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x07, 0xC3, 0xFE, 0x3E, 0x3F, 0xF9, 0xFB,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F,
  0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0xE1, 0xFE, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0x7E, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xBF, 0xE0, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xDF,
  0xFE, 0x3F, 0x3F, 0xF0, 0xFC, 0x7F, 0x83, 0xF0, 0x30, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7,
  0xC7, 0xFF, 0x9F, 0x3F, 0xFF, 0xFC, 0xFF, 0x3F, 0xF7, 0xF0, 0x3F, 0xDF,
  0xC0, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF, 0x3F, 0x07, 0xF8, 0xFC,
  0x01, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xF0, 0x7B, 0xF0, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x01, 0x80, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD,
  0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFE, 0xF9, 0xFF, 0xF7, 0xC7, 0xFF,
  0x3E, 0x1F, 0xE1, 0xF0, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xC0, 0x3F, 0x7E, 0x03, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xE0,
  0x7E, 0x3E, 0x03, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xE0, 0x7E, 0x3F, 0x07,
  0xDE, 0x07, 0xE3, 0xF0, 0x7D, 0xE0, 0x7C, 0x3F, 0x07, 0xDF, 0x0F, 0xC1,
  0xF8, 0x79, 0xF0, 0xFC, 0x1F, 0x87, 0x9F, 0x0F, 0xC1, 0xF8, 0xF8, 0xF0,
  0xF8, 0x1F, 0x8F, 0x8F, 0x1F, 0x80, 0xF8, 0xF8, 0xF9, 0xF8, 0x0F, 0xCF,
  0x0F, 0x9F, 0x80, 0xFC, 0xF0, 0xF9, 0xF0, 0x0F, 0xDF, 0x07, 0x9F, 0x00,
  0x7D, 0xF0, 0x7B, 0xF0, 0x07, 0xDF, 0x07, 0xBF, 0x00, 0x7D, 0xE0, 0x7F,
  0xF0, 0x07, 0xDE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF9, 0xF8, 0x03, 0xF7, 0xF0,
  0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7F, 0x00, 0xFE,
  0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE8, 0x01, 0xFF, 0x20, 0x00, 0x20,
};

const GFXglyph NotoSans_Condensed_SemiBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 38, 13, 3, -37 },
  { 35, 17, 13, 22, 3, -37 },
  { 63, 26, 37, 28, 1, -37 },
  { 184, 21, 42, 25, 2, -39 },
  { 295, 36, 38, 40, 2, -38 },
  { 466, 29, 39, 31, 2, -38 },
  { 608, 6, 13, 12, 3, -37 },
  { 618, 13, 45, 16, 2, -37 },
  { 692, 13, 45, 16, 1, -37 },
  { 766, 21, 21, 24, 2, -40 },
  { 822, 22, 25, 25, 2, -31 },
  { 891, 8, 13, 13, 2, -6 },
  { 904, 12, 6, 16, 2, -17 },
  { 913, 7, 8, 13, 3, -7 },
  { 920, 19, 37, 20, 1, -37 },
  { 1008, 21, 39, 25, 2, -38 },
  { 1111, 15, 37, 25, 3, -37 },
  { 1181, 21, 38, 25, 2, -38 },
  { 1281, 21, 39, 25, 2, -38 },
  { 1384, 23, 37, 25, 1, -37 },
  { 1491, 20, 38, 25, 3, -37 },
  { 1586, 21, 39, 25, 2, -38 },
  { 1689, 23, 37, 25, 1, -37 },
  { 1796, 22, 39, 25, 2, -38 },
  { 1904, 21, 39, 25, 2, -38 },
  { 2007, 7, 30, 13, 3, -29 },
  { 2034, 8, 36, 13, 2, -29 },
  { 2070, 22, 25, 25, 2, -31 },
  { 2139, 22, 15, 25, 2, -26 },
  { 2181, 22, 25, 25, 2, -31 },
  { 2250, 19, 39, 20, 0, -38 },
  { 2343, 35, 41, 39, 2, -37 },
  { 2523, 29, 37, 29, 0, -37 },
  { 2658, 23, 37, 29, 4, -37 },
  { 2765, 23, 39, 27, 3, -38 },
  { 2878, 25, 37, 31, 4, -37 },
  { 2994, 17, 37, 24, 4, -37 },
  { 3073, 17, 37, 23, 4, -37 },
  { 3152, 25, 39, 32, 3, -38 },
  { 3274, 24, 37, 32, 4, -37 },
  { 3385, 13, 37, 17, 2, -37 },
  { 3446, 13, 48, 14, -3, -37 },
  { 3524, 24, 37, 28, 4, -37 },
  { 3635, 18, 37, 23, 4, -37 },
  { 3719, 34, 37, 42, 4, -37 },
  { 3877, 26, 37, 34, 4, -37 },
  { 3998, 28, 39, 33, 3, -38 },
  { 4135, 21, 37, 27, 4, -37 },
  { 4233, 28, 47, 33, 3, -38 },
  { 4398, 24, 37, 28, 4, -37 },
  { 4509, 20, 39, 24, 2, -38 },
  { 4607, 22, 37, 24, 1, -37 },
  { 4709, 24, 38, 32, 4, -37 },
  { 4823, 27, 37, 27, 0, -37 },
  { 4948, 42, 37, 42, 0, -37 },
  { 5143, 26, 37, 26, 0, -37 },
  { 5264, 26, 37, 26, 0, -37 },
  { 5385, 21, 37, 23, 1, -37 },
  { 5483, 12, 45, 16, 3, -37 },
  { 5551, 19, 37, 20, 1, -37 },
  { 5639, 12, 45, 16, 1, -37 },
  { 5707, 25, 22, 27, 1, -37 },
  { 5776, 22, 3, 22, 0, 5 },
  { 5785, 12, 8, 16, 2, -40 },
  { 5797, 20, 30, 25, 2, -29 },
  { 5872, 22, 41, 27, 3, -40 },
  { 5985, 18, 30, 22, 2, -29 },
  { 6053, 22, 41, 27, 2, -40 },
  { 6166, 21, 30, 25, 2, -29 },
  { 6245, 17, 40, 16, 1, -40 },
  { 6330, 22, 41, 27, 2, -29 },
  { 6443, 21, 40, 28, 3, -40 },
  { 6548, 7, 39, 13, 3, -39 },
  { 6583, 12, 51, 13, -2, -39 },
  { 6660, 22, 40, 26, 4, -40 },
  { 6770, 6, 40, 13, 3, -40 },
  { 6800, 35, 29, 41, 3, -29 },
  { 6927, 21, 29, 28, 3, -29 },
  { 7004, 23, 30, 27, 2, -29 },
  { 7091, 22, 41, 27, 3, -29 },
  { 7204, 22, 41, 27, 2, -29 },
  { 7317, 15, 29, 19, 3, -29 },
  { 7372, 17, 30, 21, 2, -29 },
  { 7436, 15, 35, 17, 1, -34 },
  { 7502, 21, 29, 28, 3, -28 },
  { 7579, 24, 28, 24, 0, -28 },
  { 7663, 36, 28, 37, 0, -28 },
  { 7789, 23, 28, 23, 0, -28 },
  { 7870, 24, 40, 24, 0, -28 },
  { 7990, 18, 28, 20, 1, -28 },
  { 8053, 16, 45, 19, 1, -37 },
  { 8143, 5, 52, 24, 10, -40 },
  { 8176, 16, 45, 19, 2, -37 },
  { 8266, 22, 8, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_SemiBold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD52PT7B_H_
