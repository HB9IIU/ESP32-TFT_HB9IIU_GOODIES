#ifndef _NOTOSANS_CONDENSED_SEMIBOLD38PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0xBE, 0xFF, 0xE7, 0x80, 0xF9, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xF7,
  0x0F, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38,
  0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x83, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0F, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70,
  0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x7F, 0x83, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0x7D, 0x84, 0xF3, 0x01, 0xE6,
  0x03, 0xCC, 0x07, 0xD8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x0C, 0xF8, 0x19, 0xF0, 0x31, 0xE0, 0x63, 0xE0,
  0xCF, 0xF9, 0xFE, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0x80, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x00,
  0xFE, 0x01, 0xE0, 0x3F, 0xE0, 0x38, 0x07, 0x1C, 0x0F, 0x00, 0xE3, 0xC1,
  0xC0, 0x3C, 0x78, 0x78, 0x07, 0x8F, 0x0E, 0x00, 0xF0, 0xE3, 0xC0, 0x1E,
  0x1C, 0x78, 0x03, 0xC7, 0x8E, 0x00, 0x78, 0xF3, 0xC7, 0x07, 0x1E, 0x71,
  0xF8, 0xE3, 0x9E, 0x7F, 0x9F, 0xF3, 0x9E, 0xF1, 0xFE, 0xF3, 0x8F, 0x1F,
  0x9E, 0x71, 0xE0, 0x83, 0x9E, 0x3C, 0x00, 0xF3, 0xC3, 0x80, 0x1C, 0x78,
  0x70, 0x07, 0x8F, 0x0E, 0x00, 0xE1, 0xE3, 0xC0, 0x3C, 0x1C, 0x78, 0x07,
  0x83, 0x8F, 0x00, 0xE0, 0x79, 0xC0, 0x3C, 0x0F, 0xF8, 0x07, 0x00, 0xFE,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x0F,
  0x8F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xF7, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0x8F, 0xFC, 0x3C,
  0x7D, 0xF1, 0xF1, 0xF3, 0xE7, 0xCF, 0x87, 0xDE, 0x3E, 0x0F, 0xF8, 0xF8,
  0x3F, 0xE3, 0xE0, 0x7F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x79, 0xCE, 0x73, 0x80, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xF0,
  0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0E, 0x07, 0x83, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x04, 0x38, 0x6F, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xF7, 0xC3, 0xE7, 0x87, 0x8F, 0x83, 0x0C,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7C, 0x3C, 0x3E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x87,
  0xF1, 0xFE, 0x7F, 0xFF, 0x7B, 0xCF, 0x31, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0x80, 0x1F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7E, 0xFE, 0x30, 0x3E, 0x20, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFC, 0x7C, 0xFE, 0x20, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x3E, 0xFD, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0x8F,
  0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x8F,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xA0, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE1,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xC2, 0x3F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x79, 0xF8,
  0x7F, 0xFC, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1F, 0x3C, 0x1E,
  0x3F, 0x7E, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3E, 0x7E, 0x7C, 0x3E,
  0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x1F,
  0x7E, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7E, 0x7F,
  0x3F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x23, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0x38, 0xF9, 0xFB, 0xF7, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF1, 0xE7,
  0xCF, 0x1E, 0x3C, 0x71, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x7D, 0xF8,
  0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0xF0, 0x7F, 0x8E, 0x70, 0x7F, 0xC7, 0x38, 0x7F, 0xE3, 0xFC,
  0x78, 0x70, 0xFE, 0x38, 0x38, 0x7E, 0x1C, 0x3C, 0x3F, 0x1E, 0x1E, 0x1F,
  0x8F, 0x0F, 0x0F, 0xC7, 0x87, 0x87, 0xE3, 0xC3, 0xC7, 0xF1, 0xE1, 0xE3,
  0xF8, 0x70, 0xF1, 0xDC, 0x3C, 0xF9, 0xEF, 0x1F, 0xEF, 0xE7, 0x87, 0xE3,
  0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x18, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0x9F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0xF1,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00,
  0x3E, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x20, 0x01, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xE1, 0xFD, 0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x02, 0x3F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F, 0x3C, 0x07, 0xEF, 0x00, 0xFB, 0xC0,
  0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x07, 0xF3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDE, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFE, 0xFC,
  0x7E, 0x01, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x1F, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x7E, 0x7F, 0xFE, 0xFF, 0x7F, 0x1E, 0x00, 0xF0, 0x0F,
  0xBC, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F,
  0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xDF,
  0x00, 0xF7, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF7, 0xC0, 0xF9, 0xF0,
  0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F,
  0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0xFC, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xEE, 0x01, 0xFF, 0xF7, 0x80, 0xFF, 0xFB,
  0xC0, 0xF7, 0xFD, 0xE0, 0x7B, 0xFE, 0x78, 0x3D, 0xFF, 0x3C, 0x1C, 0xFF,
  0x9E, 0x1E, 0x7F, 0xC7, 0x0F, 0x3F, 0xE3, 0xC7, 0x1F, 0xF1, 0xE7, 0x8F,
  0xF8, 0xF3, 0xC7, 0xFC, 0x3D, 0xE3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x83, 0xF8, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0, 0x7E,
  0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xE0, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xBC, 0x0F, 0xF7, 0xC1, 0xFE, 0xF8, 0x3F, 0xCF, 0x87, 0xF9, 0xF0,
  0xFF, 0x1E, 0x1F, 0xE3, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0xCF, 0xF0, 0x79,
  0xFE, 0x0F, 0xBF, 0xC0, 0xF7, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0x80, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xDF, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xDF,
  0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFF, 0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xDF, 0xC3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3,
  0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0x07, 0xE7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F,
  0x3C, 0x0F, 0x9E, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xC0, 0xF1, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC7,
  0x81, 0xE3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x03,
  0xE0, 0x00, 0x80, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0x81,
  0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0,
  0x3E, 0xFF, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF1, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0xF0, 0x0F,
  0x80, 0x7B, 0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0x7E, 0x03, 0xE7, 0x80, 0xFC,
  0x07, 0xCF, 0x81, 0xF8, 0x0F, 0x1F, 0x03, 0xF8, 0x1E, 0x1E, 0x0F, 0xF0,
  0x7C, 0x3C, 0x1E, 0xE0, 0xF8, 0x78, 0x3D, 0xC1, 0xE0, 0xF8, 0x7B, 0xC3,
  0xC1, 0xF0, 0xE7, 0x87, 0x81, 0xE3, 0xCF, 0x1F, 0x03, 0xC7, 0x9E, 0x3E,
  0x07, 0x8F, 0x1C, 0x78, 0x0F, 0x9E, 0x3C, 0xF0, 0x0F, 0x78, 0x79, 0xE0,
  0x1E, 0xF0, 0xF7, 0xC0, 0x3D, 0xE0, 0xEF, 0x80, 0x7B, 0xC1, 0xDE, 0x00,
  0xF7, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x7D, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF8,
  0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xEF, 0x00,
  0xF9, 0xF0, 0x1F, 0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x87,
  0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xF7, 0xC0, 0x3E, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x3C, 0xF0,
  0x1E, 0x3C, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E,
  0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x07, 0x07, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF1, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x01, 0xFE, 0x3F,
  0xFC, 0xFF, 0xFB, 0xF8, 0xF7, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x3E, 0xF8, 0xFD, 0xFF, 0xF9, 0xFE, 0x71, 0xF8, 0xE0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFF, 0x7E, 0xFF, 0xFE, 0xF3, 0xFC, 0xF1, 0xF8, 0x07, 0xE0, 0xFF, 0xCF,
  0xFC, 0xFF, 0xE7, 0xC1, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0B,
  0xF3, 0xDF, 0xFE, 0x7F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F,
  0x9F, 0x3F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7E, 0xFF, 0x7F,
  0xFF, 0x3F, 0xCF, 0x1F, 0x8F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7,
  0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x04, 0xFC, 0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x03, 0xF8, 0x3F,
  0xC3, 0xFC, 0x3F, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xE3,
  0xFF, 0x3F, 0xF9, 0xFF, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x8F, 0x3F,
  0xCF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7E, 0xFF, 0x7F, 0xFF, 0x3F,
  0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x40,
  0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x23, 0xFF, 0xF7, 0x90, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x0F, 0x1F, 0x1F, 0x0F, 0x04, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0,
  0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xF0,
  0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xF0, 0x3E,
  0x3C, 0xFF, 0x3F, 0xCF, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFC, 0x3F,
  0x8F, 0xBF, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8,
  0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78,
  0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0,
  0x78, 0x1F, 0xF8, 0x1E, 0x07, 0xC0, 0xF1, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7E, 0x7C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF1, 0xF0, 0xF3, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0x7E, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x3F, 0xCF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0xFE, 0x7F, 0xDF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x0F,
  0xC1, 0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0x81, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7E, 0xFF, 0x7F, 0xEF, 0x3F,
  0xEF, 0x1F, 0xCF, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xE7,
  0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x3E, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xF8, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7, 0x83, 0xF0, 0x3D, 0xE0, 0xFE,
  0x1F, 0x7C, 0x3F, 0x87, 0xCF, 0x0E, 0xE1, 0xE3, 0xC3, 0xB8, 0x78, 0xF1,
  0xEE, 0x1E, 0x3C, 0x7B, 0xCF, 0x8F, 0x9C, 0xF3, 0xC1, 0xE7, 0x1C, 0xF0,
  0x79, 0xC7, 0x3C, 0x1E, 0xF1, 0xDF, 0x07, 0xBC, 0x7F, 0x80, 0xFE, 0x1F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x78, 0x0F, 0xBE,
  0x0F, 0x8F, 0x07, 0xC7, 0xC7, 0xC1, 0xE3, 0xC0, 0xFB, 0xE0, 0x3D, 0xE0,
  0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x3E, 0xF8, 0x1E, 0x3C, 0x1F, 0x1F, 0x0F,
  0x07, 0xCF, 0x83, 0xEF, 0x80, 0xF8, 0xF8, 0x07, 0xFC, 0x07, 0xDE, 0x03,
  0xEF, 0x81, 0xE7, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0,
  0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0xFC,
  0x3F, 0x87, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x1F, 0x87, 0xF0, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x7F, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 12, 10, 16, 2, -27 },
  { 37, 19, 27, 20, 1, -27 },
  { 102, 15, 31, 19, 2, -29 },
  { 161, 27, 28, 29, 1, -28 },
  { 256, 22, 28, 22, 1, -28 },
  { 333, 5, 10, 9, 2, -27 },
  { 340, 9, 33, 12, 2, -27 },
  { 378, 9, 33, 12, 1, -27 },
  { 416, 15, 15, 18, 1, -29 },
  { 445, 16, 19, 19, 1, -23 },
  { 483, 7, 9, 10, 1, -4 },
  { 491, 9, 4, 11, 1, -12 },
  { 496, 6, 5, 10, 2, -5 },
  { 500, 15, 27, 15, 0, -27 },
  { 551, 16, 28, 18, 1, -28 },
  { 607, 11, 27, 18, 2, -27 },
  { 645, 16, 28, 18, 1, -28 },
  { 701, 16, 28, 18, 1, -28 },
  { 757, 17, 27, 18, 1, -27 },
  { 815, 15, 27, 18, 2, -27 },
  { 866, 16, 27, 18, 1, -27 },
  { 920, 16, 27, 18, 1, -27 },
  { 974, 16, 27, 18, 1, -27 },
  { 1028, 16, 27, 18, 1, -27 },
  { 1082, 6, 21, 10, 2, -21 },
  { 1098, 7, 26, 10, 1, -21 },
  { 1121, 16, 18, 19, 1, -23 },
  { 1157, 16, 11, 19, 1, -19 },
  { 1179, 16, 18, 19, 1, -23 },
  { 1215, 14, 28, 15, 0, -28 },
  { 1264, 25, 30, 29, 2, -27 },
  { 1358, 21, 27, 21, 0, -27 },
  { 1429, 16, 27, 21, 3, -27 },
  { 1483, 17, 28, 20, 2, -28 },
  { 1543, 18, 27, 23, 3, -27 },
  { 1604, 13, 27, 18, 3, -27 },
  { 1648, 13, 27, 17, 3, -27 },
  { 1692, 19, 28, 23, 2, -28 },
  { 1759, 18, 27, 24, 3, -27 },
  { 1820, 10, 27, 12, 1, -27 },
  { 1854, 9, 35, 10, -2, -27 },
  { 1894, 18, 27, 20, 3, -27 },
  { 1955, 13, 27, 17, 3, -27 },
  { 1999, 25, 27, 31, 3, -27 },
  { 2084, 19, 27, 25, 3, -27 },
  { 2149, 20, 28, 24, 2, -28 },
  { 2219, 15, 27, 20, 3, -27 },
  { 2270, 20, 34, 24, 2, -28 },
  { 2355, 17, 27, 20, 3, -27 },
  { 2413, 15, 28, 17, 1, -28 },
  { 2466, 16, 27, 17, 1, -27 },
  { 2520, 17, 27, 23, 3, -27 },
  { 2578, 20, 27, 20, 0, -27 },
  { 2646, 31, 27, 30, 0, -27 },
  { 2751, 19, 27, 19, 0, -27 },
  { 2816, 19, 27, 19, 0, -27 },
  { 2881, 15, 27, 17, 1, -27 },
  { 2932, 8, 33, 12, 3, -27 },
  { 2965, 15, 27, 15, 0, -27 },
  { 3016, 9, 33, 12, 1, -27 },
  { 3054, 18, 16, 20, 1, -27 },
  { 3090, 16, 3, 16, 0, 3 },
  { 3096, 8, 6, 12, 2, -29 },
  { 3102, 15, 21, 19, 1, -21 },
  { 3142, 16, 29, 20, 2, -29 },
  { 3200, 13, 21, 16, 2, -21 },
  { 3235, 16, 29, 20, 2, -29 },
  { 3293, 15, 21, 18, 2, -21 },
  { 3333, 13, 29, 12, 0, -29 },
  { 3381, 16, 30, 20, 2, -21 },
  { 3441, 16, 29, 20, 2, -29 },
  { 3499, 5, 29, 9, 2, -29 },
  { 3518, 8, 38, 9, -1, -29 },
  { 3556, 16, 29, 19, 3, -29 },
  { 3614, 5, 29, 9, 2, -29 },
  { 3633, 26, 21, 30, 2, -21 },
  { 3702, 16, 21, 20, 2, -21 },
  { 3744, 16, 21, 20, 2, -21 },
  { 3786, 16, 30, 20, 2, -21 },
  { 3846, 16, 30, 20, 2, -21 },
  { 3906, 11, 21, 14, 2, -21 },
  { 3935, 13, 21, 15, 1, -21 },
  { 3970, 11, 25, 13, 1, -25 },
  { 4005, 16, 21, 20, 2, -21 },
  { 4047, 17, 21, 17, 0, -21 },
  { 4092, 26, 21, 27, 0, -21 },
  { 4161, 17, 21, 17, 0, -21 },
  { 4206, 17, 30, 17, 0, -21 },
  { 4270, 13, 21, 15, 1, -21 },
  { 4305, 11, 33, 14, 1, -27 },
  { 4351, 4, 38, 18, 7, -29 },
  { 4370, 12, 33, 14, 1, -27 },
  { 4420, 16, 6, 19, 1, -16 },
};

const GFXfont NotoSans_Condensed_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD38PT7B_H_
