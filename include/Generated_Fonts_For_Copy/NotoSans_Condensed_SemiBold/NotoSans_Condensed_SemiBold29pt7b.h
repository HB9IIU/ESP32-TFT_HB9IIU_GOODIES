#ifndef _NOTOSANS_CONDENSED_SEMIBOLD29PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xFF, 0xE0,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3F, 0x1F, 0x8D, 0xC6, 0x0E, 0x30, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x18, 0xC3, 0xFF, 0xEF, 0xFF, 0x8E,
  0x70, 0x39, 0xC0, 0xC7, 0x03, 0x18, 0x0C, 0x60, 0x73, 0x80, 0x06, 0x00,
  0x60, 0x0F, 0x83, 0xFF, 0x7F, 0xE7, 0x66, 0xF6, 0x0F, 0x60, 0xF6, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7E, 0x06, 0xF0, 0x67, 0x86, 0x7E,
  0x6F, 0xFF, 0xEF, 0xFC, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x07,
  0x07, 0xE0, 0x60, 0x7E, 0x0E, 0x0E, 0x70, 0xE0, 0xE7, 0x1C, 0x0E, 0x71,
  0xC0, 0xE3, 0x18, 0x0E, 0x73, 0x80, 0xE7, 0x31, 0x8E, 0x77, 0x3E, 0x7F,
  0x77, 0xF7, 0xE6, 0x67, 0x3C, 0xEE, 0x30, 0x0C, 0xE3, 0x01, 0xCE, 0x30,
  0x18, 0xE3, 0x03, 0x8E, 0x30, 0x38, 0x67, 0x03, 0x07, 0x70, 0x70, 0x7E,
  0x0E, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x38, 0xE0, 0x78,
  0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x3B, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x0E, 0x7F, 0x8E, 0x73, 0x9E, 0xF3, 0xDE, 0xE1, 0xFC, 0xE0, 0xFC, 0xF0,
  0x78, 0xF0, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF,
  0x0E, 0x1C, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C,
  0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0xE1,
  0xC1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x78, 0x70, 0xE1, 0xC7,
  0x8F, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x1E, 0x38, 0xE1, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x0C, 0xE6, 0xFF, 0xEF, 0xFF, 0x0F, 0x01, 0xF0, 0x3B, 0x87,
  0x9C, 0x31, 0x81, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x7B, 0x9C, 0xEE, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0xEF, 0xFE, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0F, 0x00, 0x0F, 0x03, 0xFC, 0x3F, 0xC7, 0x9E, 0x70, 0xEF,
  0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0x70, 0xE7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80,
  0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x67, 0x47, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x07, 0xFC,
  0xFF, 0xE7, 0x1E, 0x40, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xFC, 0xFF, 0xE6, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F,
  0x80, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x6E, 0x03, 0xB8, 0x0C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1,
  0xC3, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7F, 0x87, 0xFC, 0x7F, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x07, 0xE0,
  0xFE, 0x1F, 0xE3, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE7, 0xCE,
  0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7,
  0x8F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xF7, 0x0F, 0x70,
  0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x1F, 0x83, 0xFC, 0x79, 0xEF, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE7, 0xFE, 0x3F, 0x80, 0x1F, 0x03,
  0xFC, 0x7F, 0xC7, 0x1E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF9, 0xF7, 0xF7, 0x3F, 0x70, 0xCF, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x3C, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xFE, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xCE,
  0x77, 0x39, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x1F,
  0x07, 0xC3, 0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x08, 0x00, 0x3F, 0x1F, 0xF1,
  0xFF, 0x30, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0xF0, 0x3C,
  0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x8F, 0x81, 0xE0, 0x3C,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0xFC, 0xE7, 0x1F, 0xC6, 0x63, 0x8C,
  0x66, 0x30, 0xC7, 0xE7, 0x0C, 0x7E, 0x71, 0xC7, 0xE7, 0x1C, 0x7E, 0x71,
  0xC6, 0xE3, 0x1C, 0x66, 0x3B, 0xFE, 0x61, 0xF7, 0xC7, 0x0C, 0x38, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x02, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x3F, 0xFD, 0xE3,
  0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xDE, 0x1E, 0xF1, 0xE7, 0xFE, 0x3F, 0xF1,
  0xFF, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBF,
  0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x7C, 0x23,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x4F, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x3C, 0x7C, 0xF0,
  0x7B, 0xC1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF0, 0x7B, 0xC7, 0xCF,
  0xFF, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xF0, 0x63, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC3, 0xFF, 0x87, 0xF7, 0x0F, 0xEE,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x3C, 0x7F, 0xF8, 0xFF,
  0xF0, 0x7F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x7C, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1E, 0xFE, 0xFC, 0xF8, 0xF0, 0x3F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x83, 0xCF, 0x0F, 0x1C, 0x3C, 0x78, 0xF0, 0xE3, 0xC3, 0xCF,
  0x07, 0x3C, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xDC, 0x0F, 0xFB, 0x83,
  0xBF, 0x70, 0x77, 0xEE, 0x0E, 0xFC, 0xE1, 0x9F, 0x9C, 0x73, 0xF3, 0x8E,
  0x7E, 0x39, 0xCF, 0xC7, 0x71, 0xF8, 0xEE, 0x3F, 0x1D, 0xC7, 0xE1, 0xF0,
  0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0x70, 0x7E, 0x0E, 0x0E, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFB, 0x83, 0xF7,
  0x87, 0xE7, 0x0F, 0xCF, 0x1F, 0x8E, 0x3F, 0x1E, 0x7E, 0x1C, 0xFC, 0x3D,
  0xF8, 0x3B, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E,
  0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x1E,
  0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xFF,
  0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3E,
  0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x0F,
  0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x07, 0xFE, 0x3F,
  0xF9, 0xE7, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x8F,
  0x3F, 0xF9, 0xFF, 0x0F, 0xF8, 0x79, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7,
  0x87, 0xBC, 0x3D, 0xE0, 0xFF, 0x07, 0x80, 0x1F, 0x87, 0xFD, 0xFF, 0xBC,
  0x6F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x3E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF8, 0x3F, 0xFF, 0x7F, 0xE7, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x39, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0,
  0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xE7, 0x81, 0xCF, 0x07, 0x8E,
  0x0F, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xE7,
  0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0xE0, 0x38, 0x0F, 0xE0, 0x70, 0x1F, 0xC0, 0xF0,
  0x7B, 0x83, 0xE0, 0xF7, 0x07, 0xC1, 0xCE, 0x0F, 0x83, 0x9E, 0x1B, 0x87,
  0x3C, 0x77, 0x1E, 0x38, 0xEE, 0x3C, 0x71, 0xDC, 0x70, 0xE3, 0x98, 0xE1,
  0xE6, 0x39, 0xC1, 0xDC, 0x77, 0x83, 0xB8, 0xEE, 0x07, 0x71, 0xDC, 0x0E,
  0xE1, 0xB8, 0x1D, 0x83, 0x70, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x3C, 0xF0, 0x78, 0xE1, 0xE1, 0xE3,
  0xC1, 0xC7, 0x03, 0x9E, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xB8, 0x0E, 0x78, 0x3C,
  0x70, 0x70, 0xF1, 0xE0, 0xE3, 0xC1, 0xEF, 0x03, 0xE0, 0xF0, 0x3F, 0xC0,
  0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x70, 0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1F,
  0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0xF0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x0E, 0xE0, 0x67, 0x07,
  0x1C, 0x38, 0xE3, 0x83, 0x9C, 0x1D, 0xC0, 0x7E, 0x03, 0x80, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x8F, 0xF8, 0xFF, 0x90, 0xF0, 0x0E, 0x01,
  0xC1, 0xF9, 0xFF, 0x7F, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xF7, 0xDF,
  0xF9, 0xF3, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7,
  0x8E, 0xFC, 0xFF, 0xEF, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0xFF, 0xEE, 0xFC, 0x0F,
  0xCF, 0xF3, 0xFD, 0xE1, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x5F, 0xF3, 0xFC, 0x7F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0x8F, 0x70, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0xF7,
  0xFF, 0x3F, 0xF1, 0xF3, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0x0E, 0x70, 0xFF,
  0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x17,
  0xEE, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7, 0xF1, 0xF8, 0xF0, 0x3C, 0x0F, 0x03,
  0xFB, 0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x33, 0xFF, 0x7F,
  0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x77, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00,
  0x74, 0x0F, 0x7F, 0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xF0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x71, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFE, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE1,
  0xCE, 0x3C, 0xE7, 0x8E, 0x70, 0xEE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xE3,
  0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x87, 0x9D, 0xFB, 0xFB, 0xFF, 0xFF,
  0xF8, 0xF8, 0xFF, 0x0F, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF,
  0x1E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0x0F, 0x81, 0xFF, 0x0F, 0xF8,
  0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1E, 0xE0, 0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0xE7, 0x8E, 0xFC,
  0xFF, 0xEF, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0xEF, 0xEE, 0x7C, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x33, 0xFF, 0x7F,
  0xF7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x77, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE7, 0xEF, 0xFF, 0xFD, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F,
  0x1F, 0xFF, 0xFB, 0x82, 0xE0, 0x3C, 0x07, 0xC1, 0xF8, 0x3F, 0x83, 0xE0,
  0x3C, 0x0F, 0x83, 0xFF, 0xEF, 0xFB, 0xFC, 0x18, 0x0C, 0x06, 0x07, 0xFF,
  0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0,
  0x78, 0x3F, 0x8F, 0xC7, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xFF,
  0xDF, 0xD9, 0xF3, 0xF0, 0x3F, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x87, 0x1C,
  0x78, 0xE3, 0x87, 0x1C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x80, 0xD8,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0xF0, 0xF0, 0x77, 0x0F, 0x07, 0x70, 0xF8,
  0xF7, 0x0F, 0x8E, 0x79, 0xF8, 0xE7, 0x9D, 0x8E, 0x39, 0xD9, 0xE3, 0x99,
  0xDC, 0x39, 0x9D, 0xC3, 0xF9, 0xDC, 0x1F, 0x8D, 0xC1, 0xF8, 0xDC, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0xF0, 0x7B, 0xC7,
  0x8E, 0x3C, 0x7B, 0xC1, 0xDC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0x70, 0x3B, 0x83, 0xDE, 0x1C, 0x79, 0xE3, 0xDE, 0x0F, 0xF0,
  0x3F, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x87, 0x1C, 0x78, 0xE3, 0x87, 0x9C,
  0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x07, 0xE0, 0x3E, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0x0F, 0x1F, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0xF0, 0xF0, 0x78, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x7C, 0x3E, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xE0, 0xF8, 0x7C,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF1, 0xF0, 0xF8,
  0x40, 0x00, 0x7E, 0x1F, 0xFF, 0xCF, 0xF8, 0x1E,
};

const GFXglyph NotoSans_Condensed_SemiBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 7, 2, -21 },
  { 12, 9, 8, 12, 2, -21 },
  { 21, 14, 21, 15, 1, -21 },
  { 58, 12, 24, 14, 1, -22 },
  { 94, 20, 21, 22, 1, -21 },
  { 147, 16, 21, 17, 1, -21 },
  { 189, 3, 8, 7, 2, -21 },
  { 192, 7, 26, 9, 1, -21 },
  { 215, 7, 26, 9, 1, -21 },
  { 238, 12, 12, 13, 1, -22 },
  { 256, 12, 14, 14, 1, -17 },
  { 277, 5, 7, 7, 1, -3 },
  { 282, 7, 3, 9, 1, -9 },
  { 285, 4, 4, 7, 2, -4 },
  { 287, 11, 21, 11, 0, -21 },
  { 316, 12, 21, 14, 1, -21 },
  { 348, 8, 21, 14, 2, -21 },
  { 369, 12, 21, 14, 1, -21 },
  { 401, 12, 21, 14, 1, -21 },
  { 433, 14, 21, 14, 0, -21 },
  { 470, 12, 21, 14, 1, -21 },
  { 502, 12, 21, 14, 1, -21 },
  { 534, 12, 21, 14, 1, -21 },
  { 566, 12, 21, 14, 1, -21 },
  { 598, 12, 21, 14, 1, -21 },
  { 630, 4, 16, 7, 2, -16 },
  { 638, 5, 20, 7, 1, -16 },
  { 651, 12, 14, 14, 1, -17 },
  { 672, 12, 8, 14, 1, -14 },
  { 684, 12, 14, 14, 1, -17 },
  { 705, 11, 21, 11, 0, -21 },
  { 734, 20, 23, 22, 1, -21 },
  { 792, 16, 21, 16, 0, -21 },
  { 834, 13, 21, 16, 2, -21 },
  { 869, 13, 21, 15, 1, -21 },
  { 904, 14, 21, 17, 2, -21 },
  { 941, 10, 21, 13, 2, -21 },
  { 968, 10, 21, 13, 2, -21 },
  { 995, 15, 21, 18, 1, -21 },
  { 1035, 14, 21, 18, 2, -21 },
  { 1072, 8, 21, 9, 1, -21 },
  { 1093, 8, 27, 8, -2, -21 },
  { 1120, 14, 21, 16, 2, -21 },
  { 1157, 10, 21, 13, 2, -21 },
  { 1184, 19, 21, 23, 2, -21 },
  { 1234, 15, 21, 19, 2, -21 },
  { 1274, 16, 21, 19, 1, -21 },
  { 1316, 12, 21, 15, 2, -21 },
  { 1348, 16, 26, 19, 1, -21 },
  { 1400, 13, 21, 16, 2, -21 },
  { 1435, 11, 21, 13, 1, -21 },
  { 1464, 13, 21, 13, 0, -21 },
  { 1499, 14, 21, 18, 2, -21 },
  { 1536, 15, 21, 15, 0, -21 },
  { 1576, 23, 21, 23, 0, -21 },
  { 1637, 15, 21, 15, 0, -21 },
  { 1677, 14, 21, 14, 0, -21 },
  { 1714, 11, 21, 13, 1, -21 },
  { 1743, 6, 26, 9, 2, -21 },
  { 1763, 11, 21, 11, 0, -21 },
  { 1792, 6, 26, 9, 1, -21 },
  { 1812, 13, 13, 15, 1, -21 },
  { 1834, 12, 1, 12, 0, 3 },
  { 1836, 7, 4, 9, 1, -22 },
  { 1840, 11, 16, 14, 1, -16 },
  { 1862, 12, 22, 15, 2, -22 },
  { 1895, 10, 16, 12, 1, -16 },
  { 1915, 12, 22, 15, 1, -22 },
  { 1948, 12, 16, 14, 1, -16 },
  { 1972, 10, 22, 9, 0, -22 },
  { 2000, 12, 23, 15, 1, -16 },
  { 2035, 12, 22, 15, 2, -22 },
  { 2068, 3, 22, 7, 2, -22 },
  { 2077, 6, 29, 7, -1, -22 },
  { 2099, 12, 22, 14, 2, -22 },
  { 2132, 3, 22, 7, 2, -22 },
  { 2141, 19, 16, 23, 2, -16 },
  { 2179, 12, 16, 15, 2, -16 },
  { 2203, 13, 16, 15, 1, -16 },
  { 2229, 12, 23, 15, 2, -16 },
  { 2264, 12, 23, 15, 1, -16 },
  { 2299, 8, 16, 11, 2, -16 },
  { 2315, 10, 16, 12, 1, -16 },
  { 2335, 9, 19, 10, 0, -19 },
  { 2357, 11, 16, 15, 2, -16 },
  { 2379, 13, 16, 13, 0, -16 },
  { 2405, 20, 16, 20, 0, -16 },
  { 2445, 13, 16, 13, 0, -16 },
  { 2471, 13, 23, 13, 0, -16 },
  { 2509, 9, 16, 11, 1, -16 },
  { 2527, 8, 26, 11, 1, -21 },
  { 2553, 3, 29, 13, 5, -22 },
  { 2564, 9, 26, 11, 1, -21 },
  { 2594, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_SemiBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD29PT7B_H_
