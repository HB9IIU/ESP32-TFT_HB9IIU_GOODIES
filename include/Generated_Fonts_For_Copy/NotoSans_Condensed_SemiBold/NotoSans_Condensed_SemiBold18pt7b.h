#ifndef _NOTOSANS_CONDENSED_SEMIBOLD18PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xC1, 0x7C, 0xDF, 0x3C, 0xF3, 0xC8, 0x19, 0x0D,
  0x86, 0xC2, 0x67, 0xF8, 0x90, 0xC8, 0x6C, 0xFF, 0x9B, 0x09, 0x84, 0x82,
  0x40, 0x10, 0x21, 0xFF, 0xED, 0x1A, 0x3C, 0x1E, 0x1E, 0x2C, 0x5F, 0xFF,
  0xC2, 0x04, 0x00, 0x70, 0xCF, 0x18, 0x99, 0x89, 0xB0, 0x9B, 0x09, 0xAE,
  0xF6, 0xF7, 0x5B, 0x0D, 0x90, 0xD9, 0x19, 0x91, 0x8B, 0x30, 0xE0, 0x38,
  0x1F, 0x06, 0xC1, 0xB0, 0x6C, 0x1E, 0x07, 0x9B, 0xE6, 0xCF, 0xB3, 0xCC,
  0x73, 0xFC, 0x7D, 0xC0, 0xFF, 0xC0, 0x36, 0x66, 0xCC, 0xCC, 0xCC, 0xCC,
  0x66, 0x63, 0xC3, 0x0C, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x63, 0x19, 0x98,
  0x30, 0x62, 0xD7, 0xF3, 0x0F, 0x33, 0x24, 0x10, 0x20, 0x40, 0x8F, 0xE2,
  0x04, 0x08, 0x10, 0xFB, 0x60, 0xFF, 0x5F, 0x00, 0x06, 0x08, 0x30, 0x61,
  0x83, 0x06, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x00, 0x78, 0xFB, 0x3E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3B, 0xE7, 0x80, 0x19, 0xDF, 0xB5, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x80, 0x79, 0xFA, 0x38, 0x30, 0xE1, 0x87, 0x0C,
  0x30, 0xC3, 0x87, 0xFF, 0xE0, 0x79, 0xFA, 0x38, 0x30, 0xCF, 0x9E, 0x06,
  0x06, 0x0C, 0x3F, 0xEF, 0x80, 0x06, 0x0E, 0x0E, 0x1E, 0x16, 0x36, 0x26,
  0x66, 0xC6, 0xFF, 0x06, 0x06, 0x06, 0xFD, 0xFB, 0x06, 0x0C, 0x1F, 0x3F,
  0x07, 0x06, 0x0C, 0x3F, 0xEF, 0x80, 0x3C, 0xF9, 0x86, 0x0C, 0x1F, 0xBB,
  0xE3, 0xC7, 0x8F, 0x1B, 0xE7, 0xC0, 0xFF, 0xFF, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x79, 0xFB, 0x1E, 0x3C, 0xEF,
  0x9E, 0x76, 0xC7, 0x8F, 0x1F, 0xF7, 0xC0, 0x79, 0xFB, 0x3E, 0x3C, 0x78,
  0xF3, 0xBF, 0x06, 0x0C, 0x37, 0xEF, 0x80, 0xDF, 0x00, 0x02, 0xF8, 0xDF,
  0x00, 0x00, 0xFB, 0x60, 0x02, 0x0C, 0x73, 0x8C, 0x1E, 0x0F, 0x07, 0x02,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0x83, 0xC0, 0xE0, 0x63, 0xDC, 0x60,
  0x80, 0x79, 0xFA, 0x38, 0x70, 0xC3, 0x8E, 0x18, 0x30, 0x00, 0x81, 0x83,
  0x00, 0x0F, 0x03, 0x9C, 0x60, 0x64, 0x22, 0xCF, 0xBD, 0x93, 0x99, 0x39,
  0x93, 0x99, 0x3D, 0xBE, 0xCE, 0xC4, 0x00, 0x60, 0x83, 0xF8, 0x1C, 0x07,
  0x81, 0xE0, 0x78, 0x36, 0x0C, 0xC3, 0x30, 0xCC, 0x7F, 0x9F, 0xE6, 0x1B,
  0x86, 0xC1, 0xC0, 0xFC, 0xFE, 0xE7, 0xE3, 0xE3, 0xFE, 0xFE, 0xE7, 0xE3,
  0xE3, 0xE3, 0xFF, 0xFC, 0x1E, 0x7F, 0x61, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0x60, 0x7E, 0x3E, 0xFC, 0x7F, 0x39, 0xDC, 0x7E, 0x3F, 0x0F,
  0x87, 0xC3, 0xE3, 0xF1, 0xB9, 0xDF, 0xCF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3,
  0xFF, 0xF8, 0xE3, 0x8E, 0x3F, 0xFC, 0xFF, 0xFE, 0x38, 0xE3, 0x8F, 0xFF,
  0xE3, 0x8E, 0x38, 0xE0, 0x1F, 0x1F, 0xDC, 0x5C, 0x0C, 0x06, 0x03, 0x1F,
  0x8F, 0xC1, 0xF0, 0xD8, 0x6F, 0xF3, 0xF8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x18, 0xFF, 0x66,
  0x66, 0x66, 0x66, 0x6F, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x98, 0xDE, 0xC0, 0xE3, 0xF3, 0xB9, 0x9D, 0xCF, 0xC7, 0xC3, 0xE1,
  0xD8, 0xEC, 0x73, 0x39, 0x9C, 0x6E, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xE0, 0x7F, 0x07, 0xF0, 0xFD,
  0x0F, 0xD8, 0xFD, 0x8B, 0xD9, 0xBC, 0x9B, 0xCD, 0x3C, 0xF3, 0xC7, 0x3C,
  0x63, 0xC6, 0x30, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xD8, 0xF7, 0x3C, 0xCF,
  0x3B, 0xC6, 0xF1, 0xFC, 0x3F, 0x0F, 0xC1, 0xC0, 0x3E, 0x1F, 0xC6, 0x3B,
  0x86, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0x66, 0x39, 0xFC, 0x3E,
  0x00, 0xFC, 0xFE, 0xE6, 0xE7, 0xE7, 0xE6, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x3E, 0x1F, 0xC6, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0x66, 0x39, 0xFC, 0x3E, 0x01, 0xC0, 0x30, 0x0E, 0xFC, 0x7F,
  0x39, 0xDC, 0xEE, 0x77, 0x33, 0xF9, 0xF8, 0xEC, 0x73, 0x39, 0x9C, 0xEE,
  0x38, 0x7F, 0xFB, 0x16, 0x0C, 0x1E, 0x1E, 0x0E, 0x0C, 0x1E, 0x37, 0xEF,
  0x80, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xC1, 0xE0, 0xD8, 0x6C, 0x76, 0x33, 0x18,
  0xCC, 0x6C, 0x36, 0x0B, 0x07, 0x83, 0x81, 0xC0, 0xC3, 0x0F, 0x0C, 0x3E,
  0x38, 0xD9, 0xE3, 0x67, 0x9D, 0x9A, 0x66, 0x6D, 0x8D, 0x36, 0x3C, 0xD8,
  0xF3, 0xC3, 0xC7, 0x0F, 0x1C, 0x18, 0x70, 0xE3, 0xB1, 0x9D, 0xC6, 0xC3,
  0x60, 0xE0, 0x70, 0x38, 0x36, 0x1B, 0x18, 0xCC, 0x6E, 0x38, 0xC3, 0xB1,
  0x98, 0xCE, 0xC3, 0x61, 0xB0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60,
  0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0xC1,
  0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x08, 0x0E, 0x07, 0x06,
  0xC3, 0x61, 0x19, 0x8D, 0x83, 0xFF, 0xC6, 0x30, 0xF8, 0xF8, 0x38, 0x37,
  0xFC, 0xF1, 0xE7, 0xFF, 0xEC, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE6,
  0xC7, 0xC3, 0xC3, 0xC3, 0xE6, 0xFE, 0xDC, 0x3D, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0xFD, 0xF0, 0x06, 0x0C, 0x18, 0x37, 0x6F, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3F, 0xEF, 0x40, 0x38, 0xFB, 0x1E, 0x3F, 0xFF, 0xF0, 0x60, 0x7E,
  0xFC, 0x1C, 0xF3, 0x1C, 0x7B, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0,
  0x72, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xFC, 0x18, 0x3E, 0xFF,
  0x80, 0xC1, 0x83, 0x06, 0x0D, 0xDF, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xC0, 0x7C, 0xFF, 0xFF, 0xF0, 0x13, 0x30, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xC6, 0xCC, 0xD8, 0xF8,
  0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xDC, 0xEF, 0xFF,
  0xE7, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xDD, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x38, 0x7E, 0xC6,
  0xC6, 0xC7, 0xC7, 0xC6, 0xC6, 0x7E, 0x7C, 0xDC, 0xFE, 0xE6, 0xC7, 0xC3,
  0xC3, 0xC3, 0xE6, 0xFE, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0x72, 0xFF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xFC, 0x18, 0x30, 0x60, 0xC0, 0xDF, 0xF9,
  0xCC, 0x63, 0x18, 0xC6, 0x00, 0x7F, 0xEC, 0x30, 0xF1, 0xE1, 0xC3, 0xFB,
  0xE0, 0x20, 0x87, 0xFF, 0x61, 0x86, 0x18, 0x61, 0x87, 0xCF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xF4, 0xC3, 0xE3, 0x66, 0x66, 0x66,
  0x36, 0x3C, 0x3C, 0x1C, 0x18, 0xC7, 0x3F, 0x39, 0x99, 0xCC, 0xDA, 0x66,
  0xD3, 0x36, 0xF0, 0xE7, 0x87, 0x3C, 0x38, 0xE1, 0xC6, 0x00, 0xE7, 0x66,
  0x76, 0x3C, 0x1C, 0x1C, 0x3C, 0x7E, 0x66, 0xE7, 0xC3, 0xE3, 0x66, 0x66,
  0x66, 0x36, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0xF0, 0xF0, 0x7D, 0xF0,
  0xC6, 0x18, 0xC3, 0x18, 0x7F, 0xF0, 0x0C, 0x73, 0x0C, 0x30, 0xC3, 0x3C,
  0xF0, 0xC3, 0x0C, 0x30, 0xC1, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7,
  0x18, 0xC6, 0x31, 0x87, 0x3B, 0x18, 0xC6, 0x33, 0x98, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_Condensed_SemiBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 6, 5, 8, 1, -13 },
  { 10, 9, 13, 10, 0, -13 },
  { 25, 7, 15, 9, 1, -14 },
  { 39, 12, 13, 14, 1, -13 },
  { 59, 10, 13, 11, 1, -13 },
  { 76, 2, 5, 4, 1, -13 },
  { 78, 4, 16, 6, 1, -13 },
  { 86, 5, 16, 6, 0, -13 },
  { 96, 7, 8, 8, 1, -14 },
  { 103, 7, 9, 9, 1, -11 },
  { 111, 3, 4, 5, 1, -2 },
  { 113, 4, 2, 5, 1, -6 },
  { 114, 3, 3, 5, 1, -3 },
  { 116, 7, 13, 7, 0, -13 },
  { 128, 7, 13, 9, 1, -13 },
  { 140, 5, 13, 9, 1, -13 },
  { 149, 7, 13, 9, 1, -13 },
  { 161, 7, 13, 9, 1, -13 },
  { 173, 8, 13, 9, 0, -13 },
  { 186, 7, 13, 9, 1, -13 },
  { 198, 7, 13, 9, 1, -13 },
  { 210, 8, 13, 9, 0, -13 },
  { 223, 7, 13, 9, 1, -13 },
  { 235, 7, 13, 9, 1, -13 },
  { 247, 3, 10, 5, 1, -10 },
  { 251, 3, 12, 5, 1, -10 },
  { 256, 7, 9, 9, 1, -11 },
  { 264, 7, 5, 9, 1, -9 },
  { 269, 7, 9, 9, 1, -11 },
  { 277, 7, 13, 7, 0, -13 },
  { 289, 12, 14, 14, 1, -13 },
  { 310, 10, 13, 10, 0, -13 },
  { 327, 8, 13, 10, 1, -13 },
  { 340, 8, 13, 9, 1, -13 },
  { 353, 9, 13, 11, 1, -13 },
  { 368, 6, 13, 8, 1, -13 },
  { 378, 6, 13, 8, 1, -13 },
  { 388, 9, 13, 11, 1, -13 },
  { 403, 9, 13, 11, 1, -13 },
  { 418, 4, 13, 6, 1, -13 },
  { 425, 5, 17, 5, -1, -13 },
  { 436, 9, 13, 10, 1, -13 },
  { 451, 7, 13, 8, 1, -13 },
  { 463, 12, 13, 14, 1, -13 },
  { 483, 10, 13, 12, 1, -13 },
  { 500, 10, 13, 12, 1, -13 },
  { 517, 8, 13, 9, 1, -13 },
  { 530, 10, 16, 12, 1, -13 },
  { 550, 9, 13, 10, 1, -13 },
  { 565, 7, 13, 8, 1, -13 },
  { 577, 8, 13, 8, 0, -13 },
  { 590, 9, 13, 11, 1, -13 },
  { 605, 9, 13, 9, 0, -13 },
  { 620, 14, 13, 14, 0, -13 },
  { 643, 9, 13, 9, 0, -13 },
  { 658, 9, 13, 9, 0, -13 },
  { 673, 8, 13, 8, 0, -13 },
  { 686, 4, 16, 6, 1, -13 },
  { 694, 7, 13, 7, 0, -13 },
  { 706, 5, 16, 6, 0, -13 },
  { 716, 9, 8, 9, 0, -13 },
  { 725, 8, 1, 8, 0, 2 },
  { 726, 4, 3, 6, 1, -14 },
  { 728, 7, 10, 9, 1, -10 },
  { 737, 8, 14, 10, 1, -14 },
  { 751, 6, 10, 8, 1, -10 },
  { 759, 7, 14, 10, 1, -14 },
  { 772, 7, 10, 9, 1, -10 },
  { 781, 6, 14, 6, 0, -14 },
  { 792, 7, 14, 10, 1, -10 },
  { 805, 7, 14, 10, 1, -14 },
  { 818, 2, 14, 4, 1, -14 },
  { 822, 4, 18, 4, -1, -14 },
  { 831, 8, 14, 9, 1, -14 },
  { 845, 2, 14, 4, 1, -14 },
  { 849, 12, 10, 14, 1, -10 },
  { 864, 7, 10, 10, 1, -10 },
  { 873, 8, 10, 9, 1, -10 },
  { 883, 8, 14, 10, 1, -10 },
  { 897, 7, 14, 10, 1, -10 },
  { 910, 5, 10, 7, 1, -10 },
  { 917, 6, 10, 7, 1, -10 },
  { 925, 6, 12, 6, 0, -12 },
  { 934, 7, 10, 10, 1, -10 },
  { 943, 8, 10, 8, 0, -10 },
  { 953, 13, 10, 13, 0, -10 },
  { 970, 8, 10, 8, 0, -10 },
  { 980, 8, 14, 8, 0, -10 },
  { 994, 6, 10, 7, 0, -10 },
  { 1002, 6, 16, 7, 0, -13 },
  { 1014, 2, 18, 8, 3, -14 },
  { 1019, 5, 16, 7, 1, -13 },
  { 1029, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_SemiBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD18PT7B_H_
