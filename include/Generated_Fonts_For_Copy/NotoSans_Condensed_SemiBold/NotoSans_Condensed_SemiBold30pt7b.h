#ifndef _NOTOSANS_CONDENSED_SEMIBOLD30PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x00, 0x0F, 0xFF, 0xF0,
  0xE7, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x06, 0x38, 0x38, 0xC0,
  0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xCF, 0xFF, 0xFF, 0xFF, 0x1C, 0x60,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x30,
  0x39, 0xC0, 0xE7, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0x80, 0x02, 0x00, 0x20,
  0x02, 0x01, 0xFF, 0x7F, 0xF7, 0xFE, 0xF2, 0x2F, 0x20, 0xF2, 0x07, 0xA0,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x02, 0xF0, 0x27, 0x02, 0x78, 0x27,
  0xE2, 0xFF, 0xFE, 0x7F, 0xC0, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x1C,
  0x00, 0x83, 0xF0, 0x38, 0x1F, 0xC1, 0xC1, 0xCE, 0x0C, 0x0E, 0x30, 0xE0,
  0x71, 0x86, 0x03, 0x8C, 0x70, 0x1C, 0x73, 0x80, 0xE3, 0x38, 0x07, 0x19,
  0xCF, 0x39, 0xCC, 0xFC, 0xFE, 0xEE, 0xF3, 0xE6, 0x73, 0x8C, 0x73, 0x9C,
  0x03, 0x9C, 0xE0, 0x38, 0xE7, 0x01, 0xC7, 0x38, 0x0C, 0x39, 0xC0, 0xE1,
  0xCE, 0x06, 0x0E, 0x70, 0x70, 0x3F, 0x03, 0x80, 0xF0, 0x07, 0x00, 0x0F,
  0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x73, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE1, 0xE7, 0xF8,
  0xF7, 0x9E, 0x73, 0xC7, 0xF9, 0xE1, 0xFC, 0xF0, 0xFC, 0x78, 0x3E, 0x3E,
  0x3F, 0x0F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFC, 0x7C, 0xFF, 0xFF, 0xF8, 0x07,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x07, 0xE1, 0xC1, 0xC3, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x3C, 0x78,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x3C, 0x71,
  0xE3, 0x80, 0x0F, 0x00, 0xE0, 0x06, 0x08, 0x61, 0xF6, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x1F, 0x83, 0x9C, 0x79, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7B, 0xDC, 0xE7,
  0x73, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xFF, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0x07, 0x01, 0xFC, 0x3F, 0xE7, 0xDE, 0x78,
  0xF7, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x0F, 0x78, 0xE3, 0xFE, 0x3F,
  0xC1, 0xF8, 0x07, 0x1F, 0x3F, 0x7F, 0xF7, 0xE7, 0x47, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x03, 0xFC, 0x7F, 0xEF, 0xBE, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xFC, 0xFF,
  0xE7, 0x1E, 0x40, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE1, 0xFC, 0x1F,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x81,
  0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x37, 0x83, 0xBC, 0x39, 0xE1, 0xCF, 0x1C, 0x78, 0xE3,
  0xCE, 0x1E, 0x70, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x20, 0x7F, 0xC7, 0xFE, 0x7F, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xEF, 0xFC, 0x7F, 0x80,
  0x01, 0xE0, 0x7F, 0x07, 0xF8, 0x7E, 0x23, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF3, 0x87, 0xFF, 0x3B, 0xF9, 0xF1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1,
  0xDE, 0x0F, 0xF0, 0x73, 0x83, 0x9E, 0x3C, 0x7F, 0xC3, 0xFE, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0x01, 0xFE, 0x1F, 0xF8, 0xF1, 0xE7, 0x0F, 0x38, 0x39, 0xC1, 0xCE, 0x1E,
  0x79, 0xE1, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x3C, 0x7B, 0xC3, 0xDC,
  0x0E, 0xE0, 0x7F, 0x03, 0xBC, 0x1C, 0xFF, 0xE7, 0xFE, 0x0F, 0xE0, 0x0F,
  0x03, 0xFC, 0x7F, 0xE7, 0xBE, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xF7, 0xFF, 0x7F, 0xF3, 0xF7, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE7, 0xFC, 0x7F, 0x87, 0xF0, 0x4F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x23, 0xDE, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0x73, 0x9D, 0xCE, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x1E, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x0E, 0x0F, 0xF3, 0xFF,
  0x39, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x80, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0xE0,
  0x3C, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x7C, 0x77, 0x1F, 0xE7, 0x71,
  0xCE, 0x76, 0x38, 0xE3, 0x63, 0x8E, 0x3E, 0x30, 0xE3, 0xE3, 0x0E, 0x3E,
  0x30, 0xE3, 0xE3, 0x0E, 0x7E, 0x39, 0xE7, 0x63, 0xFF, 0xE7, 0x1F, 0x7C,
  0x70, 0x61, 0x83, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x30, 0x0F, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C,
  0x3C, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x38, 0x1E, 0x78,
  0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF,
  0xBF, 0xFD, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0xFF, 0xF7,
  0xFE, 0x3F, 0xF9, 0xE3, 0xEF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x87, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0xF1,
  0xFF, 0x87, 0xCE, 0x3C, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x01, 0xDE,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x79, 0xE3, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3F,
  0xF1, 0xFF, 0xCF, 0xCF, 0x7C, 0x05, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1D, 0xE0, 0x77, 0xC1, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1C, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0xFE, 0xFE,
  0xF8, 0xF0, 0x3F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFB, 0xC3,
  0xCF, 0x0F, 0x1E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x1E,
  0xF0, 0x3C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xEE, 0x07, 0x7F, 0xE0, 0x77, 0xFE, 0x07,
  0xFF, 0x70, 0xEF, 0xF7, 0x0E, 0xFF, 0x70, 0xEF, 0xF7, 0x0E, 0xFF, 0x39,
  0xCF, 0xF3, 0x9C, 0xFF, 0x39, 0xCF, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1,
  0xF8, 0xFF, 0x1F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xEE, 0x0F,
  0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF,
  0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xEF, 0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x0E, 0x70,
  0x07, 0xB8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0x80, 0x3D,
  0xC0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x87, 0x83, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF,
  0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xC3, 0xC1, 0xE3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x07, 0xB8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x1E, 0x78,
  0x0F, 0x1E, 0x07, 0x8F, 0x87, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x73, 0xC1, 0xCF, 0x07, 0x3C,
  0x1C, 0xF0, 0xF3, 0xCF, 0x8F, 0xFE, 0x3F, 0xE0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x1E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x3C,
  0x07, 0x03, 0xFF, 0x7F, 0xE7, 0xFE, 0xF0, 0x2F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0xC1, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0, 0x0F, 0x70,
  0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0F,
  0x70, 0x3C, 0x0E, 0x70, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x38, 0x7E, 0x1C, 0x38, 0xE7, 0x1C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C,
  0x1C, 0xE7, 0x3C, 0x1D, 0xE7, 0x38, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x78, 0x3E, 0xF0, 0x78, 0xF1, 0xE1,
  0xE3, 0xC1, 0xE7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x0E, 0x38,
  0x3C, 0x78, 0x78, 0x71, 0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xE0, 0xF0, 0x1E,
  0xF0, 0x79, 0xE0, 0xF1, 0xC3, 0xC3, 0xC7, 0x87, 0x8E, 0x07, 0x3C, 0x0F,
  0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0xF8,
  0x03, 0xF0, 0x1D, 0xC0, 0x77, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0x71, 0xC1,
  0xC7, 0x03, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0xF0, 0xE0,
  0xE0, 0x02, 0x07, 0xFC, 0x3F, 0xE3, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF1,
  0xFF, 0x3F, 0xF7, 0xCF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFB, 0xF7,
  0xF7, 0x3E, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x84, 0x1D, 0xF8, 0xEF, 0xE7, 0xEF, 0xBC, 0x3D, 0xE0, 0xEF, 0x07,
  0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xBC, 0x1D, 0xE1, 0xEF,
  0xFF, 0x77, 0xF3, 0x9F, 0x00, 0x03, 0x03, 0xFC, 0xFF, 0x3E, 0x67, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0,
  0x5F, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x11, 0xE3, 0xEF, 0x3F, 0xBB, 0xEF, 0xDE, 0x1E, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1E,
  0xF0, 0xF7, 0xFF, 0x9F, 0xDC, 0x7C, 0xE0, 0x02, 0x01, 0xFC, 0x3F, 0xE7,
  0x8F, 0x70, 0x77, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x81, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0x07, 0xC7, 0xF1,
  0xFC, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x06, 0x00, 0xF9, 0xCF, 0xEE, 0xFB, 0xF7, 0x87, 0xB8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xBC,
  0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF4, 0x0F,
  0x3F, 0xF9, 0xFF, 0x87, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE1, 0x0E, 0xFC, 0xEF, 0xEF, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0x4E, 0xFE, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xE0, 0x08, 0x38, 0x78, 0xE0, 0x00, 0x00, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x77, 0xEF, 0xDF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1E, 0xE1, 0xE7, 0x0E, 0x38,
  0xF1, 0xCF, 0x0E, 0x70, 0x77, 0x03, 0xFC, 0x1F, 0xF0, 0xF3, 0x87, 0x1E,
  0x38, 0x71, 0xC3, 0xCE, 0x0E, 0x70, 0x7B, 0x81, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x03, 0x8E, 0xFC, 0xFE, 0xFF,
  0xEF, 0xEF, 0xFF, 0xDF, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFE,
  0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F,
  0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0,
  0xF0, 0x01, 0x0E, 0xFC, 0xEF, 0xEF, 0xDF, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x02, 0x00, 0xFE, 0x0F, 0xF8, 0xF9, 0xE7, 0x87, 0xB8,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xF7, 0x07,
  0xBC, 0x38, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x01, 0x07, 0x7E, 0x3B, 0xF9,
  0xF3, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE0, 0xEF, 0x07, 0x78, 0x7B, 0xFF, 0xDD, 0xFC, 0xE7, 0xC7, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x00,
  0xF9, 0xCF, 0xEE, 0xFB, 0xF7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF,
  0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x01, 0xF3, 0xBB, 0xDF, 0xEF, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x04, 0x0F, 0xF7,
  0xFF, 0xC6, 0xE0, 0x3C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x87,
  0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0xC7, 0xE1, 0xF0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF1, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x9E,
  0x1C, 0x78, 0x70, 0xE3, 0xC3, 0x8F, 0x0F, 0x38, 0x1C, 0xE0, 0x77, 0x81,
  0xDC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0xF0, 0xF8,
  0x7B, 0x87, 0xC3, 0x9C, 0x3E, 0x1C, 0xF1, 0xB0, 0xE7, 0x8D, 0xCF, 0x1C,
  0xEE, 0x78, 0xE7, 0x73, 0x87, 0x39, 0x9C, 0x3D, 0x8C, 0xE0, 0xEC, 0x7F,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x83, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0xF8, 0x7B, 0xC7, 0x8F, 0x3C, 0x79, 0xC1, 0xFE,
  0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3B, 0xC3,
  0xCE, 0x1C, 0x79, 0xE1, 0xFE, 0x0F, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x9E,
  0x1C, 0x38, 0x70, 0xE3, 0xC3, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x81,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0x8F, 0xC7, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x1F, 0x0E, 0x07, 0xC0, 0xF0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3F, 0x0F, 0x80,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x83, 0xF0, 0x78, 0x7C, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xF1, 0xF8, 0xF8, 0x60, 0x00, 0x38, 0x0F, 0xF8, 0xFF, 0xFF,
  0x0F, 0xE8, 0x0E, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 7, 13, 2, -21 },
  { 20, 14, 21, 16, 1, -21 },
  { 57, 12, 25, 15, 1, -23 },
  { 95, 21, 22, 23, 1, -22 },
  { 153, 17, 22, 18, 1, -22 },
  { 200, 3, 7, 7, 2, -21 },
  { 203, 8, 27, 9, 1, -22 },
  { 230, 7, 27, 9, 1, -22 },
  { 254, 12, 12, 14, 1, -23 },
  { 272, 13, 15, 15, 1, -18 },
  { 297, 5, 7, 8, 1, -3 },
  { 302, 7, 4, 9, 1, -10 },
  { 306, 4, 4, 8, 2, -4 },
  { 308, 12, 22, 12, 0, -22 },
  { 341, 12, 22, 15, 1, -22 },
  { 374, 8, 21, 15, 2, -21 },
  { 395, 12, 22, 15, 1, -22 },
  { 428, 12, 22, 15, 1, -22 },
  { 461, 13, 21, 15, 1, -21 },
  { 496, 12, 21, 15, 1, -21 },
  { 528, 13, 22, 15, 1, -22 },
  { 564, 13, 21, 15, 1, -21 },
  { 599, 13, 22, 15, 1, -22 },
  { 635, 12, 22, 15, 1, -22 },
  { 668, 4, 17, 8, 2, -17 },
  { 677, 5, 21, 8, 1, -17 },
  { 691, 13, 14, 15, 1, -18 },
  { 714, 13, 9, 15, 1, -15 },
  { 729, 13, 14, 15, 1, -18 },
  { 752, 11, 22, 11, 0, -22 },
  { 783, 20, 24, 23, 1, -22 },
  { 843, 16, 21, 17, 0, -21 },
  { 885, 13, 21, 17, 2, -21 },
  { 920, 14, 22, 16, 1, -22 },
  { 959, 15, 21, 18, 2, -21 },
  { 999, 10, 21, 14, 2, -21 },
  { 1026, 10, 21, 14, 2, -21 },
  { 1053, 14, 22, 18, 2, -22 },
  { 1092, 14, 21, 19, 2, -21 },
  { 1129, 8, 21, 10, 1, -21 },
  { 1150, 8, 27, 8, -2, -21 },
  { 1177, 14, 21, 16, 2, -21 },
  { 1214, 11, 21, 13, 2, -21 },
  { 1243, 20, 21, 24, 2, -21 },
  { 1296, 16, 21, 20, 2, -21 },
  { 1338, 17, 22, 19, 1, -22 },
  { 1385, 12, 21, 15, 2, -21 },
  { 1417, 17, 27, 19, 1, -22 },
  { 1475, 14, 21, 16, 2, -21 },
  { 1512, 12, 22, 14, 1, -22 },
  { 1545, 13, 21, 14, 0, -21 },
  { 1580, 14, 21, 18, 2, -21 },
  { 1617, 16, 21, 16, 0, -21 },
  { 1659, 24, 21, 24, 0, -21 },
  { 1722, 15, 21, 15, 0, -21 },
  { 1762, 15, 21, 15, 0, -21 },
  { 1802, 12, 21, 13, 1, -21 },
  { 1834, 7, 27, 10, 2, -22 },
  { 1858, 12, 22, 12, 0, -22 },
  { 1891, 7, 27, 10, 1, -22 },
  { 1915, 14, 12, 16, 1, -21 },
  { 1936, 13, 2, 13, 0, 3 },
  { 1940, 7, 5, 9, 1, -23 },
  { 1945, 12, 17, 15, 1, -17 },
  { 1971, 13, 23, 16, 2, -23 },
  { 2009, 11, 17, 13, 1, -17 },
  { 2033, 13, 23, 16, 1, -23 },
  { 2071, 12, 17, 15, 1, -17 },
  { 2097, 10, 23, 9, 0, -23 },
  { 2126, 13, 24, 16, 1, -17 },
  { 2165, 12, 23, 16, 2, -23 },
  { 2200, 4, 23, 7, 2, -23 },
  { 2212, 7, 30, 7, -1, -23 },
  { 2239, 13, 23, 15, 2, -23 },
  { 2277, 3, 23, 7, 2, -23 },
  { 2286, 20, 17, 24, 2, -17 },
  { 2329, 12, 17, 16, 2, -17 },
  { 2355, 13, 17, 15, 1, -17 },
  { 2383, 13, 24, 16, 2, -17 },
  { 2422, 13, 24, 16, 1, -17 },
  { 2461, 9, 17, 11, 2, -17 },
  { 2481, 10, 17, 12, 1, -17 },
  { 2503, 9, 20, 10, 0, -20 },
  { 2526, 12, 16, 16, 2, -16 },
  { 2550, 14, 16, 14, 0, -16 },
  { 2578, 21, 16, 21, 0, -16 },
  { 2620, 13, 16, 14, 0, -16 },
  { 2646, 14, 23, 14, 0, -16 },
  { 2687, 10, 16, 11, 1, -16 },
  { 2707, 9, 26, 11, 1, -21 },
  { 2737, 3, 30, 14, 5, -23 },
  { 2749, 9, 26, 11, 1, -21 },
  { 2779, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD30PT7B_H_
