#ifndef _NOTOSANS_CONDENSED_SEMIBOLD28PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xEE, 0xFE, 0xE7,
  0xF3, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0x9C, 0x0E, 0x70, 0x73, 0x03, 0x18,
  0x18, 0xC0, 0xC6, 0x06, 0x73, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x31, 0x8F, 0xFF, 0xFF, 0xFC, 0xE6, 0x06, 0x30, 0x31, 0x81, 0x8C,
  0x0C, 0xE0, 0xE7, 0x00, 0x06, 0x00, 0xC0, 0x7F, 0x1F, 0xF7, 0xFF, 0xEC,
  0x79, 0x87, 0x30, 0x76, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x0D, 0xC1,
  0xB8, 0x37, 0xC6, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3C, 0x06, 0x07, 0xE0, 0xE0, 0xE6, 0x0C, 0x0E, 0x71, 0xC0, 0xE7, 0x18,
  0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x73, 0x00, 0xE7, 0x77, 0xCE, 0x66,
  0x7E, 0x7E, 0xEE, 0x63, 0xCC, 0xE6, 0x01, 0xCC, 0x70, 0x1C, 0xC7, 0x01,
  0x8C, 0x70, 0x38, 0xC7, 0x03, 0x0E, 0x60, 0x70, 0xE6, 0x06, 0x07, 0xE0,
  0xE0, 0x3C, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x79, 0xC0, 0x71, 0xC0,
  0x39, 0xC0, 0x39, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x7F, 0x1E,
  0x77, 0x9C, 0xF3, 0xDC, 0xE1, 0xFC, 0xE1, 0xF8, 0xE0, 0xF8, 0xF0, 0xF8,
  0xFF, 0xFC, 0x7F, 0xDC, 0x3F, 0x9F, 0xFF, 0xFF, 0xF8, 0x0E, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x70,
  0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x07, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCE, 0x39, 0xC7, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x77, 0x7F, 0xFF, 0xFF, 0xC7, 0xC1, 0xD8, 0x3B,
  0x8E, 0x38, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x7B, 0x9C, 0xEE, 0x73, 0x80, 0xFF, 0xFF, 0xF8, 0xEE, 0xFE, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x78, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xC7, 0x1E, 0x70, 0xEF, 0x0E,
  0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEF, 0x0E,
  0xF0, 0xE7, 0x0E, 0x71, 0xE7, 0xFC, 0x3F, 0xC1, 0xF8, 0x07, 0x1F, 0x3F,
  0x7F, 0xF7, 0xEF, 0x4F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x3F, 0x8F, 0xFB, 0xFF, 0x30, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x9F, 0xF9,
  0xFF, 0xA0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x3F, 0x87, 0xC0, 0xFF,
  0x01, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0x7F,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3B,
  0x81, 0x9C, 0x1C, 0xE0, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xCF,
  0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xB0, 0x7F, 0x8F, 0xF8,
  0x8F, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x81, 0xFF, 0xFB, 0xFF,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x3F, 0xC3, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x78, 0xEF, 0xCF, 0xFE, 0xF1, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0,
  0xF7, 0x0E, 0x70, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x1F, 0x87, 0xFC, 0x79, 0xE7, 0x0E, 0xF0, 0xE7, 0x0E, 0x71,
  0xE7, 0xBC, 0x3F, 0x81, 0xF0, 0x3F, 0x87, 0xBC, 0xF1, 0xEE, 0x0E, 0xE0,
  0xFE, 0x0F, 0xF0, 0xEF, 0x9E, 0x7F, 0xC3, 0xF8, 0x1F, 0x0F, 0xF1, 0xFF,
  0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0xBF,
  0xF1, 0xEE, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xCF, 0xF1, 0xFE, 0x3F, 0x00,
  0xEF, 0xEE, 0x00, 0x00, 0x00, 0x0E, 0xEF, 0xE0, 0x73, 0xDC, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xB9, 0xCE, 0xE7, 0x38, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x07, 0xE1, 0xF8, 0x7C, 0x0F, 0x00, 0xC0,
  0x08, 0x00, 0x3F, 0x3F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0x01, 0xE0, 0x70, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0E, 0x01,
  0xC3, 0x80, 0x1C, 0xE1, 0xF1, 0x9C, 0x7F, 0x3B, 0x1C, 0xE7, 0x63, 0x1C,
  0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x71, 0xCF, 0xCE, 0x39,
  0xB8, 0xEF, 0x73, 0x1F, 0x7C, 0x71, 0xC7, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x03, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x71, 0xE1, 0xE1, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF,
  0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x70, 0xFF, 0x8F,
  0xFE, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF,
  0xF8, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF,
  0xFE, 0xFF, 0xEF, 0xF8, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x78, 0x27, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x09, 0xFF, 0x87, 0xFC, 0x0F,
  0xE0, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xEE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x0E, 0xE1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xEF,
  0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x02, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0x70, 0x1D, 0xC0,
  0x77, 0x81, 0xDE, 0x07, 0x3C, 0x1C, 0xFF, 0xF1, 0xFF, 0xC1, 0xFE, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xFF, 0xFD, 0xF1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xFB,
  0xFF, 0xF0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE7, 0xFF, 0xFC,
  0xE0, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xC3, 0xCE, 0x3C, 0x71, 0xE3, 0x9E,
  0x1C, 0xE0, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0x38, 0x71, 0xE3,
  0x87, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D, 0xC0, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFB, 0x03,
  0xFE, 0xE0, 0xFF, 0xB8, 0x77, 0xEE, 0x1D, 0xF9, 0xC7, 0x7E, 0x71, 0x9F,
  0x9C, 0xE7, 0xE3, 0x39, 0xF8, 0xEC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1,
  0xF1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x83, 0x87, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7E, 0xE1, 0xFB, 0xC7, 0xE7, 0x1F,
  0x9E, 0x7E, 0x39, 0xF8, 0xF7, 0xE1, 0xDF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF,
  0x1F, 0xFB, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC,
  0x7F, 0xFF, 0x7F, 0xCF, 0xC1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78,
  0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x3C,
  0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xCE,
  0x0E, 0x70, 0x7B, 0x83, 0xDC, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE1, 0xE7, 0x07, 0xB8, 0x3D,
  0xC0, 0xF0, 0x1F, 0xCF, 0xFD, 0xFF, 0x78, 0x2F, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0xC1, 0xFF, 0xFB, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x0F, 0xF0, 0x7B, 0xFF, 0x8F, 0xF8, 0x3F, 0x80, 0xE0, 0x1F, 0xE0,
  0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x3C,
  0x38, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xE0,
  0x38, 0x1F, 0xE0, 0xF0, 0x3B, 0xC1, 0xE0, 0x73, 0x83, 0xC1, 0xE7, 0x07,
  0xC3, 0xCE, 0x1F, 0x87, 0x1E, 0x3F, 0x0E, 0x1C, 0x76, 0x1C, 0x38, 0xEE,
  0x78, 0x71, 0x9C, 0xE0, 0xE7, 0x39, 0xC1, 0xEE, 0x73, 0x81, 0xDC, 0x67,
  0x03, 0xB8, 0xFE, 0x07, 0x61, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3D, 0xE1,
  0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0x80, 0xFE, 0x03, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x0F,
  0x3C, 0x38, 0x71, 0xE1, 0xE7, 0x03, 0xBC, 0x0F, 0xF0, 0x3D, 0xC0, 0xE7,
  0x87, 0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0x81, 0xCE, 0x07, 0x78, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0xFF, 0xF1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x7F, 0xFF, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x01, 0xF8, 0x0C,
  0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x3F, 0x8F, 0xF8, 0xC7, 0x80, 0xF0, 0x0E,
  0x01, 0xCF, 0xFB, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFF, 0x3E, 0xFD,
  0xDF, 0xB8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF,
  0x8F, 0xFC, 0xF9, 0xEF, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0E, 0xE0, 0xEF, 0x0E, 0xFF, 0xEF, 0xFC, 0xEF, 0x80, 0x1F, 0xCF,
  0xF7, 0x89, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xC0, 0x7D, 0xCF, 0xF1, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x3F, 0x77, 0xFF, 0x79, 0xF7, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0x0F, 0x7F, 0xF3, 0xFF, 0x1F,
  0x70, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7F, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0xCE, 0x7F, 0xC7, 0xF0, 0x0F, 0xC7,
  0xE3, 0xC8, 0xF0, 0x3C, 0x0F, 0x07, 0xF3, 0xFC, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x3F, 0x73, 0xFF, 0x79, 0xF7, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0x0F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x61, 0xE7, 0xFE, 0x7F, 0xC1, 0xF0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xF7, 0xFE, 0xF9, 0xFE, 0x3F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0E, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C,
  0x71, 0xC6, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3F, 0xFF, 0x98, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x78, 0xE7,
  0x0E, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0E, 0x78, 0xE3, 0x8E, 0x3C, 0xE1,
  0xCE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xEF, 0x9F, 0xBF, 0xF7, 0xFF, 0xBF, 0xBF, 0xC7, 0x87, 0xE1, 0xE1, 0xF8,
  0x38, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E,
  0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1C, 0xEF, 0xDF,
  0xFB, 0xEF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0x1F, 0xC3, 0xFE, 0x79, 0xE7,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77,
  0x0F, 0x7D, 0xE3, 0xFC, 0x1F, 0x80, 0xEF, 0x8F, 0xFC, 0xF9, 0xEF, 0x0E,
  0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEF, 0x1E,
  0xFF, 0xEF, 0xFC, 0xEF, 0x8E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x3F, 0x73, 0xFF, 0x79, 0xF7, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xF7, 0x0F, 0x7F, 0xF3, 0xF7,
  0x1E, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0xCF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x3F, 0xBF, 0xFC, 0x5C, 0x0E, 0x07, 0xC1, 0xF8, 0x7E,
  0x0F, 0x83, 0xC0, 0xF0, 0x7F, 0xFF, 0xFB, 0xF8, 0x18, 0x0C, 0x0E, 0x0F,
  0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x7F, 0x1F, 0x8F, 0xC0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFF, 0xFE, 0xFF,
  0xCF, 0xB8, 0xF0, 0x7B, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0x8E, 0x1C, 0x70,
  0xE3, 0x87, 0x38, 0x1D, 0xC0, 0xEE, 0x07, 0x60, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x00, 0xF0, 0xF0, 0xF7, 0x0F, 0x0E, 0x71, 0xF0, 0xE7, 0x1F,
  0x1E, 0x71, 0xB9, 0xC3, 0x9B, 0x9C, 0x39, 0x99, 0xC3, 0xB9, 0x9C, 0x3B,
  0x9F, 0x81, 0xB9, 0xF8, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF7, 0x8E, 0x39, 0xE3, 0xDC, 0x1F,
  0xC1, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xFC, 0x1D, 0xC3, 0x9E, 0x38,
  0xE7, 0x0F, 0xF0, 0x70, 0xF0, 0x7B, 0x83, 0x9C, 0x1C, 0xF1, 0xE3, 0x8E,
  0x1C, 0x70, 0xE3, 0x87, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xF8,
  0x07, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78,
  0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0x1F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0xF8, 0xF0, 0xF8, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x3E, 0x07,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x01, 0xF0, 0xF8, 0xFC,
  0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC3, 0xE1, 0xE0, 0x78,
  0x1F, 0xF7, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_Condensed_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 20, 7, 2, -20 },
  { 11, 9, 7, 12, 2, -20 },
  { 19, 13, 20, 15, 1, -20 },
  { 52, 11, 23, 14, 1, -21 },
  { 84, 20, 20, 22, 1, -20 },
  { 134, 16, 20, 17, 1, -20 },
  { 174, 3, 7, 7, 2, -20 },
  { 177, 7, 24, 9, 1, -20 },
  { 198, 6, 24, 9, 1, -20 },
  { 216, 11, 11, 13, 1, -21 },
  { 232, 12, 14, 14, 1, -17 },
  { 253, 5, 7, 7, 1, -3 },
  { 258, 7, 3, 8, 1, -9 },
  { 261, 4, 4, 7, 2, -4 },
  { 263, 11, 20, 11, 0, -20 },
  { 291, 12, 20, 14, 1, -20 },
  { 321, 8, 20, 14, 2, -20 },
  { 341, 11, 20, 14, 1, -20 },
  { 369, 11, 20, 14, 1, -20 },
  { 397, 13, 20, 14, 0, -20 },
  { 430, 11, 20, 14, 1, -20 },
  { 458, 12, 20, 14, 1, -20 },
  { 488, 12, 20, 14, 1, -20 },
  { 518, 12, 20, 14, 1, -20 },
  { 548, 11, 20, 14, 1, -20 },
  { 576, 4, 15, 7, 2, -15 },
  { 584, 5, 19, 7, 1, -15 },
  { 596, 12, 14, 14, 1, -17 },
  { 617, 12, 8, 14, 1, -14 },
  { 629, 12, 14, 14, 1, -17 },
  { 650, 10, 20, 11, 0, -20 },
  { 675, 19, 22, 21, 1, -20 },
  { 728, 15, 20, 15, 0, -20 },
  { 766, 12, 20, 15, 2, -20 },
  { 796, 13, 20, 15, 1, -20 },
  { 829, 13, 20, 17, 2, -20 },
  { 862, 10, 20, 13, 2, -20 },
  { 887, 10, 20, 13, 2, -20 },
  { 912, 14, 20, 17, 1, -20 },
  { 947, 13, 20, 17, 2, -20 },
  { 980, 7, 20, 9, 1, -20 },
  { 998, 7, 26, 8, -2, -20 },
  { 1021, 13, 20, 15, 2, -20 },
  { 1054, 10, 20, 12, 2, -20 },
  { 1079, 18, 20, 23, 2, -20 },
  { 1124, 14, 20, 19, 2, -20 },
  { 1159, 16, 20, 18, 1, -20 },
  { 1199, 11, 20, 14, 2, -20 },
  { 1227, 16, 25, 18, 1, -20 },
  { 1277, 13, 20, 15, 2, -20 },
  { 1310, 11, 20, 13, 1, -20 },
  { 1338, 12, 20, 13, 0, -20 },
  { 1368, 13, 20, 17, 2, -20 },
  { 1401, 15, 20, 15, 0, -20 },
  { 1439, 23, 20, 22, 0, -20 },
  { 1497, 14, 20, 14, 0, -20 },
  { 1532, 14, 20, 14, 0, -20 },
  { 1567, 11, 20, 13, 1, -20 },
  { 1595, 6, 24, 9, 2, -20 },
  { 1613, 11, 20, 11, 0, -20 },
  { 1641, 6, 24, 9, 1, -20 },
  { 1659, 13, 12, 15, 1, -20 },
  { 1679, 12, 2, 12, 0, 2 },
  { 1682, 6, 4, 9, 1, -21 },
  { 1685, 11, 15, 14, 1, -15 },
  { 1706, 12, 21, 15, 2, -21 },
  { 1738, 10, 15, 12, 1, -15 },
  { 1757, 12, 21, 15, 1, -21 },
  { 1789, 11, 15, 14, 1, -15 },
  { 1810, 10, 21, 9, 0, -21 },
  { 1837, 12, 22, 15, 1, -15 },
  { 1870, 11, 21, 15, 2, -21 },
  { 1899, 3, 21, 7, 2, -21 },
  { 1907, 6, 28, 7, -1, -21 },
  { 1928, 12, 21, 14, 2, -21 },
  { 1960, 3, 21, 7, 2, -21 },
  { 1968, 18, 15, 22, 2, -15 },
  { 2002, 11, 15, 15, 2, -15 },
  { 2023, 12, 15, 14, 1, -15 },
  { 2046, 12, 22, 15, 2, -15 },
  { 2079, 12, 22, 15, 1, -15 },
  { 2112, 8, 15, 10, 2, -15 },
  { 2127, 9, 15, 11, 1, -15 },
  { 2144, 9, 18, 9, 0, -18 },
  { 2165, 11, 15, 15, 2, -15 },
  { 2186, 13, 15, 13, 0, -15 },
  { 2211, 20, 15, 20, 0, -15 },
  { 2249, 12, 15, 13, 0, -15 },
  { 2272, 13, 22, 13, 0, -15 },
  { 2308, 9, 15, 11, 1, -15 },
  { 2325, 8, 24, 10, 1, -20 },
  { 2349, 3, 28, 13, 5, -21 },
  { 2360, 9, 24, 10, 1, -20 },
  { 2387, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD28PT7B_H_
