#ifndef _NOTOSANS_CONDENSED_SEMIBOLD26PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x06, 0x7F, 0x70, 0xF7,
  0xF9, 0xDC, 0xEC, 0x76, 0x33, 0x19, 0x8C, 0x0C, 0x60, 0xCE, 0x0C, 0xC1,
  0xCC, 0x1C, 0xC1, 0x8C, 0xFF, 0xFF, 0xFF, 0x19, 0xC1, 0x98, 0x39, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x73, 0x00,
  0x04, 0x00, 0x80, 0x3C, 0x1F, 0xE7, 0xFD, 0xC8, 0xB9, 0x07, 0x20, 0x74,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7C, 0x09, 0xC1, 0x3C, 0x2E, 0xFF, 0xDF,
  0xF0, 0x78, 0x02, 0x00, 0x40, 0x08, 0x00, 0x38, 0x0C, 0x1F, 0x07, 0x0E,
  0xE1, 0x83, 0x98, 0xE0, 0xC6, 0x30, 0x31, 0x8C, 0x0C, 0x67, 0x03, 0x19,
  0x80, 0xE6, 0xEF, 0xBB, 0xB3, 0xE7, 0xCD, 0xDC, 0xE6, 0x63, 0x01, 0x98,
  0xC0, 0xE6, 0x30, 0x31, 0x8C, 0x1C, 0x63, 0x06, 0x1D, 0xC1, 0x83, 0xE0,
  0xC0, 0x78, 0x0E, 0x00, 0xFE, 0x03, 0xF8, 0x1C, 0x70, 0x71, 0xC1, 0xC6,
  0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x77, 0xF3, 0xFD, 0xCE, 0xE3,
  0xBB, 0x87, 0xEE, 0x1F, 0x38, 0x3C, 0xFB, 0xF1, 0xFF, 0xE3, 0xF3, 0xC0,
  0xFF, 0x76, 0x66, 0x60, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x87,
  0x00, 0xC3, 0x87, 0x1C, 0x38, 0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x18, 0xE3, 0x8C, 0x71, 0x8E, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x33,
  0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x73, 0x9C, 0xE1, 0x20, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x77, 0x7E, 0xEE, 0xFF, 0xF0, 0x67, 0xF7, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0xF1,
  0xFE, 0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0x77, 0x0F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFE, 0x1D, 0xC3, 0xB8, 0x73, 0x8E, 0x7B, 0xC7, 0xF0, 0x7C, 0x00,
  0x0E, 0x3C, 0xFB, 0xFF, 0xFD, 0xD3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x1E, 0x0F, 0xF3, 0xFE, 0x31, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x1F, 0xF3, 0xFF,
  0x20, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x3F, 0x07, 0xE0, 0xFE, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0xE7, 0xDF, 0xF3, 0xFC, 0x00, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0D, 0xC1, 0xDC, 0x19,
  0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0x61, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xB8, 0x7F, 0x9F, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07,
  0xE7, 0xFF, 0xE7, 0xF0, 0x07, 0xC3, 0xF8, 0xFF, 0x3C, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x78, 0xFF, 0x9F, 0xFB, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3B, 0x8E, 0x7B, 0xC7, 0xF0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x1E, 0x07,
  0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xC3, 0x9C, 0x73, 0xDC, 0x3F, 0x03, 0xE1,
  0xFE, 0x39, 0xEE, 0x1D, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xCF, 0xF8, 0xFC,
  0x00, 0x1E, 0x07, 0xE1, 0xFE, 0x79, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0F,
  0xE1, 0xFE, 0x7D, 0xFB, 0x9F, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x4F,
  0x8F, 0xE1, 0xF8, 0x00, 0x7F, 0x76, 0x00, 0x00, 0x00, 0x67, 0xF7, 0x77,
  0x72, 0x00, 0x00, 0x00, 0x07, 0x77, 0xEE, 0xE0, 0x00, 0x20, 0x0C, 0x07,
  0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x18, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x1F,
  0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x1E, 0x7F, 0x9F, 0xE8, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x03, 0x81, 0x80, 0x00, 0x00,
  0x30, 0x3C, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x01, 0xE1, 0xE0,
  0x70, 0x1C, 0x30, 0x03, 0x1C, 0x3C, 0xE6, 0x3F, 0x99, 0x9C, 0xE6, 0xE7,
  0x39, 0xB9, 0x8E, 0x7C, 0x63, 0x9B, 0x18, 0xE6, 0xC6, 0x39, 0xB9, 0xCE,
  0x6E, 0x7F, 0xF1, 0x8F, 0x38, 0x70, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0xC0,
  0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3B, 0x01, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0xC3, 0x87,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x3F, 0xC0,
  0x7F, 0x01, 0xC0, 0xF8, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8,
  0x7F, 0x0E, 0xFF, 0x9F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xC1, 0xFF, 0x3F, 0xE3, 0xC2,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0xF8,
  0x0F, 0xF8, 0xFF, 0xCE, 0x3E, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00,
  0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0x27, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xF7, 0x03, 0xB8, 0x1D, 0xC0,
  0xEF, 0x07, 0x3E, 0x78, 0xFF, 0xC3, 0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0xFF, 0xFD, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x39, 0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF,
  0xFF, 0x7C, 0xE0, 0xFE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x78, 0xE7,
  0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xE7, 0x8E, 0x38, 0xE3,
  0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x6F, 0xD8, 0x77, 0xEE, 0x3B,
  0xF7, 0x19, 0xF9, 0x8C, 0xFC, 0xCE, 0x7E, 0x77, 0x3F, 0x3B, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC7, 0xE3, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xE0, 0xF0, 0x3F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xB8, 0xFD, 0xC7, 0xEF,
  0x3F, 0x39, 0xF9, 0xEF, 0xC7, 0x7E, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xF8, 0x1E, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x78, 0x3D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x03, 0xDE, 0x0E, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0xF8, 0x1F, 0xF3, 0xFF, 0x71, 0xEE, 0x1D, 0xC3, 0xB8,
  0x7F, 0x0E, 0xE1, 0xDD, 0xFB, 0xFE, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E,
  0x1E, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x03, 0xDE, 0x0E, 0x3F, 0xF8,
  0x7F, 0xC0, 0xFE, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFC,
  0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE1, 0xCE, 0x1E, 0xE1, 0xEE, 0x1C, 0xE3,
  0xCF, 0xF8, 0xFF, 0x0F, 0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1,
  0xEE, 0x0E, 0xE0, 0xF0, 0x1F, 0x0F, 0xF7, 0xFB, 0xC2, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x0F,
  0xFF, 0xBF, 0xEF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE7, 0xFE,
  0x3F, 0x80, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1D,
  0xC0, 0x37, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x1C, 0xE1, 0xE0, 0xE7, 0x0F,
  0x87, 0x38, 0x6C, 0x39, 0xC3, 0x61, 0xCE, 0x3B, 0x1C, 0x39, 0xDC, 0xE1,
  0xCE, 0xE7, 0x0E, 0x67, 0x38, 0x73, 0x1B, 0xC1, 0xB8, 0xDC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xE0, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0x71, 0xC3, 0xCE, 0x0E, 0xE0,
  0x77, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0E,
  0xE0, 0xE3, 0x87, 0x1C, 0x78, 0xF3, 0x83, 0xBC, 0x1E, 0xE0, 0x7F, 0x83,
  0x9C, 0x1C, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0x18,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0xFF, 0xFF,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1F, 0xFF, 0xC0, 0x04, 0x00, 0xE0, 0x0E, 0x01, 0xF0, 0x1B, 0x03,
  0xB8, 0x39, 0x87, 0x1C, 0x70, 0xC6, 0x0E, 0xE0, 0x6C, 0x07, 0xFF, 0xFF,
  0xFC, 0xF1, 0xC3, 0x87, 0x3F, 0x9F, 0xE2, 0x3C, 0x07, 0x01, 0xC3, 0xF7,
  0xFF, 0xE7, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xFF, 0xDF, 0x30, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7, 0xFC, 0xF3, 0xDC, 0x3B,
  0x87, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0x0E, 0xE1, 0xDE, 0x7B, 0xFE,
  0x67, 0x80, 0x1F, 0x9F, 0xDE, 0x4E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x1C, 0x0F, 0x33, 0xF8, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xCF, 0xBB, 0xFF, 0x79, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xEF, 0x3D, 0xFF, 0x9F, 0x70, 0x1F, 0x07,
  0xF1, 0xC7, 0x38, 0xEE, 0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x63, 0xFC, 0x3F, 0x80, 0x0F, 0x0F, 0xCF, 0xC7, 0x03, 0x81,
  0xC1, 0xFD, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3E, 0xEF, 0xFD, 0xE7, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xBD, 0xF7, 0xFE, 0x7D,
  0xC0, 0x38, 0x07, 0x00, 0xEC, 0x79, 0xFF, 0x3F, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0xFB, 0xFE, 0xF3, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x5F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x71, 0xC6, 0x00, 0x01, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xEF,
  0xFB, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x77,
  0x1C, 0xE7, 0x9C, 0xE3, 0xB8, 0x7E, 0x0F, 0xE1, 0xFC, 0x3D, 0xC7, 0x38,
  0xE3, 0x9C, 0x73, 0x87, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xDF, 0x9F, 0x6F, 0xDF, 0xBC, 0xF9, 0xFC, 0x38, 0x7E, 0x1C,
  0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1C, 0xCF, 0xB7, 0xFF, 0x3F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x70, 0x1F, 0x87, 0xF9, 0xE7, 0x38, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1D, 0xC3, 0xBC, 0xE3, 0xFC, 0x3F, 0x00, 0xCF, 0x9B,
  0xF3, 0xCF, 0x70, 0xEE, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3B,
  0x87, 0x7D, 0xEF, 0xF9, 0xDE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x3E, 0xEF, 0xFD, 0xE7, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xBD, 0xF7, 0xFE, 0x7D, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xCF, 0xBF, 0xFF, 0x8E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x7F, 0x7F, 0xB8, 0x5C, 0x0E,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x03, 0xC0, 0xF9, 0xEF, 0xF7, 0xF0, 0x18,
  0x38, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3D, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xDF, 0xFF, 0xDF, 0x30, 0xE0, 0xF7,
  0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x1B, 0x81,
  0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xE1, 0xDC, 0x78, 0x77,
  0x1E, 0x1D, 0xC7, 0xCE, 0x73, 0xB3, 0x8C, 0xEC, 0xE3, 0xB3, 0x38, 0xEC,
  0xDC, 0x3B, 0x3F, 0x0E, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x80, 0xF0, 0xE7, 0x1E, 0x39, 0xC3, 0xB8, 0x1F, 0x81, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC3, 0x9C, 0x70, 0xEF, 0x0F,
  0xE0, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0B, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0x02, 0x3C, 0x79, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0x73, 0xE7, 0x8F, 0x07, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0xC3, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1E, 0x0F,
  0x1F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF0, 0x78,
  0x3F, 0xFF, 0x3F, 0xC1, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 19, 7, 1, -19 },
  { 11, 9, 7, 11, 1, -19 },
  { 19, 12, 19, 14, 1, -19 },
  { 48, 11, 22, 13, 1, -20 },
  { 79, 18, 19, 20, 1, -19 },
  { 122, 14, 19, 15, 1, -19 },
  { 156, 4, 7, 6, 1, -19 },
  { 160, 7, 23, 8, 1, -19 },
  { 181, 6, 23, 8, 1, -19 },
  { 199, 10, 11, 12, 1, -20 },
  { 213, 11, 12, 13, 1, -15 },
  { 230, 4, 6, 7, 1, -3 },
  { 233, 6, 2, 8, 1, -8 },
  { 235, 4, 4, 7, 1, -4 },
  { 237, 10, 19, 10, 0, -19 },
  { 261, 11, 19, 13, 1, -19 },
  { 288, 7, 19, 13, 2, -19 },
  { 305, 11, 19, 13, 1, -19 },
  { 332, 11, 19, 13, 1, -19 },
  { 359, 12, 19, 13, 0, -19 },
  { 388, 10, 19, 13, 1, -19 },
  { 412, 11, 19, 13, 1, -19 },
  { 439, 11, 19, 13, 1, -19 },
  { 466, 11, 19, 13, 1, -19 },
  { 493, 11, 19, 13, 1, -19 },
  { 520, 4, 14, 7, 1, -14 },
  { 527, 4, 17, 7, 1, -14 },
  { 536, 11, 13, 13, 1, -16 },
  { 554, 11, 8, 13, 1, -13 },
  { 565, 11, 13, 13, 1, -16 },
  { 583, 9, 19, 10, 0, -19 },
  { 605, 18, 21, 20, 1, -19 },
  { 653, 14, 19, 14, 0, -19 },
  { 687, 11, 19, 14, 2, -19 },
  { 714, 12, 19, 14, 1, -19 },
  { 743, 12, 19, 16, 2, -19 },
  { 772, 9, 19, 12, 2, -19 },
  { 794, 9, 19, 12, 2, -19 },
  { 816, 13, 19, 16, 1, -19 },
  { 847, 12, 19, 16, 2, -19 },
  { 876, 7, 19, 8, 1, -19 },
  { 893, 7, 24, 7, -2, -19 },
  { 914, 12, 19, 14, 2, -19 },
  { 943, 9, 19, 11, 2, -19 },
  { 965, 17, 19, 21, 2, -19 },
  { 1006, 13, 19, 17, 2, -19 },
  { 1037, 14, 19, 17, 1, -19 },
  { 1071, 11, 19, 13, 2, -19 },
  { 1098, 14, 23, 17, 1, -19 },
  { 1139, 12, 19, 14, 2, -19 },
  { 1168, 10, 19, 12, 1, -19 },
  { 1192, 12, 19, 12, 0, -19 },
  { 1221, 12, 19, 16, 2, -19 },
  { 1250, 14, 19, 14, 0, -19 },
  { 1284, 21, 19, 21, 0, -19 },
  { 1334, 13, 19, 13, 0, -19 },
  { 1365, 13, 19, 13, 0, -19 },
  { 1396, 10, 19, 12, 1, -19 },
  { 1420, 6, 23, 8, 2, -19 },
  { 1438, 10, 19, 10, 0, -19 },
  { 1462, 6, 23, 8, 1, -19 },
  { 1480, 12, 12, 14, 1, -19 },
  { 1498, 11, 2, 11, 0, 2 },
  { 1501, 6, 4, 8, 1, -20 },
  { 1504, 10, 14, 13, 1, -14 },
  { 1522, 11, 20, 14, 2, -20 },
  { 1550, 9, 14, 11, 1, -14 },
  { 1566, 11, 20, 14, 1, -20 },
  { 1594, 11, 14, 13, 1, -14 },
  { 1614, 9, 20, 8, 0, -20 },
  { 1637, 11, 20, 14, 1, -14 },
  { 1665, 10, 20, 14, 2, -20 },
  { 1690, 3, 20, 6, 2, -20 },
  { 1698, 6, 26, 6, -1, -20 },
  { 1718, 11, 20, 13, 2, -20 },
  { 1746, 3, 20, 6, 2, -20 },
  { 1754, 17, 14, 21, 2, -14 },
  { 1784, 10, 14, 14, 2, -14 },
  { 1802, 11, 14, 13, 1, -14 },
  { 1822, 11, 20, 14, 2, -14 },
  { 1850, 11, 20, 14, 1, -14 },
  { 1878, 7, 14, 9, 2, -14 },
  { 1891, 9, 14, 10, 1, -14 },
  { 1907, 8, 17, 9, 0, -17 },
  { 1924, 10, 14, 14, 2, -14 },
  { 1942, 12, 14, 12, 0, -14 },
  { 1963, 18, 14, 18, 0, -14 },
  { 1995, 12, 14, 12, 0, -14 },
  { 2016, 12, 20, 12, 0, -14 },
  { 2046, 8, 14, 10, 1, -14 },
  { 2060, 7, 23, 9, 1, -19 },
  { 2081, 2, 26, 12, 5, -20 },
  { 2088, 8, 23, 9, 1, -19 },
  { 2111, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD26PT7B_H_
