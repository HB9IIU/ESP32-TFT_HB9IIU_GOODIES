#ifndef _NOTOSANS_CONDENSED_SEMIBOLD45PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF,
  0xFE, 0x20, 0xFC, 0x7E, 0xF8, 0xFD, 0xF1, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF,
  0x87, 0x9F, 0x0F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC1,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x83, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xE1,
  0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0xC0,
  0x0F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0xC3, 0x3E,
  0x30, 0x0F, 0x8C, 0x03, 0xE3, 0x00, 0xF8, 0xC0, 0x3F, 0x30, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x33, 0xF0, 0x0C, 0x7C, 0x03, 0x1F, 0x00, 0xC7, 0xE0,
  0x31, 0xFC, 0x0C, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xC7, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0xFF,
  0x00, 0x7C, 0x03, 0xFF, 0x00, 0xF0, 0x0F, 0x9E, 0x01, 0xE0, 0x1E, 0x3E,
  0x07, 0x80, 0x3C, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x3C, 0x00, 0xF0, 0xF0,
  0x78, 0x01, 0xE1, 0xE1, 0xF0, 0x03, 0xC3, 0xC3, 0xC0, 0x07, 0x87, 0x87,
  0x80, 0x0F, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0xF1,
  0xFC, 0x78, 0x79, 0xE7, 0xFC, 0x79, 0xE7, 0xCF, 0xFC, 0xFF, 0xCF, 0x3E,
  0x78, 0xFF, 0x1E, 0x78, 0x78, 0xFC, 0x78, 0xF0, 0xF0, 0x60, 0xF1, 0xE1,
  0xE0, 0x03, 0xC3, 0xC3, 0xC0, 0x07, 0x87, 0x87, 0x80, 0x0F, 0x0F, 0x0F,
  0x00, 0x3C, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x3C, 0x01, 0xE0, 0x78, 0x78,
  0x03, 0xC0, 0xF0, 0xF0, 0x0F, 0x81, 0xE3, 0xE0, 0x1E, 0x01, 0xE7, 0x80,
  0x3C, 0x03, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x87, 0xFE, 0x07, 0xC3, 0xFF, 0xC1,
  0xF0, 0xFD, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x07, 0xCF, 0x87, 0xC1,
  0xFF, 0xE3, 0xF0, 0x3F, 0xF0, 0xFC, 0x07, 0xFC, 0x3F, 0x00, 0xFE, 0x07,
  0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0xFC, 0x07, 0xFC, 0x1F, 0xC0, 0xFD,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x80, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x38, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xBC, 0x03, 0xCF, 0x81, 0xF1, 0xF0, 0xFC, 0x7E, 0x0E, 0x0E, 0x00, 0x82,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78,
  0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE2, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF9, 0xF0, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8,
  0x7E, 0x7F, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFD, 0xFB,
  0xFF, 0xBF, 0xF9, 0xFB, 0x8F, 0xC8, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0xE7, 0x01, 0xF8, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0xFE,
  0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1E, 0x0F, 0xE2, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0xE0,
  0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3C, 0xF8,
  0x03, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x38, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE8, 0x01, 0xFB, 0xC1, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x30,
  0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF8, 0x3E, 0x7F, 0x1F,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xE0, 0x3F, 0x7C, 0x07, 0xEF,
  0x80, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF0, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0x8F, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x3F, 0x1F,
  0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xF0, 0x3F, 0x7E,
  0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFD, 0xF0, 0xFF, 0x3E, 0x03,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC2, 0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x38, 0xF9, 0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0x3E, 0x7C, 0xFB, 0xE7,
  0xCF, 0x9E, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF8, 0x7F, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x78, 0x3F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x07, 0xF0, 0x78, 0xF0,
  0x7F, 0xF1, 0xE7, 0x83, 0xFF, 0xC7, 0x9E, 0x0F, 0x9F, 0x0F, 0x78, 0x7C,
  0x3C, 0x3D, 0xE1, 0xE0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3, 0xFC, 0x3C, 0x1F,
  0x0F, 0xF0, 0xF0, 0x7C, 0x3F, 0xC3, 0xC1, 0xF0, 0xFF, 0x0F, 0x07, 0x83,
  0xFC, 0x3C, 0x1E, 0x0F, 0xF0, 0xF0, 0x78, 0x3F, 0xC3, 0xC1, 0xE1, 0xEF,
  0x0F, 0x8F, 0xC7, 0xBC, 0x1F, 0x7F, 0xFC, 0x78, 0x7F, 0xDF, 0xF1, 0xE0,
  0xFE, 0x3F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x03, 0xF8, 0x03,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xF3, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x3F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x1E, 0x1F, 0x80, 0x23, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x02, 0x1F, 0xF1, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0xCF, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xC1, 0xE1, 0xFC, 0x00, 0x8F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7C,
  0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xE0, 0x1F, 0x1F, 0xF0, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0xFF, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xF0,
  0x03, 0xDF, 0xFB, 0xC0, 0x0F, 0x7F, 0xEF, 0x80, 0x7D, 0xFF, 0xBE, 0x01,
  0xF7, 0xFE, 0x78, 0x07, 0x9F, 0xF9, 0xF0, 0x1E, 0x7F, 0xE7, 0xC0, 0xF9,
  0xFF, 0x8F, 0x03, 0xC7, 0xFE, 0x3C, 0x0F, 0x1F, 0xF8, 0xF8, 0x7C, 0x7F,
  0xE3, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0x87, 0xFE, 0x1F, 0x3E, 0x1F, 0xF8,
  0x7C, 0xF8, 0x7F, 0xE0, 0xF3, 0xC1, 0xFF, 0x83, 0xCF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x81, 0xFE,
  0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01,
  0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xE0, 0x3F, 0xF7, 0xE0,
  0x7F, 0xE7, 0xC0, 0xFF, 0xCF, 0xC1, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0x87,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x3E, 0x3F, 0xF0, 0x7C, 0x7F,
  0xE0, 0xFC, 0xFF, 0xC0, 0xF9, 0xFF, 0x81, 0xF9, 0xFF, 0x01, 0xF3, 0xFE,
  0x03, 0xF7, 0xFC, 0x03, 0xEF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x1F, 0xBF, 0x07, 0xF7,
  0xE7, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xCF, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E,
  0x07, 0xE3, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3,
  0xF8, 0xFB, 0xF0, 0x09, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x03,
  0xEF, 0xCF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x80, 0xFC, 0xFF, 0x0F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x01,
  0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7E, 0x03, 0xFC, 0x07, 0xE3,
  0xE0, 0x3F, 0xC0, 0x7E, 0x3E, 0x03, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0xE0,
  0x7C, 0x3E, 0x07, 0xFE, 0x07, 0xC3, 0xF0, 0x79, 0xE0, 0xFC, 0x1F, 0x07,
  0x9E, 0x0F, 0x81, 0xF0, 0x79, 0xE0, 0xF8, 0x1F, 0x0F, 0x9F, 0x0F, 0x81,
  0xF0, 0xF9, 0xF0, 0xF8, 0x1F, 0x8F, 0x0F, 0x1F, 0x80, 0xF8, 0xF0, 0xF1,
  0xF0, 0x0F, 0x9F, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F,
  0x0F, 0x9F, 0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00,
  0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xE1, 0xF8,
  0x07, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xF0, 0x07, 0xE3,
  0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F,
  0x83, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7F,
  0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xEF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x7C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x3C,
  0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xC0,
  0x07, 0xFE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xE3, 0xF0, 0x80, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0xFB, 0xFE, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFD, 0xFF, 0xDE, 0xFF, 0xCF,
  0x3F, 0xC7, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x0F, 0x03, 0xE7, 0xF8, 0x7D, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0xFD,
  0xFC, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFB, 0xFF, 0x1E, 0x3F, 0xC0,
  0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x04,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x01, 0x7F, 0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x7C, 0x3F, 0xCF, 0x8F, 0xFD, 0xF3, 0xFF, 0xBE, 0xFF, 0xFF, 0xDF,
  0x83, 0xFB, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xE0, 0xFE, 0xFC,
  0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xDF, 0x1F, 0xFB, 0xE1, 0xFC, 0x3C, 0x01,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x83,
  0xE7, 0xC0, 0xFB, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x02, 0x7F, 0x01, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC7, 0xFE, 0x1F, 0x88, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x07, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x01, 0xFE,
  0x7C, 0x7F, 0xEF, 0x9F, 0xFD, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBE, 0x07, 0xF7, 0xE1, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFE, 0xF8, 0xFF, 0x9F, 0x0F, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x98, 0x03, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0x0F, 0x9F, 0xE3, 0xEF,
  0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0x77, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0xFF, 0xFF,
  0xBF, 0xDF, 0xCF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0,
  0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xE7,
  0xC0, 0x7D, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFC, 0xFC, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0x83,
  0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7C, 0x07, 0xC3, 0xC7, 0xF8, 0x7F, 0x8F, 0x3F, 0xF3, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF8, 0x7F, 0x83, 0xFF, 0xC0, 0xFC,
  0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01,
  0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8,
  0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03,
  0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC,
  0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x3C,
  0x7F, 0x8F, 0x3F, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0xFD, 0xF0, 0x1F, 0xBF, 0x03, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x78, 0x1E, 0x3F, 0xC3, 0xEF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFB, 0xF0, 0x1F, 0x7E, 0x07, 0xEF, 0xF1, 0xFD, 0xFF, 0xFF, 0x3E, 0xFF,
  0xE7, 0xDF, 0xF8, 0xF8, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFE,
  0x7C, 0x7F, 0xEF, 0x9F, 0xFD, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBE, 0x07, 0xF7, 0xE1, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFE, 0xF8, 0xFF, 0x9F, 0x0F, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F,
  0x8F, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xEB, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7,
  0x9F, 0x01, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xEE, 0x0F, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8,
  0x7F, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x47, 0xFE, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0x3C, 0x7F, 0x0F, 0xFC, 0x01, 0xF7,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x7D,
  0xF0, 0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0xF8, 0x0F, 0xC0, 0x7D, 0xF0, 0x3F, 0x80, 0xFB, 0xE0, 0x7F, 0x83,
  0xE3, 0xE0, 0xFF, 0x07, 0xC7, 0xC1, 0xFE, 0x0F, 0x8F, 0x87, 0xBC, 0x1F,
  0x1F, 0x0F, 0x38, 0x7C, 0x3F, 0x1E, 0x78, 0xF8, 0x3E, 0x3C, 0xF1, 0xF0,
  0x7C, 0x79, 0xE3, 0xE0, 0xF9, 0xE3, 0xC7, 0xC1, 0xF3, 0xC3, 0xDF, 0x01,
  0xF7, 0x87, 0xBE, 0x03, 0xEF, 0x0F, 0x7C, 0x07, 0xDE, 0x1E, 0xF8, 0x0F,
  0xB8, 0x3D, 0xE0, 0x0F, 0xF0, 0x7B, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF3, 0xE0, 0x7E, 0x3F,
  0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0xDF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xDF,
  0x00, 0xF9, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xC3, 0xE0,
  0x7E, 0x7E, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xDE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x83, 0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x00,
  0x3F, 0x80, 0x17, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xEC, 0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 33, 12, 3, -32 },
  { 26, 15, 11, 19, 2, -32 },
  { 47, 22, 32, 24, 1, -32 },
  { 135, 18, 37, 22, 2, -34 },
  { 219, 31, 33, 35, 2, -33 },
  { 347, 26, 33, 27, 1, -33 },
  { 455, 6, 11, 10, 2, -32 },
  { 464, 11, 39, 14, 2, -32 },
  { 518, 11, 39, 14, 1, -32 },
  { 572, 18, 18, 21, 1, -34 },
  { 613, 18, 22, 22, 2, -27 },
  { 663, 8, 11, 11, 1, -5 },
  { 674, 11, 4, 14, 1, -14 },
  { 680, 6, 7, 11, 3, -6 },
  { 686, 17, 32, 18, 0, -32 },
  { 754, 18, 33, 22, 2, -33 },
  { 829, 13, 32, 22, 3, -32 },
  { 881, 18, 33, 22, 2, -33 },
  { 956, 18, 33, 22, 2, -33 },
  { 1031, 20, 32, 22, 1, -32 },
  { 1111, 18, 32, 22, 2, -32 },
  { 1183, 18, 33, 22, 2, -33 },
  { 1258, 19, 32, 22, 1, -32 },
  { 1334, 19, 33, 22, 1, -33 },
  { 1413, 19, 33, 22, 1, -33 },
  { 1492, 6, 26, 12, 3, -25 },
  { 1512, 7, 31, 12, 2, -25 },
  { 1540, 19, 22, 22, 1, -27 },
  { 1593, 18, 13, 22, 2, -22 },
  { 1623, 18, 22, 22, 2, -27 },
  { 1673, 16, 34, 17, 0, -33 },
  { 1741, 30, 36, 34, 2, -32 },
  { 1876, 25, 32, 25, 0, -32 },
  { 1976, 20, 32, 25, 3, -32 },
  { 2056, 20, 33, 23, 2, -33 },
  { 2139, 22, 32, 27, 3, -32 },
  { 2227, 16, 32, 21, 3, -32 },
  { 2291, 16, 32, 20, 3, -32 },
  { 2355, 22, 33, 27, 2, -33 },
  { 2446, 22, 32, 28, 3, -32 },
  { 2534, 12, 32, 15, 1, -32 },
  { 2582, 12, 41, 12, -3, -32 },
  { 2644, 21, 32, 24, 3, -32 },
  { 2728, 16, 32, 20, 3, -32 },
  { 2792, 30, 32, 36, 3, -32 },
  { 2912, 23, 32, 30, 3, -32 },
  { 3004, 25, 33, 29, 2, -33 },
  { 3108, 19, 32, 23, 3, -32 },
  { 3184, 25, 41, 29, 2, -33 },
  { 3313, 21, 32, 24, 3, -32 },
  { 3397, 17, 33, 21, 2, -33 },
  { 3468, 19, 32, 21, 1, -32 },
  { 3544, 21, 32, 28, 3, -32 },
  { 3628, 24, 32, 24, 0, -32 },
  { 3724, 36, 32, 36, 0, -32 },
  { 3868, 23, 32, 23, 0, -32 },
  { 3960, 22, 32, 22, 0, -32 },
  { 4048, 18, 32, 20, 1, -32 },
  { 4120, 10, 39, 14, 3, -32 },
  { 4169, 17, 32, 18, 0, -32 },
  { 4237, 10, 39, 14, 1, -32 },
  { 4286, 21, 19, 23, 1, -32 },
  { 4336, 19, 3, 19, 0, 4 },
  { 4344, 10, 7, 14, 2, -34 },
  { 4353, 17, 25, 22, 2, -25 },
  { 4407, 19, 34, 24, 3, -34 },
  { 4488, 16, 25, 19, 2, -25 },
  { 4538, 19, 34, 24, 2, -34 },
  { 4619, 18, 25, 22, 2, -25 },
  { 4676, 14, 34, 14, 1, -34 },
  { 4736, 19, 36, 24, 2, -25 },
  { 4822, 18, 34, 24, 3, -34 },
  { 4899, 5, 34, 11, 3, -34 },
  { 4921, 9, 45, 11, -1, -34 },
  { 4972, 19, 34, 22, 3, -34 },
  { 5053, 5, 34, 11, 3, -34 },
  { 5075, 30, 25, 36, 3, -25 },
  { 5169, 18, 25, 24, 3, -25 },
  { 5226, 19, 25, 23, 2, -25 },
  { 5286, 19, 36, 24, 3, -25 },
  { 5372, 19, 36, 24, 2, -25 },
  { 5458, 13, 25, 16, 3, -25 },
  { 5499, 15, 25, 18, 2, -25 },
  { 5546, 13, 30, 15, 1, -30 },
  { 5595, 18, 24, 24, 3, -24 },
  { 5649, 20, 24, 20, 0, -24 },
  { 5709, 31, 24, 32, 0, -24 },
  { 5802, 20, 24, 20, 0, -24 },
  { 5862, 20, 35, 21, 0, -24 },
  { 5950, 15, 24, 17, 1, -24 },
  { 5995, 14, 39, 16, 1, -32 },
  { 6064, 5, 44, 21, 8, -34 },
  { 6092, 13, 39, 16, 2, -32 },
  { 6156, 20, 7, 22, 1, -19 },
};

const GFXfont NotoSans_Condensed_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD45PT7B_H_
