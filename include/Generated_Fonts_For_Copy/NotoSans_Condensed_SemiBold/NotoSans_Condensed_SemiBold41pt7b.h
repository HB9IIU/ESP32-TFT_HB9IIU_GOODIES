#ifndef _NOTOSANS_CONDENSED_SEMIBOLD41PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0x78, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78, 0xF0, 0x07, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x1E,
  0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE, 0xFD, 0x8E, 0xF9, 0x80, 0xF1,
  0x80, 0xF1, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xBF, 0x01, 0x9F, 0x01,
  0x8F, 0x01, 0x8F, 0x81, 0x9F, 0xE1, 0x9F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0x1F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0xC0,
  0x78, 0x07, 0x9E, 0x03, 0x80, 0x3C, 0x78, 0x3C, 0x01, 0xC3, 0xC1, 0xC0,
  0x1E, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x3C,
  0x3C, 0x78, 0x00, 0xE1, 0xE3, 0x80, 0x07, 0x0F, 0x3C, 0x7C, 0x3C, 0x79,
  0xE7, 0xF1, 0xE7, 0x9E, 0x7F, 0xC7, 0xFC, 0xF3, 0xDE, 0x3F, 0xCF, 0x3C,
  0x78, 0xFC, 0x79, 0xE3, 0xC1, 0xC3, 0x8F, 0x1E, 0x00, 0x3C, 0x78, 0xF0,
  0x01, 0xE3, 0xC7, 0x80, 0x1E, 0x1E, 0x3C, 0x00, 0xF0, 0xF1, 0xE0, 0x0F,
  0x07, 0x8F, 0x00, 0x78, 0x3C, 0x78, 0x03, 0x81, 0xE3, 0xC0, 0x3C, 0x07,
  0x1E, 0x01, 0xE0, 0x3F, 0xE0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x3E, 0x3F, 0xF8,
  0x7C, 0xFD, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3, 0xE3, 0xF7, 0xCF, 0x83, 0xFF,
  0x9F, 0x03, 0xFE, 0x3E, 0x03, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xC1,
  0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x07, 0xC3,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C,
  0x13, 0xCE, 0x79, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xF0, 0x01,
  0xFC, 0x01, 0xEF, 0x01, 0xF7, 0xC1, 0xF1, 0xF0, 0x78, 0xF0, 0x18, 0x30,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF,
  0x9F, 0x3C, 0x79, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E,
  0x78, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7E, 0xFF, 0xCF,
  0x39, 0xF1, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0, 0xF8, 0xC0, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xF1, 0x80,
  0xF8, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xB0, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x0F, 0xF8, 0x03, 0xBE,
  0x01, 0xEF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83,
  0xC3, 0xE0, 0xF0, 0xF8, 0x78, 0x3E, 0x1E, 0x0F, 0x8F, 0x03, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0xC0, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x3C, 0x03, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE6, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0xF0, 0xF3, 0xFC, 0xF7, 0xFC,
  0xFF, 0xFE, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E,
  0x3F, 0x1F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x1F, 0xFE, 0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x3E, 0x78,
  0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x03,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xC0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x7E, 0xFE, 0xFF, 0x3F, 0xF7, 0x9F, 0xFB,
  0xC3, 0xF9, 0xE0, 0x61, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0x11, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFF, 0xF7, 0x80, 0x08, 0x7C, 0xFB, 0xF7,
  0xE7, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF1, 0xE7, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xE3,
  0xFF, 0xE7, 0xFF, 0xC4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x0F, 0x83, 0xCF, 0x07, 0xFE,
  0x39, 0xE1, 0xFF, 0xC7, 0xB8, 0x7C, 0x78, 0xFF, 0x0F, 0x0F, 0x1F, 0xE3,
  0xC1, 0xE1, 0xFC, 0x78, 0x3C, 0x3F, 0x8F, 0x07, 0x87, 0xF1, 0xE0, 0xE0,
  0xFC, 0x3C, 0x1C, 0x3F, 0x87, 0x87, 0x87, 0xF8, 0xF0, 0xF0, 0xFF, 0x1E,
  0x1E, 0x1D, 0xE3, 0xE3, 0xE7, 0xBC, 0x3F, 0xFF, 0xF7, 0x83, 0xF9, 0xFC,
  0x78, 0x3E, 0x3F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xE0, 0x63, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x61,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x3F, 0x8F, 0x80, 0xFC,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x81, 0xFC, 0xF8, 0x7F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xF8, 0x06, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xE0, 0x1F, 0x3F, 0x01, 0xF3, 0xF8, 0x1F, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x01, 0xFB,
  0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87,
  0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F,
  0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0x9F, 0x03, 0xE3, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C,
  0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFD, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7B, 0xFF, 0x78, 0x0F, 0x7F, 0xEF, 0x01, 0xEF, 0xFD, 0xE0, 0x3D, 0xFF,
  0xBE, 0x0F, 0x3F, 0xF3, 0xC1, 0xE7, 0xFE, 0x78, 0x3C, 0xFF, 0xCF, 0x8F,
  0x1F, 0xF8, 0xF1, 0xE3, 0xFF, 0x1E, 0x3C, 0x7F, 0xE3, 0xCF, 0x0F, 0xFC,
  0x7D, 0xE1, 0xFF, 0x87, 0xBC, 0x3F, 0xF0, 0xF7, 0x87, 0xFE, 0x1F, 0xE0,
  0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x3F, 0x83, 0xFF, 0x07, 0xE0, 0x7F, 0xE0,
  0xFC, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xE0, 0x3E, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFE, 0xF8, 0x1F, 0xF7, 0xC0, 0xFF, 0xDF, 0x07, 0xFE,
  0xF8, 0x3F, 0xF3, 0xE1, 0xFF, 0x9F, 0x0F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3,
  0xFF, 0x0F, 0x9F, 0xF8, 0x7C, 0x7F, 0xC1, 0xF3, 0xFE, 0x0F, 0x9F, 0xF0,
  0x3E, 0xFF, 0x81, 0xF7, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFE,
  0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC3, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF8,
  0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x83, 0xF1, 0xF0, 0x3F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7E, 0x7C,
  0x0F, 0x8F, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7E, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xDF, 0x81, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x7C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78,
  0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F,
  0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x07, 0x8F,
  0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0xF9, 0xF0,
  0x1F, 0xC0, 0x7C, 0x78, 0x1E, 0xE0, 0x7C, 0x3E, 0x0F, 0x78, 0x3E, 0x1F,
  0x07, 0xBC, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x87, 0xC1, 0xEF, 0x07, 0x81,
  0xE1, 0xE7, 0x87, 0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0x78, 0xF1, 0xF0,
  0x3E, 0x3C, 0x78, 0xF8, 0x0F, 0x3E, 0x3C, 0x78, 0x07, 0x9E, 0x1F, 0x7C,
  0x03, 0xEF, 0x07, 0xBE, 0x01, 0xF7, 0x83, 0xDF, 0x00, 0xFB, 0xC1, 0xEF,
  0x00, 0x3D, 0xC0, 0xF7, 0x80, 0x1F, 0xE0, 0x3B, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x03,
  0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F,
  0x8F, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x9E,
  0x00, 0xF3, 0xC0, 0x1F, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x00, 0xE0, 0x0F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFE, 0x1C, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xCF, 0x7C, 0x0F, 0x7C,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7E, 0xFF, 0x7F,
  0xFF, 0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xE0,
  0x79, 0xFC, 0x3D, 0xFF, 0x1E, 0xFF, 0xCF, 0xF7, 0xF7, 0xE0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xBF, 0x07, 0xDF, 0xFF, 0xEF, 0x7F, 0xE7, 0xBF, 0xE3, 0xCF, 0xE0, 0x01,
  0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0x39, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x5F, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0x0F, 0x8F,
  0xE7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xF7, 0xFB, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDF,
  0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0x79, 0xFF, 0x3C, 0x3F, 0x1E, 0x01, 0x80,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7E, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x02,
  0x7F, 0xBE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0xF3, 0xCF, 0xF9, 0xE7, 0xFF, 0xF7,
  0xF7, 0xFB, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDF, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0x7C, 0x3F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE8, 0x03, 0xE7, 0x87, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x60, 0xF3, 0xFC, 0xF7, 0xFE,
  0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0x39, 0xEF, 0xFF, 0x78, 0xC0, 0x00, 0x01, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x07, 0x07, 0x87, 0xE3, 0xF0, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE9, 0xF7, 0xFB, 0xF9,
  0xFC, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x0F,
  0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xC7, 0xC7, 0xC3, 0xE7, 0xE1, 0xE3,
  0xE0, 0xF3, 0xE0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x1E, 0x1E, 0x7F, 0x0F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0x0F, 0xFE, 0x07, 0xC0,
  0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xC0,
  0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x3E, 0x07,
  0xFC, 0x07, 0xC0, 0xFF, 0x80, 0xF8, 0x1F, 0xF0, 0x1F, 0x03, 0xFE, 0x03,
  0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0x3F,
  0xE0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0xF8, 0x00, 0x60, 0xF3, 0xFC, 0xF7,
  0xFE, 0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xF3, 0xF3, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xC7, 0xFF, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x60, 0x79, 0xFC, 0x3D, 0xFF,
  0x1E, 0xFF, 0xCF, 0xE7, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBF, 0x0F, 0xDF, 0xFF,
  0xEF, 0x7F, 0xE7, 0xBF, 0xE3, 0xC7, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xF3, 0xCF, 0xF9, 0xE7,
  0xFF, 0xF7, 0xF7, 0xFB, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDF, 0x07, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0x7C, 0x3F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0x80, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7C, 0x3B, 0xE0, 0x2F, 0x80,
  0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF,
  0x7F, 0xEF, 0x7F, 0xEF, 0x3F, 0x8F, 0xF8, 0x07, 0xEF, 0x00, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x78, 0x1E, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF3,
  0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0xFB, 0xC0, 0xFE, 0x07, 0x9F, 0x07, 0xF0, 0x7C, 0xF8, 0x3F,
  0x83, 0xE7, 0xC1, 0xDC, 0x1E, 0x1E, 0x0E, 0xE0, 0xF0, 0xF8, 0xF7, 0x8F,
  0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x3D, 0xE3, 0xC0, 0xF1, 0xC7, 0x1E, 0x07,
  0x9E, 0x39, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C, 0x07, 0xBC,
  0x7B, 0xC0, 0x3D, 0xC1, 0xDE, 0x01, 0xEE, 0x0E, 0xF0, 0x0F, 0x70, 0x7F,
  0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xCF, 0x83, 0xE3,
  0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3E, 0x7C, 0x0F, 0xBF, 0x01, 0xF0, 0xF8, 0x07, 0xEF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x07,
  0x8F, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x27, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x83, 0xF0, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0x07, 0xF0, 0xFF, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0xF8, 0x08, 0x00, 0x08, 0x00, 0x4F, 0xE0, 0x1F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xE8, 0x00, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 29, 11, 2, -29 },
  { 23, 13, 10, 18, 2, -29 },
  { 40, 20, 29, 22, 1, -29 },
  { 113, 16, 33, 20, 2, -31 },
  { 179, 29, 30, 32, 1, -30 },
  { 288, 23, 30, 24, 1, -30 },
  { 375, 5, 10, 10, 2, -29 },
  { 382, 10, 35, 13, 2, -29 },
  { 426, 10, 35, 13, 1, -29 },
  { 470, 17, 16, 19, 1, -31 },
  { 504, 18, 19, 20, 1, -24 },
  { 547, 7, 10, 10, 1, -5 },
  { 556, 10, 4, 12, 1, -13 },
  { 561, 6, 6, 10, 2, -6 },
  { 566, 16, 29, 16, 0, -29 },
  { 624, 16, 30, 20, 2, -30 },
  { 684, 12, 29, 20, 2, -29 },
  { 728, 17, 30, 20, 1, -30 },
  { 792, 17, 30, 20, 1, -30 },
  { 856, 18, 29, 20, 1, -29 },
  { 922, 16, 29, 20, 2, -29 },
  { 980, 16, 30, 20, 2, -30 },
  { 1040, 18, 29, 20, 1, -29 },
  { 1106, 18, 30, 20, 1, -30 },
  { 1174, 17, 30, 20, 1, -30 },
  { 1238, 6, 23, 11, 2, -23 },
  { 1256, 7, 28, 11, 1, -23 },
  { 1281, 18, 20, 20, 1, -25 },
  { 1326, 18, 12, 20, 1, -20 },
  { 1353, 18, 20, 20, 1, -25 },
  { 1398, 15, 30, 16, 0, -30 },
  { 1455, 27, 33, 31, 2, -30 },
  { 1567, 23, 29, 23, 0, -29 },
  { 1651, 18, 29, 23, 3, -29 },
  { 1717, 18, 30, 21, 2, -30 },
  { 1785, 20, 29, 25, 3, -29 },
  { 1858, 14, 29, 19, 3, -29 },
  { 1909, 14, 29, 18, 3, -29 },
  { 1960, 20, 30, 25, 2, -30 },
  { 2035, 19, 29, 26, 3, -29 },
  { 2104, 11, 29, 13, 1, -29 },
  { 2144, 10, 37, 11, -2, -29 },
  { 2191, 19, 29, 22, 3, -29 },
  { 2260, 14, 29, 18, 3, -29 },
  { 2311, 27, 29, 33, 3, -29 },
  { 2409, 21, 29, 27, 3, -29 },
  { 2486, 22, 30, 26, 2, -30 },
  { 2569, 17, 29, 21, 3, -29 },
  { 2631, 22, 37, 26, 2, -30 },
  { 2733, 19, 29, 22, 3, -29 },
  { 2802, 15, 30, 19, 2, -30 },
  { 2859, 17, 29, 19, 1, -29 },
  { 2921, 19, 29, 25, 3, -29 },
  { 2990, 22, 29, 22, 0, -29 },
  { 3070, 33, 29, 33, 0, -29 },
  { 3190, 21, 29, 21, 0, -29 },
  { 3267, 20, 29, 20, 0, -29 },
  { 3340, 17, 29, 18, 1, -29 },
  { 3402, 9, 36, 13, 3, -29 },
  { 3443, 16, 29, 16, 0, -29 },
  { 3501, 9, 36, 13, 1, -29 },
  { 3542, 19, 17, 21, 1, -29 },
  { 3583, 17, 2, 17, 0, 4 },
  { 3588, 9, 6, 13, 2, -31 },
  { 3595, 16, 23, 20, 1, -23 },
  { 3641, 17, 31, 22, 3, -31 },
  { 3707, 14, 23, 17, 2, -23 },
  { 3748, 17, 31, 22, 2, -31 },
  { 3814, 16, 23, 20, 2, -23 },
  { 3860, 14, 31, 13, 0, -31 },
  { 3915, 17, 33, 22, 2, -23 },
  { 3986, 16, 31, 22, 3, -31 },
  { 4048, 6, 31, 10, 2, -31 },
  { 4072, 9, 41, 10, -1, -31 },
  { 4119, 17, 31, 20, 3, -31 },
  { 4185, 4, 31, 10, 3, -31 },
  { 4201, 27, 23, 33, 3, -23 },
  { 4279, 16, 23, 22, 3, -23 },
  { 4325, 17, 23, 21, 2, -23 },
  { 4374, 17, 33, 22, 3, -23 },
  { 4445, 17, 33, 22, 2, -23 },
  { 4516, 11, 23, 15, 3, -23 },
  { 4548, 14, 23, 16, 1, -23 },
  { 4589, 12, 27, 14, 1, -27 },
  { 4630, 16, 22, 22, 3, -22 },
  { 4674, 19, 22, 19, 0, -22 },
  { 4727, 29, 22, 29, 0, -22 },
  { 4807, 18, 22, 18, 0, -22 },
  { 4857, 19, 32, 19, 0, -22 },
  { 4933, 14, 22, 16, 1, -22 },
  { 4972, 12, 36, 15, 1, -29 },
  { 5026, 5, 41, 19, 7, -31 },
  { 5052, 12, 36, 15, 2, -29 },
  { 5106, 18, 7, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_SemiBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD41PT7B_H_
