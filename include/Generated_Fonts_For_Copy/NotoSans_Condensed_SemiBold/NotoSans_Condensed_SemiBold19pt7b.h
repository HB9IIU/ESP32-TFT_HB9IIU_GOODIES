#ifndef _NOTOSANS_CONDENSED_SEMIBOLD19PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0x48, 0x2F, 0xC0, 0xCF, 0x3C, 0xF3, 0xCC, 0x09,
  0x86, 0x41, 0x90, 0x64, 0x7F, 0xDF, 0xF1, 0x30, 0x4C, 0xFF, 0xBF, 0xE3,
  0x60, 0xD8, 0x26, 0x09, 0x80, 0x10, 0x7F, 0xFE, 0x9D, 0x1E, 0x1E, 0x1E,
  0x1E, 0x2E, 0x5F, 0xFF, 0xC2, 0x04, 0x00, 0x60, 0xC7, 0x86, 0x36, 0x61,
  0x33, 0x09, 0x90, 0x4D, 0x83, 0x6D, 0xDE, 0xDB, 0x66, 0xD8, 0x64, 0xC3,
  0x26, 0x11, 0xB1, 0x8D, 0x8C, 0x38, 0x38, 0x1F, 0x06, 0x61, 0x98, 0x6E,
  0x1F, 0x03, 0x81, 0xE7, 0xDD, 0xB3, 0xEC, 0x7B, 0x1C, 0xFF, 0x9F, 0x70,
  0xFF, 0xC0, 0x13, 0x66, 0xEC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0x30, 0xC3,
  0x0C, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x33, 0x98, 0xCC, 0xE0, 0x30, 0x23,
  0xFF, 0xF3, 0x8D, 0xB3, 0x00, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0xFB, 0x60, 0xFF, 0x5F, 0x80, 0x06, 0x0C, 0x18, 0x60, 0xC3,
  0x06, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x00, 0x38, 0x7C, 0xEE, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC7, 0xC6, 0xC6, 0xC6, 0xE6, 0x7E, 0x7C, 0x0C, 0x73,
  0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x39, 0xFB, 0x38,
  0x30, 0x60, 0xC3, 0x8E, 0x18, 0x61, 0xC7, 0x0F, 0xFF, 0xC0, 0x39, 0xFB,
  0x38, 0x30, 0x61, 0xDE, 0x3E, 0x0E, 0x0C, 0x1C, 0x3F, 0xFF, 0x80, 0x06,
  0x03, 0x03, 0x81, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x7F, 0xFF, 0xE0,
  0xC0, 0x60, 0x30, 0x7F, 0xFF, 0x06, 0x0C, 0x1A, 0x3F, 0x27, 0x06, 0x0C,
  0x1C, 0x3F, 0xFF, 0x80, 0x1E, 0x3E, 0x70, 0xE0, 0xC0, 0xDC, 0xFE, 0xE6,
  0xC6, 0xC7, 0xC6, 0xE6, 0x7E, 0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x38, 0x7E, 0xC6, 0xC6,
  0xC6, 0x6E, 0x7C, 0x7C, 0xEE, 0xC6, 0xC7, 0xC6, 0xFE, 0x7C, 0x38, 0xFB,
  0xBE, 0x3C, 0x78, 0xF1, 0xFF, 0x7E, 0x0C, 0x18, 0x7F, 0xDF, 0x00, 0xFC,
  0x00, 0x02, 0xFC, 0xFC, 0x00, 0x00, 0xFB, 0x60, 0x03, 0x0F, 0x3C, 0xF0,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x3C, 0xF0, 0xC0, 0x80, 0x39, 0xF9, 0x38, 0x30, 0x61,
  0x87, 0x1C, 0x30, 0x60, 0x01, 0x83, 0x06, 0x00, 0x07, 0x00, 0xFE, 0x0C,
  0x18, 0xC0, 0x64, 0x7B, 0x66, 0xCB, 0x66, 0x7B, 0x33, 0xD9, 0x96, 0xCC,
  0xB3, 0xFD, 0x9C, 0xC6, 0x00, 0x38, 0x20, 0xFF, 0x00, 0xC0, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1B, 0x0E, 0xC3, 0x30, 0xCE, 0x3F, 0x9F, 0xE6, 0x19,
  0x87, 0xE0, 0xF8, 0x30, 0xF8, 0x7F, 0xB9, 0xDC, 0x6E, 0x37, 0x1B, 0xF9,
  0xFE, 0xE3, 0x71, 0xF8, 0xFC, 0x6F, 0xF7, 0xF0, 0x0E, 0x3F, 0x71, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x7F, 0x3F, 0xF8, 0x7F,
  0x39, 0xDC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x6F,
  0xF7, 0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x00, 0x0F, 0x1F, 0xDC, 0x2C, 0x0E, 0x06, 0x03, 0x01,
  0x8F, 0xC7, 0xF0, 0xF8, 0x6E, 0x37, 0xF8, 0xFC, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C,
  0xFF, 0xD8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xCF, 0x7C, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0xF7, 0x00, 0xE1, 0xF1, 0xF9,
  0xDC, 0xCE, 0xE7, 0xE3, 0xE1, 0xF8, 0xEC, 0x77, 0x39, 0x9C, 0xEE, 0x3F,
  0x1C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F,
  0xFF, 0xC0, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xA0, 0xFF, 0x8D, 0xFC, 0x6F,
  0xE3, 0x7D, 0x93, 0xED, 0x9F, 0x6C, 0xF9, 0xE7, 0xCE, 0x3E, 0x71, 0xF3,
  0x8C, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xD8, 0xFF, 0x3E, 0xCF, 0xBB, 0xE6,
  0xF9, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x70, 0x1E, 0x0F, 0xC7, 0x3B, 0x87,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x1D, 0x86, 0x7F, 0x8F,
  0xC0, 0xF8, 0xFE, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x1E, 0x0F, 0xC7, 0x3B, 0x87, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x3E, 0x1D, 0x86, 0x7F, 0x8F, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0xF8, 0x7F, 0x39, 0xDC, 0x6E, 0x37, 0x1B, 0x9D, 0xFC, 0xFC, 0x77,
  0x39, 0x9C, 0xEE, 0x37, 0x1C, 0x38, 0xFF, 0x96, 0x0C, 0x1C, 0x1E, 0x1E,
  0x0E, 0x0C, 0x1C, 0x7F, 0xDF, 0x00, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x6C, 0x77, 0xF9, 0xF0,
  0xC0, 0xF8, 0x76, 0x19, 0x86, 0x61, 0x9C, 0xE3, 0x30, 0xCC, 0x33, 0x0F,
  0x81, 0xE0, 0x78, 0x1E, 0x03, 0x00, 0xC1, 0x87, 0x87, 0x0F, 0x8E, 0x1B,
  0x1C, 0x76, 0x2C, 0xCC, 0xD9, 0x99, 0xB3, 0x3B, 0x66, 0x36, 0x5C, 0x68,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x83, 0x86, 0x00, 0xE1, 0x98, 0xE7,
  0x30, 0xDC, 0x3E, 0x07, 0x81, 0xC0, 0x70, 0x1E, 0x0F, 0x83, 0x71, 0xCC,
  0x63, 0xB8, 0x70, 0xC1, 0xF0, 0xD8, 0xCE, 0x63, 0x71, 0xB0, 0x78, 0x38,
  0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x7F, 0x7F, 0x07, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xC0, 0xC1, 0x83, 0x03,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x08, 0x06, 0x07, 0x03,
  0xC3, 0x21, 0x99, 0x8C, 0xC3, 0xC1, 0x80, 0xFF, 0xCE, 0x70, 0x10, 0xF9,
  0x38, 0x30, 0x6F, 0xF9, 0xE3, 0xC7, 0xFF, 0xD8, 0xC0, 0xC0, 0xC0, 0xC0,
  0xDE, 0xF7, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xFF, 0xDE, 0x11, 0xF6,
  0x70, 0xC3, 0x0C, 0x30, 0xE1, 0xF7, 0xC0, 0x03, 0x03, 0x03, 0x13, 0x7B,
  0xEF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x7D, 0xCF, 0x1E,
  0x3F, 0xF8, 0x30, 0x70, 0x7E, 0x7C, 0x0A, 0x78, 0xD1, 0x83, 0x1F, 0x8C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x10, 0x7B, 0xEF, 0xC7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x03, 0x07, 0xCE, 0xFE, 0x30,
  0xC0, 0xC0, 0xC0, 0xC8, 0xDE, 0xF7, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFC, 0x0D, 0xB6, 0xDB, 0x6D, 0x80, 0x39, 0xC0, 0x03, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0xB7, 0x90, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC7, 0xCE, 0xCC, 0xD8, 0xF8, 0xEC, 0xCC, 0xC6, 0xC7, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x08, 0x26, 0xF7, 0xBD, 0xEF, 0xCE, 0x3E, 0x71, 0xE3, 0x8F,
  0x1C, 0x78, 0xE3, 0xC7, 0x1E, 0x38, 0xF1, 0xC6, 0x08, 0xDE, 0xF7, 0xE3,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x10, 0x7E, 0xE6, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x08, 0xDE, 0xF7, 0xE3, 0xE3, 0xC3,
  0xC3, 0xE3, 0xE3, 0xFF, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x10, 0x7B,
  0xEF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFF, 0x7B, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x0B, 0x7F, 0xB8, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x13,
  0xFC, 0xB0, 0xE1, 0xE3, 0xC3, 0x0F, 0xFF, 0x80, 0x30, 0xC3, 0x3F, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x3C, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7F, 0x7B, 0xE3, 0xB1, 0x98, 0xCC, 0xC7, 0x61, 0xB0, 0xD8,
  0x78, 0x1C, 0x0E, 0x00, 0xE7, 0x1B, 0x38, 0xD9, 0xEE, 0xCB, 0x66, 0xDB,
  0x1E, 0xD8, 0xF2, 0xC7, 0x94, 0x38, 0xE1, 0xC7, 0x00, 0xE3, 0x76, 0x36,
  0x3C, 0x1C, 0x1C, 0x3E, 0x76, 0x67, 0xE3, 0xE3, 0xB1, 0x98, 0xCC, 0xC3,
  0x61, 0xB0, 0xD8, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x83, 0x81, 0x00,
  0x7E, 0x1C, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x7F, 0xFC, 0x04, 0x71, 0x8E,
  0x38, 0xE3, 0x8C, 0xE3, 0xC3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x83, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x1C, 0xF7, 0x18,
  0x61, 0x86, 0x38, 0xC0, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 10, 14, 10, 0, -14 },
  { 29, 7, 15, 9, 1, -14 },
  { 43, 13, 14, 15, 1, -14 },
  { 66, 10, 14, 11, 1, -14 },
  { 84, 2, 5, 4, 1, -14 },
  { 86, 4, 17, 6, 1, -14 },
  { 95, 5, 17, 6, 0, -14 },
  { 106, 7, 7, 9, 1, -14 },
  { 113, 8, 9, 9, 1, -11 },
  { 122, 3, 4, 5, 1, -2 },
  { 124, 4, 2, 6, 1, -6 },
  { 125, 3, 3, 5, 1, -3 },
  { 127, 7, 14, 7, 0, -14 },
  { 140, 8, 14, 9, 1, -14 },
  { 154, 6, 14, 9, 1, -14 },
  { 165, 7, 14, 9, 1, -14 },
  { 178, 7, 14, 9, 1, -14 },
  { 191, 9, 14, 9, 0, -14 },
  { 207, 7, 14, 9, 1, -14 },
  { 220, 8, 14, 9, 1, -14 },
  { 234, 8, 14, 9, 1, -14 },
  { 248, 8, 14, 9, 1, -14 },
  { 262, 7, 14, 9, 1, -14 },
  { 275, 3, 10, 5, 1, -10 },
  { 279, 3, 12, 5, 1, -10 },
  { 284, 8, 9, 9, 1, -11 },
  { 293, 8, 5, 9, 1, -9 },
  { 298, 8, 9, 9, 1, -11 },
  { 307, 7, 14, 7, 0, -14 },
  { 320, 13, 16, 14, 1, -14 },
  { 346, 10, 14, 10, 0, -14 },
  { 364, 9, 14, 11, 1, -14 },
  { 380, 8, 14, 10, 1, -14 },
  { 394, 9, 14, 11, 1, -14 },
  { 410, 7, 14, 9, 1, -14 },
  { 423, 7, 14, 9, 1, -14 },
  { 436, 9, 14, 12, 1, -14 },
  { 452, 9, 14, 12, 1, -14 },
  { 468, 5, 14, 6, 1, -14 },
  { 477, 5, 18, 5, -1, -14 },
  { 489, 9, 14, 10, 1, -14 },
  { 505, 7, 14, 8, 1, -14 },
  { 518, 13, 14, 15, 1, -14 },
  { 541, 10, 14, 13, 1, -14 },
  { 559, 10, 14, 12, 1, -14 },
  { 577, 8, 14, 10, 1, -14 },
  { 591, 10, 17, 12, 1, -14 },
  { 613, 9, 14, 10, 1, -14 },
  { 629, 7, 14, 9, 1, -14 },
  { 642, 8, 14, 9, 0, -14 },
  { 656, 9, 14, 12, 1, -14 },
  { 672, 10, 14, 10, 0, -14 },
  { 690, 15, 14, 15, 0, -14 },
  { 717, 10, 14, 10, 0, -14 },
  { 735, 9, 14, 9, 0, -14 },
  { 751, 8, 14, 9, 0, -14 },
  { 765, 5, 17, 6, 1, -14 },
  { 776, 7, 14, 7, 0, -14 },
  { 789, 5, 17, 6, 0, -14 },
  { 800, 9, 9, 10, 0, -14 },
  { 811, 8, 1, 8, 0, 2 },
  { 812, 4, 3, 6, 1, -15 },
  { 814, 7, 11, 9, 1, -11 },
  { 824, 8, 14, 10, 1, -14 },
  { 838, 6, 11, 8, 1, -11 },
  { 847, 8, 14, 10, 1, -14 },
  { 861, 7, 10, 9, 1, -10 },
  { 870, 7, 15, 6, 0, -15 },
  { 884, 8, 16, 10, 1, -11 },
  { 900, 8, 14, 10, 1, -14 },
  { 914, 3, 14, 5, 1, -14 },
  { 920, 5, 19, 5, -1, -14 },
  { 932, 8, 14, 9, 1, -14 },
  { 946, 2, 14, 5, 1, -14 },
  { 950, 13, 11, 15, 1, -11 },
  { 968, 8, 11, 10, 1, -11 },
  { 979, 8, 11, 10, 1, -11 },
  { 990, 8, 16, 10, 1, -11 },
  { 1006, 8, 16, 10, 1, -11 },
  { 1022, 6, 11, 7, 1, -11 },
  { 1031, 6, 11, 8, 1, -11 },
  { 1040, 6, 13, 6, 0, -13 },
  { 1050, 8, 10, 10, 1, -10 },
  { 1060, 9, 10, 9, 0, -10 },
  { 1072, 13, 10, 13, 0, -10 },
  { 1089, 8, 10, 9, 0, -10 },
  { 1099, 9, 15, 9, 0, -10 },
  { 1116, 7, 10, 7, 0, -10 },
  { 1125, 6, 17, 7, 0, -14 },
  { 1138, 2, 18, 9, 3, -14 },
  { 1143, 6, 17, 7, 1, -14 },
  { 1156, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD19PT7B_H_
