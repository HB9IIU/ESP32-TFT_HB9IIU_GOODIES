#ifndef _NOTOSANS_CONDENSED_SEMIBOLD11PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0x80, 0x28, 0xA7, 0xCC, 0x53, 0xE5, 0x14, 0x23, 0xF8,
  0xC3, 0x97, 0xE4, 0x20, 0x64, 0xA4, 0xA8, 0xAA, 0x6D, 0x15, 0x15, 0x27,
  0x70, 0xB1, 0x41, 0x87, 0x5B, 0xB2, 0x3B, 0xE0, 0x29, 0x2C, 0x92, 0x44,
  0xC9, 0x92, 0x4B, 0x58, 0x27, 0xCC, 0xA0, 0x21, 0x09, 0xF2, 0x10, 0x70,
  0xFC, 0xC0, 0x11, 0x22, 0x64, 0x4C, 0x72, 0xD3, 0x9C, 0xE5, 0x6E, 0x7E,
  0x92, 0x49, 0x76, 0xC6, 0x23, 0x11, 0x1F, 0xF2, 0xC6, 0xE3, 0x04, 0x7E,
  0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xE8, 0x8E, 0x31, 0x3E, 0x3A, 0x11, 0xED,
  0xE5, 0x6E, 0xF8, 0x44, 0x23, 0x10, 0x8C, 0x72, 0xD6, 0xE7, 0x67, 0x2E,
  0x72, 0xF3, 0xB7, 0x84, 0x4E, 0xCC, 0x50, 0x1C, 0x08, 0xD9, 0xC1, 0x84,
  0xF8, 0x3E, 0x87, 0x0E, 0x36, 0x40, 0xE9, 0x12, 0x64, 0x46, 0x1C, 0x62,
  0x5D, 0x55, 0xA5, 0x75, 0x5E, 0x40, 0x3C, 0x30, 0xC3, 0x1A, 0x49, 0xEC,
  0xF3, 0xF4, 0xA5, 0xEB, 0x4E, 0x7E, 0x7D, 0x88, 0x88, 0xC7, 0xE4, 0xE7,
  0x18, 0xCE, 0x7E, 0xF8, 0x8E, 0x88, 0x8F, 0xF8, 0x88, 0xE8, 0x88, 0x7E,
  0x61, 0x0B, 0xC7, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xE9, 0x24, 0x97,
  0x24, 0x92, 0x49, 0x3C, 0x9C, 0xA9, 0xCE, 0x5A, 0x53, 0x88, 0x88, 0x88,
  0x8F, 0xC7, 0x8F, 0x3D, 0x5A, 0xB5, 0x6C, 0xC9, 0xCE, 0x7B, 0x5B, 0xCE,
  0x71, 0x73, 0x68, 0xA2, 0x8E, 0x2C, 0x9C, 0xE9, 0x99, 0xF8, 0x88, 0x73,
  0x68, 0xA2, 0x8E, 0x2C, 0x9C, 0x10, 0x20, 0xE4, 0xA5, 0x2E, 0x5A, 0x53,
  0x7A, 0x70, 0xC3, 0x0E, 0x7E, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63,
  0x18, 0xC6, 0x6E, 0x8F, 0x24, 0x92, 0x59, 0xC3, 0x0C, 0x89, 0xE4, 0xF7,
  0x4A, 0xA5, 0x52, 0xB9, 0xD8, 0x44, 0xC9, 0x67, 0x0C, 0x31, 0xC5, 0xB3,
  0xCA, 0xD4, 0xE3, 0x10, 0x84, 0xF8, 0x84, 0x42, 0x21, 0x1F, 0xEA, 0xAA,
  0xB0, 0x84, 0x46, 0x22, 0x31, 0xE4, 0x92, 0x49, 0x3C, 0x21, 0x94, 0x9C,
  0x80, 0xF8, 0xE0, 0x70, 0xCE, 0xBD, 0xB4, 0x88, 0xF9, 0x99, 0x9F, 0x74,
  0xCC, 0x47, 0x08, 0x5E, 0x9C, 0xE5, 0x2F, 0x72, 0x7F, 0x84, 0x3C, 0x74,
  0xE4, 0x44, 0x44, 0x7A, 0x73, 0x94, 0xBC, 0x2B, 0x70, 0x88, 0xF9, 0x99,
  0x99, 0xBF, 0x45, 0x55, 0x78, 0x88, 0x9A, 0xCA, 0xB9, 0xFF, 0xFF, 0x26,
  0x4C, 0x99, 0x32, 0x40, 0xF9, 0x99, 0x99, 0x72, 0x73, 0x94, 0xB8, 0xF9,
  0x99, 0x9F, 0x88, 0x80, 0x7A, 0x73, 0x94, 0xBC, 0x21, 0x08, 0xF2, 0x49,
  0x00, 0x7C, 0x63, 0x1F, 0x5D, 0x24, 0x98, 0x99, 0x99, 0x9F, 0x8E, 0xD4,
  0xA5, 0x10, 0x9B, 0xDA, 0x5A, 0x6A, 0x6A, 0x64, 0xDA, 0x9C, 0xE5, 0x6C,
  0x8E, 0xD4, 0xA7, 0x10, 0x9C, 0xC0, 0xF3, 0x26, 0x4F, 0x36, 0x66, 0xC4,
  0x66, 0x63, 0xFF, 0xE0, 0xC6, 0x66, 0x32, 0x66, 0x6C, 0x6D, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 8, 8, 9, 0, -8 },
  { 24, 7, 8, 7, 0, -8 },
  { 31, 1, 3, 3, 1, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 3, 10, 3, 0, -8 },
  { 40, 5, 4, 5, 0, -8 },
  { 43, 5, 6, 5, 0, -7 },
  { 47, 2, 2, 3, 0, -1 },
  { 48, 3, 2, 3, 0, -4 },
  { 49, 1, 2, 3, 1, -2 },
  { 50, 4, 8, 4, 0, -8 },
  { 54, 5, 8, 5, 0, -8 },
  { 59, 3, 8, 5, 1, -8 },
  { 62, 5, 8, 5, 0, -8 },
  { 67, 5, 8, 5, 0, -8 },
  { 72, 5, 8, 5, 0, -8 },
  { 77, 4, 8, 5, 1, -8 },
  { 81, 5, 8, 5, 0, -8 },
  { 86, 5, 8, 5, 0, -8 },
  { 91, 5, 8, 5, 0, -8 },
  { 96, 5, 8, 5, 0, -8 },
  { 101, 1, 6, 3, 1, -6 },
  { 102, 2, 7, 3, 0, -6 },
  { 104, 5, 6, 5, 0, -7 },
  { 108, 5, 3, 5, 0, -5 },
  { 110, 5, 6, 5, 0, -7 },
  { 114, 4, 8, 4, 0, -8 },
  { 118, 8, 9, 8, 0, -8 },
  { 127, 6, 8, 6, 0, -8 },
  { 133, 5, 8, 6, 1, -8 },
  { 138, 4, 8, 6, 1, -8 },
  { 142, 5, 8, 7, 1, -8 },
  { 147, 4, 8, 5, 1, -8 },
  { 151, 4, 8, 5, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 3, 8, 4, 0, -8 },
  { 168, 3, 10, 3, -1, -8 },
  { 172, 5, 8, 6, 1, -8 },
  { 177, 4, 8, 5, 1, -8 },
  { 181, 7, 8, 9, 1, -8 },
  { 188, 5, 8, 7, 1, -8 },
  { 193, 6, 8, 7, 1, -8 },
  { 199, 4, 8, 6, 1, -8 },
  { 203, 6, 10, 7, 1, -8 },
  { 211, 5, 8, 6, 1, -8 },
  { 216, 5, 8, 5, 0, -8 },
  { 221, 5, 8, 5, 0, -8 },
  { 226, 5, 8, 7, 1, -8 },
  { 231, 6, 8, 6, 0, -8 },
  { 237, 9, 8, 9, 0, -8 },
  { 246, 6, 8, 6, 0, -8 },
  { 252, 5, 8, 5, 0, -8 },
  { 257, 5, 8, 5, 0, -8 },
  { 262, 2, 10, 3, 1, -8 },
  { 265, 4, 8, 4, 0, -8 },
  { 269, 3, 10, 3, 0, -8 },
  { 273, 5, 5, 6, 0, -8 },
  { 277, 5, 1, 5, 0, 1 },
  { 278, 3, 1, 3, 0, -8 },
  { 279, 5, 6, 5, 0, -6 },
  { 283, 4, 8, 6, 1, -8 },
  { 287, 4, 6, 5, 0, -6 },
  { 290, 5, 8, 6, 0, -8 },
  { 295, 5, 6, 5, 0, -6 },
  { 299, 4, 8, 3, 0, -8 },
  { 303, 5, 9, 6, 0, -6 },
  { 309, 4, 8, 6, 1, -8 },
  { 313, 1, 8, 3, 1, -8 },
  { 314, 2, 11, 3, 0, -8 },
  { 317, 4, 8, 5, 1, -8 },
  { 321, 1, 8, 3, 1, -8 },
  { 322, 7, 6, 9, 1, -6 },
  { 328, 4, 6, 6, 1, -6 },
  { 331, 5, 6, 6, 0, -6 },
  { 335, 4, 9, 6, 1, -6 },
  { 340, 5, 9, 6, 0, -6 },
  { 346, 3, 6, 4, 1, -6 },
  { 349, 4, 6, 4, 0, -6 },
  { 352, 3, 7, 4, 0, -7 },
  { 355, 4, 6, 6, 1, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 8, 6, 8, 0, -6 },
  { 368, 5, 6, 5, 0, -6 },
  { 372, 5, 9, 5, 0, -6 },
  { 378, 4, 6, 4, 0, -6 },
  { 381, 4, 10, 4, 0, -8 },
  { 386, 1, 11, 5, 2, -8 },
  { 388, 4, 10, 4, 0, -8 },
  { 393, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_SemiBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD11PT7B_H_
