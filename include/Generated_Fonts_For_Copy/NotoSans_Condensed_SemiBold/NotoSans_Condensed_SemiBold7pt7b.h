#ifndef _NOTOSANS_CONDENSED_SEMIBOLD7PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xB4, 0x6F, 0x6E, 0xA0, 0x79, 0x9C, 0xD6, 0xBE, 0x75, 0x80,
  0x66, 0x5B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xFC, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x29, 0x28, 0x76, 0xD6, 0x75, 0x40, 0xE4, 0xAE, 0xE5, 0x1E,
  0x2E, 0xF2, 0x73, 0x9E, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0x5E, 0x77, 0x9C,
  0x90, 0x98, 0x39, 0x80, 0xFC, 0xC7, 0x00, 0xC5, 0x04, 0x75, 0xF7, 0xF4,
  0x18, 0x66, 0x6E, 0x90, 0xD7, 0x5C, 0x72, 0x46, 0xD6, 0xDC, 0xEE, 0xC0,
  0xEE, 0x80, 0x78, 0xB9, 0x70, 0xB7, 0xDA, 0xD5, 0xC0, 0xFC, 0xFA, 0x6A,
  0xAA, 0xC0, 0x9B, 0xBF, 0xD0, 0xB7, 0xFA, 0x79, 0x99, 0x70, 0xFE, 0x80,
  0x79, 0x99, 0x71, 0xDB, 0x6E, 0x71, 0x1E, 0xE9, 0x24, 0x99, 0x99, 0x60,
  0x9A, 0x66, 0x40, 0xA6, 0xEB, 0x96, 0x58, 0xA6, 0x46, 0xB0, 0xAD, 0x24,
  0xE5, 0x2E, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x4E, 0x80, 0xE0, 0xC0,
  0x6E, 0xF0, 0x9E, 0xDE, 0x72, 0x30, 0x2E, 0xD6, 0x77, 0x30, 0x7A, 0x80,
  0x76, 0xB3, 0xC0, 0x9E, 0xDA, 0xF8, 0xFE, 0x97, 0x7A, 0xF8, 0xFD, 0x6B,
  0x50, 0xF6, 0xD0, 0x76, 0xB0, 0xF6, 0xF9, 0x00, 0x76, 0xB2, 0x40, 0xEA,
  0xF1, 0xE0, 0x7A, 0x40, 0xB6, 0xB0, 0xB5, 0x20, 0xAD, 0x74, 0xA0, 0xA9,
  0x50, 0xB5, 0x25, 0x00, 0xC9, 0x70, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 5, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 2, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 3, 2, 3, 0, -5 },
  { 21, 3, 3, 3, 0, -4 },
  { 23, 1, 2, 2, 0, -1 },
  { 24, 2, 1, 2, 0, -2 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 3, 5, 3, 0, -5 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 2, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 5, 6, 5, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 3, 5, 4, 1, -5 },
  { 66, 3, 5, 4, 0, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 2, 5, 3, 1, -5 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 2, 5, 2, 0, -5 },
  { 81, 1, 6, 2, 0, -5 },
  { 82, 3, 5, 4, 1, -5 },
  { 84, 2, 5, 3, 1, -5 },
  { 86, 4, 5, 6, 1, -5 },
  { 89, 3, 5, 5, 1, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 2, 5, 4, 1, -5 },
  { 96, 4, 6, 4, 0, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 6, 5, 6, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 2, 6, 2, 0, -5 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 2, 6, 2, 0, -5 },
  { 128, 3, 3, 4, 0, -5 },
  { 130, 3, 1, 3, 0, 0 },
  { 131, 2, 1, 2, 0, -5 },
  { 132, 3, 4, 3, 0, -4 },
  { 134, 3, 5, 4, 0, -5 },
  { 136, 3, 4, 3, 0, -4 },
  { 138, 3, 5, 4, 0, -5 },
  { 140, 3, 4, 3, 0, -4 },
  { 142, 2, 5, 2, 0, -5 },
  { 144, 3, 6, 4, 0, -4 },
  { 147, 3, 5, 4, 0, -5 },
  { 149, 1, 5, 2, 0, -5 },
  { 150, 1, 7, 2, 0, -5 },
  { 151, 3, 5, 3, 0, -5 },
  { 153, 1, 5, 2, 0, -5 },
  { 154, 5, 4, 6, 0, -4 },
  { 157, 3, 4, 4, 0, -4 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 3, 6, 4, 0, -4 },
  { 164, 3, 6, 4, 0, -4 },
  { 167, 2, 4, 3, 0, -4 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 2, 5, 2, 0, -5 },
  { 172, 3, 4, 4, 0, -4 },
  { 174, 3, 4, 3, 0, -4 },
  { 176, 5, 4, 5, 0, -4 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 3, 6, 3, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 2, 6, 3, 0, -5 },
  { 188, 1, 7, 3, 1, -5 },
  { 189, 2, 6, 3, 0, -5 },
  { 191, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD7PT7B_H_
