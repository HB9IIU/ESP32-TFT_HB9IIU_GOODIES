#ifndef _NOTOSANS_CONDENSED_SEMIBOLD8PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xB4, 0x55, 0xF6, 0xF6, 0x6D, 0xC2, 0xD6, 0x4A, 0xCB,
  0x9B, 0x2D, 0xB0, 0x63, 0x18, 0xFB, 0x3C, 0xC0, 0x5A, 0x94, 0x95, 0x5C,
  0x5D, 0x80, 0x44, 0xF4, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x6A, 0x99,
  0xA6, 0x3C, 0x92, 0x40, 0x6A, 0x22, 0x4F, 0xE2, 0x26, 0x1E, 0x22, 0x6A,
  0xF2, 0x64, 0xE2, 0x1E, 0x64, 0xE9, 0x96, 0xF2, 0x22, 0x44, 0x69, 0x66,
  0x96, 0x6A, 0x97, 0x26, 0xC3, 0xC1, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C,
  0xC4, 0xA0, 0x80, 0x31, 0x2B, 0x6D, 0xB9, 0x03, 0x00, 0x26, 0x65, 0xB9,
  0xD6, 0xFB, 0xC0, 0x34, 0x88, 0x47, 0xD6, 0xDB, 0xC0, 0xEB, 0xB0, 0xEB,
  0xA0, 0x34, 0x89, 0x57, 0xB6, 0xFB, 0x40, 0xD5, 0x70, 0x55, 0x5E, 0xBF,
  0x6F, 0x40, 0xAA, 0xB0, 0x9C, 0xF7, 0xDE, 0xD4, 0x99, 0xDD, 0xBB, 0x72,
  0xA3, 0x14, 0xB8, 0xD6, 0xE9, 0x00, 0x72, 0xA3, 0x14, 0xB8, 0x60, 0xD6,
  0xED, 0x40, 0x73, 0x13, 0xC0, 0xF4, 0x44, 0x44, 0xB6, 0xDB, 0xC0, 0x99,
  0x56, 0x66, 0x96, 0x5B, 0x5D, 0x6D, 0x20, 0x96, 0x66, 0x69, 0x9A, 0x66,
  0x44, 0xE4, 0xA5, 0xC0, 0xFE, 0x91, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x69,
  0xE0, 0xC0, 0xEE, 0xF0, 0x93, 0xDB, 0xC0, 0x72, 0x30, 0x11, 0x79, 0x97,
  0x6F, 0x86, 0x6B, 0x24, 0x80, 0x79, 0x97, 0x16, 0x93, 0xDB, 0x40, 0xCA,
  0xA0, 0xCA, 0xAA, 0x97, 0x6D, 0x40, 0xFC, 0xFD, 0x6B, 0x50, 0xF6, 0xD0,
  0x79, 0x96, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA, 0xF8, 0xF0, 0x59,
  0x26, 0x99, 0x97, 0xB6, 0x64, 0xBE, 0xE5, 0x96, 0xF6, 0x6B, 0xB6, 0x64,
  0x4C, 0xE9, 0x70, 0x69, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 2, 0, -6 },
  { 20, 2, 7, 3, 0, -6 },
  { 22, 2, 7, 3, 0, -6 },
  { 24, 3, 3, 4, 0, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 2, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 2, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 3, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 4, 4, 0, -5 },
  { 69, 4, 2, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 3, 6, 3, 0, -6 },
  { 75, 6, 7, 6, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 3, 6, 4, 1, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 2, 6, 4, 1, -6 },
  { 95, 2, 6, 4, 1, -6 },
  { 97, 4, 6, 5, 0, -6 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 2, 6, 3, 0, -6 },
  { 105, 2, 8, 2, 0, -6 },
  { 107, 3, 6, 4, 1, -6 },
  { 110, 2, 6, 4, 1, -6 },
  { 112, 5, 6, 6, 1, -6 },
  { 116, 4, 6, 5, 1, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 3, 6, 4, 1, -6 },
  { 126, 5, 7, 5, 0, -6 },
  { 131, 3, 6, 4, 1, -6 },
  { 134, 3, 6, 4, 0, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 3, 6, 5, 1, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 6, 6, 6, 0, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 3, 6, 4, 0, -6 },
  { 160, 1, 7, 3, 1, -6 },
  { 161, 3, 6, 3, 0, -6 },
  { 164, 2, 7, 3, 0, -6 },
  { 166, 4, 4, 4, 0, -6 },
  { 168, 3, 1, 3, 0, 0 },
  { 169, 2, 1, 2, 0, -6 },
  { 170, 3, 4, 4, 0, -4 },
  { 172, 3, 6, 4, 1, -6 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 3, 6, 2, 0, -6 },
  { 185, 4, 6, 4, 0, -4 },
  { 188, 3, 6, 4, 1, -6 },
  { 191, 2, 6, 2, 0, -6 },
  { 193, 2, 8, 2, 0, -6 },
  { 195, 3, 6, 4, 1, -6 },
  { 198, 1, 6, 2, 0, -6 },
  { 199, 5, 4, 6, 1, -4 },
  { 202, 3, 4, 4, 1, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 3, 6, 4, 1, -4 },
  { 209, 4, 6, 4, 0, -4 },
  { 212, 2, 4, 3, 1, -4 },
  { 213, 3, 4, 3, 0, -4 },
  { 215, 3, 5, 3, 0, -5 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 6, 4, 6, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 6, 4, 0, -4 },
  { 229, 3, 4, 3, 0, -4 },
  { 231, 3, 7, 3, 0, -6 },
  { 234, 1, 8, 4, 1, -6 },
  { 235, 3, 7, 3, 0, -6 },
  { 238, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_SemiBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD8PT7B_H_
