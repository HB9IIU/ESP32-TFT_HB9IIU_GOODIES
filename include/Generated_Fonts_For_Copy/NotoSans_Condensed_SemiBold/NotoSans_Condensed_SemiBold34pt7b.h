#ifndef _NOTOSANS_CONDENSED_SEMIBOLD34PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0xEF, 0xFF, 0xFE, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1D, 0xE3,
  0xBC, 0x77, 0x8E, 0xE1, 0xC0, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x38, 0xE0, 0xFF, 0xFF, 0x7F, 0xFF,
  0x87, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x00, 0xE3, 0x83, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x1C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x03, 0xFC, 0x3F, 0xFD, 0xFF, 0xE7, 0xF3, 0x9E, 0xC0, 0x73, 0x01,
  0xCC, 0x07, 0xB0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0x7C, 0x0C, 0xF0, 0x33, 0xE0, 0xCF, 0xE3, 0x3F, 0xFF, 0xEF, 0xFF,
  0x0F, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x3F, 0x01, 0xE0, 0x7F, 0x81, 0xC0, 0x73, 0x81, 0xC0, 0x73, 0x83, 0x80,
  0xE3, 0xC3, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xCF, 0x00,
  0xE1, 0xCE, 0x00, 0xE3, 0xCE, 0x78, 0x73, 0x9C, 0xFC, 0x73, 0x9D, 0xFE,
  0x7F, 0xB9, 0xCF, 0x3F, 0x39, 0xC7, 0x0C, 0x79, 0xC7, 0x00, 0x71, 0xC7,
  0x00, 0x71, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x01, 0xC1, 0xC7,
  0x01, 0xC1, 0xC7, 0x03, 0xC1, 0xFE, 0x03, 0x80, 0xFE, 0x07, 0x80, 0x7C,
  0x01, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x87, 0x9F, 0xF8, 0xF3,
  0xCF, 0xBE, 0xF0, 0xF7, 0x9E, 0x0F, 0xF3, 0xC1, 0xFC, 0x78, 0x1F, 0x8F,
  0x83, 0xE0, 0xF8, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xBE, 0x1F, 0xE3, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0xF0, 0x70,
  0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x78, 0x70, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x67, 0x1B,
  0xFF, 0xEF, 0xFF, 0xC7, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xDE, 0x1F, 0x3C,
  0x38, 0x60, 0x21, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3D, 0xF7, 0x9E, 0x79,
  0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0x00, 0x3F, 0x81, 0xFF, 0x0F, 0xFC, 0x7C, 0x79, 0xE1, 0xE7,
  0x83, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x78, 0x78, 0xF3, 0xE3, 0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0x03, 0xC1, 0xF0,
  0xFC, 0xFF, 0x7F, 0xFE, 0xF7, 0x3D, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x3F, 0xFE, 0x70, 0x78,
  0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x70, 0x78, 0x81, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7F,
  0x83, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x78, 0x0E, 0xF0,
  0x39, 0xE0, 0x73, 0xC1, 0xC7, 0x87, 0x8F, 0x0E, 0x1E, 0x3C, 0x3C, 0x70,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xE4,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x01,
  0xEC, 0x1F, 0x7F, 0xF3, 0xFF, 0x9F, 0xF0, 0x00, 0x70, 0x1F, 0xE0, 0xFF,
  0x87, 0xFE, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC3,
  0x0F, 0x7F, 0x3D, 0xFE, 0xFF, 0xFB, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3C, 0xF1, 0xE3, 0xFF, 0x87,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0x80, 0x7F,
  0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78,
  0x78, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0xCF, 0x9E,
  0x1E, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7,
  0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFC,
  0x78, 0x79, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFE, 0x1F, 0x78, 0x7D, 0xFF, 0xF3, 0xFF, 0xC7, 0xEF, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F,
  0x80, 0x67, 0xBF, 0xFF, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF,
  0xFC, 0x31, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x7D, 0xE7, 0x9E, 0x71, 0xCF, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07,
  0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x06, 0x03, 0xFC,
  0xFF, 0xE7, 0xFF, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x3C, 0x3C, 0x00,
  0x71, 0xE0, 0x00, 0xE7, 0x07, 0xE3, 0x9C, 0x3F, 0xC7, 0xE1, 0xEF, 0x1F,
  0x8F, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE1, 0xC7, 0xE7, 0x87, 0x1F, 0x9E,
  0x1C, 0x7E, 0x78, 0xF1, 0xF9, 0xE3, 0xC7, 0xE3, 0x8F, 0x3B, 0x8F, 0x7F,
  0xEE, 0x1F, 0xBF, 0x38, 0x3C, 0x78, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x60, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7B, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x1E, 0x3E,
  0x03, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFB, 0xC3, 0xEF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF1, 0xFF,
  0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF,
  0xE3, 0xE0, 0xCF, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE3, 0x8F, 0xFF,
  0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF1, 0xFC,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x60,
  0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0x06, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x7C, 0x0F, 0x3F, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xDF, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3,
  0xFB, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xDF, 0xEF, 0xF7,
  0xF3, 0xE0, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E,
  0x3E, 0x3C, 0xF8, 0x79, 0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3C, 0xF0, 0x78, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3,
  0xC3, 0xE7, 0x83, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFE, 0xE0, 0x3B, 0xFB, 0x80, 0xEF, 0xEF, 0x07, 0xBF, 0x9C, 0x1E, 0xFE,
  0x70, 0x73, 0xF9, 0xE1, 0xCF, 0xE7, 0x8F, 0x3F, 0x8E, 0x38, 0xFE, 0x3C,
  0xE3, 0xF8, 0xF7, 0x8F, 0xE1, 0xDC, 0x3F, 0x87, 0x70, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE0, 0xF8, 0x3F, 0x83, 0xE0, 0xFE, 0x0F, 0x83, 0xF8,
  0x1C, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xBC, 0x1F, 0xDE, 0x0F, 0xE7, 0x87, 0xF3, 0xC3, 0xF8,
  0xF1, 0xFC, 0x78, 0xFE, 0x1E, 0x7F, 0x0F, 0x3F, 0x83, 0xDF, 0xC1, 0xEF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x79,
  0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xCF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE3, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xEF, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x79,
  0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xCF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x8F, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3C, 0xF0, 0x78, 0xF0, 0xF1, 0xE1, 0xE3,
  0xE3, 0xC3, 0xC7, 0x87, 0xCF, 0x07, 0x9E, 0x0F, 0xBC, 0x0F, 0x78, 0x1F,
  0x03, 0x00, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7, 0xC3, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xFC, 0xFF,
  0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF8, 0xF0, 0x03, 0xFC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x8E, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xFE,
  0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xBC, 0x0F, 0x81, 0xF7, 0x81, 0xF0,
  0x3C, 0xF0, 0x7F, 0x07, 0x9E, 0x0E, 0xE0, 0xF1, 0xE1, 0xDC, 0x1E, 0x3C,
  0x3B, 0x87, 0x87, 0x87, 0x78, 0xF0, 0xF1, 0xEF, 0x1E, 0x1E, 0x3C, 0xE3,
  0xC1, 0xE7, 0x1C, 0x78, 0x3C, 0xE3, 0x9E, 0x07, 0xBC, 0x7B, 0xC0, 0xF7,
  0x87, 0x78, 0x0E, 0xE0, 0xEF, 0x01, 0xDC, 0x1D, 0xC0, 0x3F, 0x83, 0xB8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0xBE, 0x0F, 0x8F, 0x07, 0x87,
  0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC3, 0xC3,
  0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x07,
  0x9E, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x38,
  0x38, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xFF, 0x8F, 0xFC,
  0x79, 0xF2, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x1F, 0xF9, 0xFF, 0xDF,
  0x9F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x1F, 0x7F, 0xFB, 0xFD,
  0xCF, 0xCE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0xE0, 0xF7, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xC3,
  0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xF7, 0x81, 0xEF, 0x83, 0xDF, 0x07, 0xBF, 0x1F, 0x7F, 0xFC, 0xF7,
  0xF1, 0xC7, 0xC0, 0x03, 0xC0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0xC3, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0x8F, 0x1F,
  0xDE, 0x7F, 0xFC, 0xFF, 0xFB, 0xE1, 0xF7, 0x83, 0xEF, 0x03, 0xDE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0x83, 0xEF,
  0x07, 0xDF, 0x1F, 0x9F, 0xFF, 0x3F, 0xDE, 0x3F, 0x3C, 0x07, 0x80, 0x7F,
  0x83, 0xFF, 0x0F, 0x9E, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x02, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xF0, 0xFE, 0x1F, 0xE1,
  0xF2, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xCF, 0xFC, 0xFF, 0xC1,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x00,
  0x3F, 0xBC, 0xFF, 0xF9, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0xDE, 0x07, 0xBC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x81, 0xEF, 0x03,
  0xDE, 0x0F, 0xBE, 0x3F, 0x3F, 0xFE, 0x7F, 0xBC, 0x7E, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x90, 0x0F, 0x38, 0x3E, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F,
  0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x70, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE, 0x1F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x6F,
  0xFF, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0C, 0x3C, 0x78, 0xF0, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xEF, 0xFF, 0xFD, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7D, 0xE0,
  0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3D, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x83, 0xEF, 0x87, 0x8F, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x3D, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0xE1, 0xEF,
  0xE7, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x87, 0xE3, 0xFF, 0x0F,
  0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x78,
  0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83,
  0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x78, 0x3F,
  0xC0, 0xF0, 0x78, 0x01, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F,
  0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x07,
  0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x1E, 0x3E, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F,
  0x80, 0x01, 0xC1, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x87, 0xDF, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xEF,
  0x03, 0xDF, 0x07, 0xBE, 0x0F, 0x7E, 0x3E, 0xFF, 0xF9, 0xEF, 0xE3, 0xCF,
  0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xBC, 0xFF, 0xF9, 0xFF, 0xF7,
  0xC3, 0xEF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xF7, 0x81, 0xEF, 0x07, 0xDE, 0x0F, 0xBE, 0x3F, 0x3F, 0xFE,
  0x7F, 0xBC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF9, 0xFF, 0x7F, 0xFF,
  0xFE, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xFD, 0xFF, 0xFE,
  0xFF, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF0,
  0x1E, 0x01, 0xC0, 0x3E, 0x0F, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0xFF, 0xBF, 0xEF, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC4, 0xFF, 0x3F,
  0xC7, 0xF0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x8F, 0xDF, 0xFF, 0x7F, 0xBC, 0xFC, 0x70, 0xF0, 0x1E,
  0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x8F, 0x1E, 0x1E,
  0x3C, 0x1C, 0x78, 0x3C, 0xE0, 0x7B, 0xC0, 0x77, 0x80, 0xEF, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x3C,
  0xEE, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x1C,
  0xE7, 0x38, 0x1D, 0xC7, 0x78, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xE0, 0x78, 0x3E, 0x78, 0x78, 0xF1, 0xE0, 0xF3, 0xC1, 0xEF, 0x01,
  0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x81, 0xEF, 0x03, 0xCF, 0x0F, 0x1E, 0x1E, 0x1E, 0x78, 0x3D, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F,
  0x1E, 0x0E, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xFF,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xC3, 0xF0, 0xFC, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x3F, 0x0F, 0x03, 0xF0, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xFC,
  0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x83, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x1F, 0xC0, 0x78, 0x7F, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC3, 0xF8, 0x7E, 0x0F, 0x80,
  0x10, 0x02, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 17, 24, 18, 1, -24 },
  { 80, 14, 28, 17, 1, -26 },
  { 129, 24, 25, 26, 1, -25 },
  { 204, 19, 25, 20, 1, -25 },
  { 264, 4, 9, 8, 2, -24 },
  { 269, 8, 29, 11, 2, -24 },
  { 298, 8, 29, 11, 1, -24 },
  { 327, 14, 14, 16, 1, -26 },
  { 352, 14, 16, 17, 1, -20 },
  { 380, 6, 8, 9, 1, -4 },
  { 386, 8, 4, 10, 1, -11 },
  { 390, 5, 5, 9, 2, -5 },
  { 394, 13, 24, 13, 0, -24 },
  { 433, 14, 25, 17, 1, -25 },
  { 477, 10, 24, 17, 2, -24 },
  { 507, 14, 25, 17, 1, -25 },
  { 551, 14, 25, 17, 1, -25 },
  { 595, 15, 24, 17, 1, -24 },
  { 640, 13, 24, 17, 2, -24 },
  { 679, 14, 25, 17, 1, -25 },
  { 723, 14, 24, 17, 1, -24 },
  { 765, 14, 25, 17, 1, -25 },
  { 809, 14, 25, 17, 1, -25 },
  { 853, 5, 19, 9, 2, -19 },
  { 865, 6, 23, 9, 1, -19 },
  { 883, 14, 16, 17, 1, -20 },
  { 911, 14, 10, 17, 1, -17 },
  { 929, 14, 16, 17, 1, -20 },
  { 957, 12, 25, 13, 0, -25 },
  { 995, 22, 27, 26, 2, -24 },
  { 1070, 19, 24, 19, 0, -24 },
  { 1127, 14, 24, 19, 3, -24 },
  { 1169, 15, 25, 18, 2, -25 },
  { 1216, 16, 24, 20, 3, -24 },
  { 1264, 11, 24, 16, 3, -24 },
  { 1297, 11, 24, 15, 3, -24 },
  { 1330, 16, 25, 21, 2, -25 },
  { 1380, 16, 24, 21, 3, -24 },
  { 1428, 9, 24, 11, 1, -24 },
  { 1455, 9, 31, 9, -2, -24 },
  { 1490, 15, 24, 18, 3, -24 },
  { 1535, 11, 24, 15, 3, -24 },
  { 1568, 22, 24, 27, 3, -24 },
  { 1634, 17, 24, 23, 3, -24 },
  { 1685, 18, 25, 22, 2, -25 },
  { 1742, 13, 24, 18, 3, -24 },
  { 1781, 18, 31, 22, 2, -25 },
  { 1851, 15, 24, 18, 3, -24 },
  { 1896, 13, 25, 16, 1, -25 },
  { 1937, 15, 24, 16, 0, -24 },
  { 1982, 16, 24, 21, 2, -24 },
  { 2030, 18, 24, 18, 0, -24 },
  { 2084, 27, 24, 27, 0, -24 },
  { 2165, 17, 24, 17, 0, -24 },
  { 2216, 17, 24, 17, 0, -24 },
  { 2267, 14, 24, 15, 1, -24 },
  { 2309, 8, 29, 11, 2, -24 },
  { 2338, 13, 24, 13, 0, -24 },
  { 2377, 8, 29, 11, 1, -24 },
  { 2406, 16, 14, 18, 1, -24 },
  { 2434, 14, 2, 14, 0, 3 },
  { 2438, 8, 5, 10, 1, -26 },
  { 2443, 13, 19, 17, 1, -19 },
  { 2474, 15, 26, 18, 2, -26 },
  { 2523, 12, 19, 14, 1, -19 },
  { 2552, 15, 26, 18, 1, -26 },
  { 2601, 14, 19, 16, 1, -19 },
  { 2635, 12, 26, 10, 0, -26 },
  { 2674, 15, 27, 18, 1, -19 },
  { 2725, 14, 26, 18, 2, -26 },
  { 2771, 4, 26, 8, 2, -26 },
  { 2784, 7, 34, 8, -1, -26 },
  { 2814, 15, 26, 17, 2, -26 },
  { 2863, 4, 26, 8, 2, -26 },
  { 2876, 23, 19, 27, 2, -19 },
  { 2931, 14, 19, 18, 2, -19 },
  { 2965, 15, 19, 18, 1, -19 },
  { 3001, 15, 27, 18, 2, -19 },
  { 3052, 15, 27, 18, 1, -19 },
  { 3103, 10, 19, 12, 2, -19 },
  { 3127, 11, 19, 14, 1, -19 },
  { 3154, 10, 22, 11, 1, -22 },
  { 3182, 14, 18, 18, 2, -18 },
  { 3214, 15, 18, 15, 0, -18 },
  { 3248, 24, 18, 24, 0, -18 },
  { 3302, 15, 18, 15, 0, -18 },
  { 3336, 15, 26, 16, 0, -18 },
  { 3385, 11, 18, 13, 1, -18 },
  { 3410, 10, 29, 12, 1, -24 },
  { 3447, 4, 34, 16, 6, -26 },
  { 3464, 11, 29, 12, 1, -24 },
  { 3504, 15, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD34PT7B_H_
