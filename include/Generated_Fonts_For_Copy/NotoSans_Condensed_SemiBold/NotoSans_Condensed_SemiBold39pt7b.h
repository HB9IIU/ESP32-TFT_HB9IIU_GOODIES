#ifndef _NOTOSANS_CONDENSED_SEMIBOLD39PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x01, 0x1E, 0xFF, 0xFF, 0xDE, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3D, 0xF1, 0xEF, 0x8F, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70,
  0xF3, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x87, 0x00, 0x71, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE1, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1E, 0x01, 0xFF, 0xC7, 0xFF, 0xDF, 0xFF, 0x7E,
  0xCE, 0xF1, 0x85, 0xE3, 0x03, 0xC6, 0x07, 0x8C, 0x0F, 0xD8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0D, 0xF0,
  0x19, 0xE0, 0x33, 0xE0, 0x67, 0xE0, 0xDF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xE1, 0xFF, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0x00,
  0x3C, 0x03, 0xF8, 0x03, 0x80, 0x7F, 0xC0, 0x78, 0x07, 0x9E, 0x07, 0x00,
  0x71, 0xE0, 0xF0, 0x07, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0xE0, 0x0F, 0x0E,
  0x1E, 0x00, 0xF0, 0xE1, 0xC0, 0x0F, 0x0E, 0x3C, 0x00, 0xF0, 0xE3, 0x80,
  0x07, 0x0E, 0x78, 0xF8, 0x71, 0xE7, 0x9F, 0xC7, 0x9E, 0x73, 0xFE, 0x3F,
  0xCF, 0x39, 0xE3, 0xFC, 0xE7, 0x8E, 0x1F, 0x9E, 0x78, 0xF0, 0x01, 0xC7,
  0x8F, 0x00, 0x3C, 0x70, 0xF0, 0x03, 0xC7, 0x0F, 0x00, 0x38, 0x70, 0xF0,
  0x07, 0x87, 0x8F, 0x00, 0x70, 0x78, 0xF0, 0x0F, 0x07, 0x8E, 0x00, 0xE0,
  0x39, 0xE0, 0x1E, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x1E, 0x3E,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x0F, 0x8F, 0xFC, 0x3E, 0x7C, 0xF8, 0xF1, 0xF1,
  0xF7, 0xCF, 0x87, 0xDF, 0x3E, 0x0F, 0xF8, 0xF8, 0x1F, 0xE3, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xDF, 0x83, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xBD, 0xEE, 0x73, 0x80,
  0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E,
  0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x43, 0xC1, 0x73, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C, 0x1C, 0x38,
  0x04, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0xCF,
  0x1E, 0x38, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x21, 0xEF,
  0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3,
  0xFF, 0x7D, 0xFF, 0x9F, 0x71, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x78, 0x3E, 0x30, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFE, 0x30, 0x3E, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03,
  0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE6, 0x07, 0xFF,
  0x8F, 0xFF, 0x9F, 0xFF, 0x9E, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0xFF,
  0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x0F, 0x7F, 0x87, 0xFF, 0xE3, 0xFF,
  0xF3, 0xF8, 0x7D, 0xF8, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0x9E, 0x03, 0xEF,
  0x01, 0xF7, 0x80, 0xF3, 0xE0, 0x79, 0xF0, 0x7C, 0x7C, 0x3E, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xEF, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x3E,
  0x7C, 0x1F, 0x1E, 0x0F, 0x0F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xE0, 0x7F, 0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x9E, 0x07, 0xDF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3C, 0xF8, 0x3E, 0x7E, 0x3F,
  0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x37, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xC0, 0x7B, 0xFF, 0xFF, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x7B, 0xFF, 0xFF, 0x78, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF1,
  0xE7, 0xCF, 0x9E, 0x3C, 0x71, 0xE0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x70, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xE0, 0x3C, 0x1E, 0x78, 0x3F, 0xE7, 0x9C, 0x1F, 0xF8, 0xE7, 0x0F, 0x1E,
  0x3B, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xF8, 0x70, 0x70, 0xFE, 0x1C,
  0x1C, 0x3F, 0x8F, 0x07, 0x0F, 0xE3, 0xC1, 0xC3, 0xF8, 0x70, 0x70, 0xEE,
  0x1C, 0x3C, 0x3B, 0x87, 0x8F, 0x1E, 0xF1, 0xF7, 0xE7, 0x3C, 0x3F, 0xBF,
  0xCF, 0x07, 0xE7, 0xE1, 0xE0, 0x40, 0x60, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x0F, 0xCF, 0xFF, 0xC7,
  0xFF, 0x83, 0xFF, 0xF9, 0xF0, 0xFE, 0xF8, 0x1F, 0x7C, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7E, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0x31, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x02, 0x1F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xFB,
  0xE1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF8, 0x0C, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xCF,
  0x80, 0x79, 0xF8, 0x0F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xC0, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xFA, 0x7E, 0xFF, 0xBF, 0xCF, 0xE3,
  0xF0, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E,
  0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFD, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xEF, 0x00, 0xFF, 0xF7, 0x80, 0xF7, 0xFB, 0xC0, 0x7B, 0xFD, 0xE0, 0x3D,
  0xFE, 0x78, 0x1C, 0xFF, 0x3C, 0x1E, 0x7F, 0x9E, 0x0F, 0x3F, 0xC7, 0x87,
  0x1F, 0xE3, 0xC7, 0x8F, 0xF1, 0xE3, 0xC7, 0xF8, 0xF1, 0xE3, 0xFC, 0x3D,
  0xE1, 0xFE, 0x1E, 0xF0, 0xFF, 0x0F, 0x78, 0x7F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0x03, 0xFC,
  0x0F, 0x81, 0xFE, 0x07, 0xC0, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xF7, 0xC0, 0xFF, 0x7C, 0x0F, 0xF3, 0xE0, 0xFF, 0x3E, 0x0F,
  0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF0, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0, 0x7C,
  0xFF, 0x07, 0xCF, 0xF0, 0x3E, 0xFF, 0x03, 0xEF, 0xF0, 0x1E, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xF0, 0x7E, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF8, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3E, 0x3C, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xFB, 0xE0,
  0x3F, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xE0, 0xCF, 0x80,
  0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x00,
  0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x78, 0x3E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F,
  0x01, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xF0,
  0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFB, 0xC0, 0x3E, 0x01, 0xF7, 0x80,
  0x7E, 0x03, 0xCF, 0x81, 0xFC, 0x07, 0x9F, 0x03, 0xF8, 0x1F, 0x3E, 0x07,
  0x70, 0x3E, 0x3C, 0x0E, 0xF0, 0x7C, 0x78, 0x3D, 0xE0, 0xF0, 0xF8, 0x7B,
  0xC1, 0xE1, 0xF0, 0xF7, 0x87, 0xC1, 0xE1, 0xE7, 0x0F, 0x83, 0xC3, 0x8F,
  0x1E, 0x07, 0x8F, 0x1E, 0x3C, 0x0F, 0x9E, 0x3C, 0xF8, 0x1F, 0x3C, 0x79,
  0xF0, 0x1E, 0x78, 0x7B, 0xE0, 0x3D, 0xE0, 0xF7, 0x80, 0x7B, 0xC1, 0xEF,
  0x00, 0xF7, 0x83, 0xDE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE7, 0xC0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F,
  0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xE0, 0x0F, 0x9F,
  0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0,
  0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x7B, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0x80, 0x1F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x1C, 0x3E, 0x10, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x7F, 0x7F, 0xEF, 0x3F, 0xCF,
  0x1F, 0x8F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x40, 0xF3, 0xF8, 0xF7, 0xFC,
  0xFF, 0xFC, 0xFE, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFE, 0xFE, 0xFF, 0xFC, 0xF7, 0xF8,
  0xE3, 0xF0, 0x00, 0x80, 0x7F, 0xC7, 0xFE, 0x7F, 0xF7, 0xE3, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x5F, 0xDE, 0x7F, 0xF3, 0xFF,
  0x87, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x02, 0x0F, 0x1F, 0xCF, 0x3F, 0xEF,
  0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7E, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF,
  0x1F, 0xCF, 0x01, 0x00, 0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC7, 0xCF,
  0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x05,
  0xFC, 0x71, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xF0, 0x3F, 0xC3,
  0xFE, 0x1F, 0xF1, 0xF0, 0x8F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x02, 0x00, 0x1F,
  0xCF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x40, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x41, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xFF, 0xF7, 0x00,
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0x80, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F,
  0x1F, 0xFF, 0xFE, 0xFE, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x3F, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9,
  0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x10, 0x38,
  0xFE, 0x3F, 0x8E, 0x7F, 0xDF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFE, 0xFF, 0xDF,
  0xBE, 0x0F, 0xC3, 0xEF, 0x83, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x3E,
  0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0,
  0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F,
  0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xF0, 0x00, 0x41, 0xC7, 0xF3,
  0x9F, 0xF7, 0xFF, 0xEF, 0xEF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xC0, 0x00, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E,
  0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x40,
  0xE3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x02, 0x00, 0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7E, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0x7F, 0xFF, 0x7F, 0xEF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0xDC, 0x7F, 0x9F, 0xFF, 0xEF, 0xFD, 0xFC, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0x00, 0xFF,
  0x8F, 0xFE, 0xFF, 0xF7, 0xC3, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00,
  0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0xD9, 0xFF, 0x1F, 0xE1, 0xFC, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xCF, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x1E, 0x1E, 0x07,
  0x8F, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x01, 0xEF, 0x03, 0xF0, 0x7D, 0xE0, 0x7E,
  0x0F, 0xBE, 0x1F, 0xC1, 0xE7, 0xC3, 0xF8, 0x3C, 0x78, 0x77, 0x0F, 0x8F,
  0x0E, 0xF1, 0xF1, 0xF1, 0xDE, 0x3C, 0x3E, 0x79, 0xC7, 0x83, 0xCF, 0x38,
  0xF0, 0x79, 0xC7, 0xBE, 0x0F, 0x38, 0xF7, 0x81, 0xE7, 0x1E, 0xF0, 0x1F,
  0xE1, 0xDE, 0x03, 0xFC, 0x3B, 0xC0, 0x7F, 0x07, 0x70, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xF3,
  0xE0, 0x7B, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3D, 0xF0, 0x3E, 0x78,
  0x1E, 0x3E, 0x1F, 0x0F, 0x0F, 0x07, 0xCF, 0x81, 0xFF, 0x80, 0xF8, 0xF8,
  0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07,
  0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0xF0, 0xFC, 0x0F, 0x80, 0xFE, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0x07, 0xF0, 0xFC, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0x80, 0x1C, 0x00, 0xBF, 0xC0,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x1F, 0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 13, 10, 17, 2, -28 },
  { 39, 19, 28, 21, 1, -28 },
  { 106, 15, 32, 19, 2, -30 },
  { 166, 28, 28, 30, 1, -28 },
  { 264, 22, 28, 23, 1, -28 },
  { 341, 5, 10, 9, 2, -28 },
  { 348, 9, 34, 12, 2, -28 },
  { 387, 9, 34, 12, 1, -28 },
  { 426, 16, 16, 18, 1, -30 },
  { 458, 17, 19, 19, 1, -23 },
  { 499, 7, 9, 10, 1, -4 },
  { 507, 10, 5, 12, 1, -13 },
  { 514, 6, 6, 10, 2, -6 },
  { 519, 15, 28, 15, 0, -28 },
  { 572, 16, 28, 19, 1, -28 },
  { 628, 12, 28, 19, 2, -28 },
  { 670, 16, 28, 19, 1, -28 },
  { 726, 16, 28, 19, 1, -28 },
  { 782, 17, 28, 19, 1, -28 },
  { 842, 15, 28, 19, 2, -28 },
  { 895, 17, 28, 19, 1, -28 },
  { 955, 17, 28, 19, 1, -28 },
  { 1015, 17, 28, 19, 1, -28 },
  { 1075, 16, 28, 19, 1, -28 },
  { 1131, 6, 21, 10, 2, -21 },
  { 1147, 7, 26, 10, 1, -21 },
  { 1170, 17, 18, 19, 1, -23 },
  { 1209, 17, 11, 19, 1, -19 },
  { 1233, 17, 18, 19, 1, -23 },
  { 1272, 14, 28, 15, 0, -28 },
  { 1321, 26, 31, 29, 2, -28 },
  { 1422, 21, 28, 21, 0, -28 },
  { 1496, 17, 28, 22, 3, -28 },
  { 1556, 17, 28, 20, 2, -28 },
  { 1616, 18, 28, 23, 3, -28 },
  { 1679, 13, 28, 18, 3, -28 },
  { 1725, 13, 28, 18, 3, -28 },
  { 1771, 19, 28, 24, 2, -28 },
  { 1838, 18, 28, 24, 3, -28 },
  { 1901, 10, 28, 13, 1, -28 },
  { 1936, 10, 36, 11, -2, -28 },
  { 1981, 18, 28, 21, 3, -28 },
  { 2044, 13, 28, 17, 3, -28 },
  { 2090, 25, 28, 31, 3, -28 },
  { 2178, 20, 28, 26, 3, -28 },
  { 2248, 21, 28, 25, 2, -28 },
  { 2322, 16, 28, 20, 3, -28 },
  { 2378, 21, 35, 25, 2, -28 },
  { 2470, 18, 28, 21, 3, -28 },
  { 2533, 15, 28, 18, 1, -28 },
  { 2586, 16, 28, 18, 1, -28 },
  { 2642, 18, 28, 24, 3, -28 },
  { 2705, 21, 28, 21, 0, -28 },
  { 2779, 31, 28, 31, 0, -28 },
  { 2888, 20, 28, 20, 0, -28 },
  { 2958, 19, 28, 19, 0, -28 },
  { 3025, 16, 28, 17, 1, -28 },
  { 3081, 8, 34, 12, 3, -28 },
  { 3115, 15, 28, 15, 0, -28 },
  { 3168, 9, 34, 12, 1, -28 },
  { 3207, 18, 17, 20, 1, -28 },
  { 3246, 16, 3, 16, 0, 3 },
  { 3252, 8, 6, 12, 2, -30 },
  { 3258, 16, 22, 19, 1, -22 },
  { 3302, 16, 30, 21, 3, -30 },
  { 3362, 13, 22, 16, 2, -22 },
  { 3398, 16, 30, 21, 2, -30 },
  { 3458, 15, 22, 19, 2, -22 },
  { 3500, 13, 30, 12, 0, -30 },
  { 3549, 16, 31, 21, 2, -22 },
  { 3611, 15, 30, 21, 3, -30 },
  { 3668, 5, 29, 10, 2, -29 },
  { 3687, 8, 38, 10, -1, -29 },
  { 3725, 16, 30, 19, 3, -30 },
  { 3785, 4, 30, 10, 3, -30 },
  { 3800, 26, 22, 31, 3, -22 },
  { 3872, 15, 22, 21, 3, -22 },
  { 3914, 16, 22, 20, 2, -22 },
  { 3958, 16, 31, 21, 3, -22 },
  { 4020, 16, 31, 21, 2, -22 },
  { 4082, 11, 22, 14, 3, -22 },
  { 4113, 13, 22, 16, 1, -22 },
  { 4149, 11, 26, 13, 1, -26 },
  { 4185, 16, 21, 21, 2, -21 },
  { 4227, 18, 21, 18, 0, -21 },
  { 4275, 27, 21, 28, 0, -21 },
  { 4346, 17, 21, 18, 0, -21 },
  { 4391, 18, 30, 18, 0, -21 },
  { 4459, 13, 21, 15, 1, -21 },
  { 4494, 12, 34, 14, 1, -28 },
  { 4545, 4, 39, 18, 7, -30 },
  { 4565, 12, 34, 14, 1, -28 },
  { 4616, 17, 6, 19, 1, -17 },
};

const GFXfont NotoSans_Condensed_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD39PT7B_H_
