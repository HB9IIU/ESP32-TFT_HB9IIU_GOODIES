#ifndef _NOTOSANS_CONDENSED_SEMIBOLD47PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0x00, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xEF,
  0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1,
  0xF7, 0xC1, 0xEF, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC1, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x3C, 0x3C, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x9C, 0x33, 0xF3, 0x80, 0x7C, 0x70, 0x0F,
  0x8E, 0x01, 0xF9, 0xC0, 0x1F, 0x38, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3B, 0xF0, 0x07, 0x3F, 0x00, 0xE3, 0xE0, 0x1C, 0x7C, 0x03, 0x8F, 0xC0,
  0x73, 0xFF, 0x0E, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0xE0, 0x03, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x01, 0xE0, 0x0F, 0x9F, 0x01, 0xF0,
  0x07, 0xC7, 0x80, 0xF0, 0x03, 0xC3, 0xE0, 0x78, 0x01, 0xE1, 0xF0, 0x78,
  0x00, 0xF0, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x1E,
  0x00, 0x1E, 0x0F, 0x1F, 0x00, 0x0F, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0xC7,
  0x83, 0x03, 0xC3, 0xE7, 0x87, 0xF1, 0xE1, 0xE3, 0xC7, 0xFC, 0x78, 0xF3,
  0xE7, 0xFE, 0x3F, 0xF9, 0xE7, 0xCF, 0x8F, 0xF9, 0xF3, 0xC3, 0xC7, 0xF8,
  0xF1, 0xE1, 0xE0, 0xF8, 0x78, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x7C, 0x00,
  0x3C, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x1E, 0x1F, 0x0F, 0x80,
  0x1F, 0x07, 0x87, 0xC0, 0x0F, 0x03, 0xC3, 0xE0, 0x07, 0x81, 0xE1, 0xE0,
  0x07, 0x80, 0xF0, 0xF0, 0x03, 0xC0, 0x7C, 0x78, 0x03, 0xE0, 0x1F, 0xFC,
  0x01, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x81, 0xF8, 0x7F, 0xF8, 0x3E, 0x1F, 0xBF, 0x0F, 0xC7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x3F, 0x3E, 0x1F, 0x07, 0xFF, 0xC3, 0xE0, 0x7F, 0xF8, 0xFC, 0x07,
  0xFE, 0x1F, 0x80, 0x7F, 0xC1, 0xF0, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x9F, 0xC0, 0xFF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x81, 0xE0, 0x9E,
  0x3C, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x03, 0xE7, 0xC0, 0xF8, 0xFC, 0x3F,
  0x0F, 0x81, 0xE1, 0xE0, 0x08, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xE3, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0x7C, 0x07,
  0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8,
  0x7F, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xE7, 0xDE, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xF8, 0x3F, 0x8C, 0x03,
  0xF1, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0, 0x3F, 0x88, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE8,
  0x01, 0xFD, 0xF0, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xEC, 0x01, 0xFD, 0xF0, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x81, 0x01,
  0xF3, 0xFC, 0x3E, 0xFF, 0xC7, 0xDF, 0xFC, 0xFF, 0xFF, 0xDF, 0xE1, 0xFB,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBF, 0x03, 0xF7,
  0xE0, 0xFC, 0x7F, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xFB, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xF1, 0xF8, 0x7F, 0x7F,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x9F, 0xC7, 0xE1, 0xFD, 0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFC, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xEF, 0x9F, 0xFD, 0xF1,
  0xFF, 0x3E, 0x1F, 0xCF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x81, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x7B, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0x3C, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3C, 0x78, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFF, 0xF1, 0xC0, 0xFC, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x07, 0xF0, 0x78, 0xF0,
  0x3F, 0xF8, 0xFB, 0xE0, 0xFF, 0xF0, 0xF7, 0x83, 0xFF, 0xE1, 0xEF, 0x07,
  0x83, 0xC3, 0xDE, 0x1F, 0x0F, 0x87, 0xFC, 0x3C, 0x1F, 0x0F, 0xF8, 0x78,
  0x3E, 0x1F, 0xE1, 0xF0, 0x7C, 0x3F, 0xC3, 0xE0, 0xF8, 0x7F, 0x87, 0xC1,
  0xF0, 0xFF, 0x0F, 0x83, 0xC1, 0xFE, 0x1F, 0x07, 0x83, 0xFC, 0x3E, 0x0F,
  0x07, 0xF8, 0x3C, 0x3F, 0x1E, 0xF8, 0x7C, 0x7E, 0x3C, 0xF0, 0xFF, 0xDF,
  0xF9, 0xE0, 0xFF, 0xBF, 0xE3, 0xC0, 0xFE, 0x3F, 0x87, 0xC0, 0x70, 0x1C,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x3F, 0x7E, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x7E, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0,
  0x38, 0x7F, 0x00, 0x47, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x87, 0xFE, 0x3F, 0x01, 0xFE, 0x7E,
  0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xCF,
  0xC0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x1C, 0x1F, 0xC0, 0x04, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0x7C, 0x07, 0xFF, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x80,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xF9, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFE, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xDF, 0xEF,
  0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x01, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0xFE, 0x7C, 0x07, 0xE3, 0xE0,
  0x7E, 0x1F, 0x07, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81,
  0xF1, 0xF8, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7E,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFE, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3D, 0xFF, 0xBC, 0x01, 0xF7, 0xFE, 0xF8, 0x07, 0xDF, 0xFB,
  0xE0, 0x1E, 0x7F, 0xEF, 0x80, 0xF9, 0xFF, 0x9E, 0x03, 0xE7, 0xFE, 0x7C,
  0x0F, 0x9F, 0xF9, 0xF0, 0x3C, 0x7F, 0xE3, 0xC1, 0xF1, 0xFF, 0x8F, 0x87,
  0xC7, 0xFE, 0x3E, 0x1E, 0x1F, 0xF8, 0xF8, 0xF8, 0x7F, 0xE1, 0xE3, 0xE1,
  0xFF, 0x87, 0xCF, 0x07, 0xFE, 0x1F, 0x3C, 0x1F, 0xF8, 0x3D, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x01, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x03,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xF0, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFB, 0xE0, 0x3F, 0xFB, 0xF0, 0x3F, 0xF9, 0xF0,
  0x3F, 0xF9, 0xF8, 0x3F, 0xF8, 0xF8, 0x3F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC,
  0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xF8, 0x3F, 0x3F, 0xF8, 0x3F,
  0x3F, 0xF8, 0x1F, 0xBF, 0xF8, 0x1F, 0xBF, 0xF8, 0x0F, 0xDF, 0xF8, 0x0F,
  0xDF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x9F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC3, 0xFE, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC,
  0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0x03,
  0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC1,
  0xCF, 0xC0, 0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x01,
  0xF8, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x00, 0x7E, 0x7C, 0x01, 0xFC,
  0x01, 0xF9, 0xF0, 0x07, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F, 0x1F,
  0x80, 0x7F, 0x80, 0x7C, 0x3E, 0x03, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3D, 0xF0, 0x3F, 0x0F, 0xC0, 0xF7, 0xC0, 0xF8, 0x3F,
  0x03, 0xDF, 0x03, 0xE0, 0x7C, 0x1F, 0x3C, 0x1F, 0x81, 0xF0, 0x7C, 0xF0,
  0x7E, 0x07, 0xE1, 0xF3, 0xE1, 0xF8, 0x1F, 0x87, 0x8F, 0x87, 0xC0, 0x3E,
  0x3E, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x78, 0xFC, 0x03, 0xE3, 0xE1, 0xF3,
  0xF0, 0x0F, 0xCF, 0x87, 0xCF, 0x80, 0x3F, 0x3C, 0x1F, 0x3E, 0x00, 0x7D,
  0xF0, 0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xDF,
  0x80, 0x1F, 0x78, 0x0F, 0xFC, 0x00, 0x3D, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07,
  0xE7, 0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00,
  0x78, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x9E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0xF0,
  0x0F, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x3F,
  0x86, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xDF, 0x7F, 0xE3, 0xC7, 0xF0, 0xF0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x7C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF,
  0xF8, 0xF9, 0xFF, 0x8F, 0x8F, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0x02, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x01,
  0x7F, 0x8F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xE3, 0xF0, 0xFF, 0x3F, 0x1F, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0x1F,
  0xF9, 0xF0, 0x7F, 0x1F, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xF9, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x04, 0x7F, 0x03, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xF9, 0xF3, 0xFF, 0xDF,
  0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xF1, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE6, 0x00, 0x7E, 0x7F, 0x3F,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE1,
  0xF8, 0x7C, 0xFF, 0x8F, 0xBF, 0xF9, 0xF7, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xF0, 0xFB, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07,
  0xDB, 0xFB, 0xFF, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xF9, 0xF0,
  0x0F, 0xBF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xE7,
  0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x03, 0xE1, 0xF3, 0xFE, 0x1F,
  0xF3, 0xEF, 0xFE, 0x7F, 0xF7, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xFE, 0x03, 0xF0, 0x1F,
  0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFF,
  0xE0, 0x3E, 0x01, 0xFF, 0xC0, 0x7C, 0x03, 0xFF, 0x80, 0xF8, 0x07, 0xFF,
  0x01, 0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x1F, 0xFC, 0x07, 0xC0, 0x3F, 0xF8,
  0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC0,
  0x7C, 0x03, 0xFF, 0x80, 0xF8, 0x07, 0xFF, 0x01, 0xF0, 0x0F, 0xFE, 0x03,
  0xE0, 0x1F, 0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0x80, 0x7C, 0xF0, 0x7C,
  0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xE0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xF0, 0x7C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF,
  0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFE, 0x07, 0xEF, 0xF1, 0xFC,
  0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9, 0xFF, 0x8F, 0x8F, 0xE0, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xF9, 0xF3, 0xFF, 0xDF,
  0x3F, 0xFF, 0xF7, 0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF7, 0xC0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0x7F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0xF0,
  0x7F, 0xC3, 0xEF, 0x9F, 0xBE, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0xF9, 0xFF, 0xFB, 0xFF, 0xEF, 0xE7, 0xDF, 0x01, 0xBE, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE7, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x47, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F, 0xDF, 0xFF, 0xFB,
  0xFF, 0xDF, 0x3F, 0xF3, 0xE3, 0xFC, 0x7C, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xDF, 0x00, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0,
  0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xBE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xBE, 0x03, 0xF8, 0x0F,
  0xDF, 0x01, 0xFC, 0x07, 0xCF, 0x80, 0xFE, 0x03, 0xE7, 0xE0, 0x7F, 0x01,
  0xF1, 0xF0, 0x7F, 0xC1, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0x7C, 0x1E, 0xF0,
  0x7C, 0x3F, 0x0F, 0x78, 0x3E, 0x1F, 0x87, 0xBE, 0x3F, 0x07, 0xC7, 0xCF,
  0x1F, 0x03, 0xE3, 0xC7, 0x8F, 0x81, 0xF1, 0xE3, 0xC7, 0xC0, 0xFC, 0xF1,
  0xE7, 0xE0, 0x3E, 0x78, 0xFB, 0xE0, 0x1F, 0x7C, 0x3D, 0xF0, 0x0F, 0xBC,
  0x1E, 0xF8, 0x07, 0xDE, 0x0F, 0x7C, 0x01, 0xEF, 0x07, 0xBC, 0x00, 0xFF,
  0x83, 0xDE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x3F, 0x3E, 0x01, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xFC, 0x03, 0xE7,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07,
  0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x6F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x03, 0xF0, 0x1F,
  0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0xC3,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x83,
  0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x17, 0xFE, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFE, 0x80, 0x0F,
  0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 35, 12, 3, -34 },
  { 28, 15, 13, 20, 3, -34 },
  { 53, 23, 34, 25, 1, -34 },
  { 151, 19, 39, 23, 2, -36 },
  { 244, 33, 34, 36, 2, -34 },
  { 385, 27, 34, 28, 1, -34 },
  { 500, 5, 13, 11, 3, -34 },
  { 509, 12, 41, 15, 2, -34 },
  { 571, 12, 41, 15, 1, -34 },
  { 633, 19, 19, 22, 1, -36 },
  { 679, 19, 23, 23, 2, -28 },
  { 734, 7, 11, 12, 2, -5 },
  { 744, 12, 5, 14, 1, -15 },
  { 752, 6, 8, 12, 3, -7 },
  { 758, 17, 34, 19, 1, -34 },
  { 831, 19, 34, 23, 2, -34 },
  { 912, 13, 34, 23, 3, -34 },
  { 968, 19, 34, 23, 2, -34 },
  { 1049, 19, 34, 23, 2, -34 },
  { 1130, 21, 34, 23, 1, -34 },
  { 1220, 19, 34, 23, 2, -34 },
  { 1301, 19, 34, 23, 2, -34 },
  { 1382, 20, 34, 23, 1, -34 },
  { 1467, 19, 34, 23, 2, -34 },
  { 1548, 19, 34, 23, 2, -34 },
  { 1629, 6, 27, 12, 3, -26 },
  { 1650, 7, 32, 12, 2, -26 },
  { 1678, 20, 22, 23, 1, -28 },
  { 1733, 19, 13, 23, 2, -23 },
  { 1764, 19, 22, 23, 2, -28 },
  { 1817, 17, 35, 18, 0, -34 },
  { 1892, 31, 38, 36, 2, -34 },
  { 2040, 26, 34, 26, 0, -34 },
  { 2151, 21, 34, 26, 3, -34 },
  { 2241, 21, 34, 24, 2, -34 },
  { 2331, 23, 34, 28, 3, -34 },
  { 2429, 15, 34, 22, 4, -34 },
  { 2493, 15, 34, 21, 4, -34 },
  { 2557, 24, 34, 29, 2, -34 },
  { 2659, 22, 34, 29, 4, -34 },
  { 2753, 13, 34, 15, 1, -34 },
  { 2809, 12, 44, 13, -3, -34 },
  { 2875, 21, 34, 25, 4, -34 },
  { 2965, 17, 34, 21, 3, -34 },
  { 3038, 30, 34, 38, 4, -34 },
  { 3166, 24, 34, 31, 4, -34 },
  { 3268, 26, 34, 30, 2, -34 },
  { 3379, 20, 34, 24, 3, -34 },
  { 3464, 26, 42, 30, 2, -34 },
  { 3601, 22, 34, 25, 3, -34 },
  { 3695, 18, 34, 22, 2, -34 },
  { 3772, 20, 34, 22, 1, -34 },
  { 3857, 22, 34, 29, 3, -34 },
  { 3951, 25, 34, 25, 0, -34 },
  { 4058, 38, 34, 38, 0, -34 },
  { 4220, 24, 34, 24, 0, -34 },
  { 4322, 23, 34, 23, 0, -34 },
  { 4420, 19, 34, 21, 1, -34 },
  { 4501, 11, 41, 15, 3, -34 },
  { 4558, 17, 34, 19, 1, -34 },
  { 4631, 11, 41, 15, 1, -34 },
  { 4688, 22, 21, 24, 1, -34 },
  { 4746, 20, 3, 20, 0, 4 },
  { 4754, 11, 8, 14, 2, -36 },
  { 4765, 18, 26, 23, 2, -26 },
  { 4824, 20, 36, 25, 3, -36 },
  { 4914, 16, 26, 20, 2, -26 },
  { 4966, 20, 36, 25, 2, -36 },
  { 5056, 19, 26, 23, 2, -26 },
  { 5118, 15, 36, 14, 1, -36 },
  { 5186, 20, 37, 25, 2, -26 },
  { 5279, 19, 36, 25, 3, -36 },
  { 5365, 6, 35, 12, 3, -35 },
  { 5392, 11, 46, 12, -2, -35 },
  { 5456, 20, 36, 23, 3, -36 },
  { 5546, 6, 36, 12, 3, -36 },
  { 5573, 31, 26, 37, 3, -26 },
  { 5674, 19, 26, 25, 3, -26 },
  { 5736, 20, 26, 24, 2, -26 },
  { 5801, 20, 37, 25, 3, -26 },
  { 5894, 20, 37, 25, 2, -26 },
  { 5987, 14, 26, 17, 3, -26 },
  { 6033, 15, 26, 19, 2, -26 },
  { 6082, 14, 31, 16, 1, -31 },
  { 6137, 19, 26, 25, 3, -26 },
  { 6199, 21, 26, 21, 0, -26 },
  { 6268, 33, 26, 33, 0, -26 },
  { 6376, 21, 26, 21, 0, -26 },
  { 6445, 21, 37, 21, 0, -26 },
  { 6543, 16, 26, 18, 1, -26 },
  { 6595, 14, 41, 17, 1, -34 },
  { 6667, 4, 47, 22, 9, -36 },
  { 6691, 14, 41, 17, 2, -34 },
  { 6763, 20, 7, 23, 1, -20 },
};

const GFXfont NotoSans_Condensed_SemiBold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD47PT7B_H_
