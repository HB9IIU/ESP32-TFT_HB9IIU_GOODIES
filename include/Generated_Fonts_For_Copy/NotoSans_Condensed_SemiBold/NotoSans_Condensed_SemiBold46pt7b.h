#ifndef _NOTOSANS_CONDENSED_SEMIBOLD46PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0xFC, 0x7E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB,
  0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x0F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7E, 0xE7, 0xBF, 0x38, 0x2F,
  0x8E, 0x03, 0xE3, 0x80, 0xF8, 0xE0, 0x3F, 0x38, 0x07, 0xEE, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x0E, 0xFC, 0x03, 0x9F, 0x00, 0xE7, 0xC0, 0x39, 0xF8,
  0x0E, 0x7F, 0x83, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F,
  0xE0, 0x0F, 0x00, 0x7F, 0xE0, 0x1E, 0x00, 0xF8, 0xF0, 0x1E, 0x00, 0xF0,
  0xF0, 0x3E, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0,
  0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0xF0, 0x00, 0xF0,
  0xF8, 0xF0, 0x00, 0xF0, 0xF1, 0xF0, 0x00, 0xF0, 0xF1, 0xE1, 0xF0, 0xF0,
  0xF1, 0xE7, 0xF8, 0xF8, 0xF3, 0xC7, 0xFC, 0x7F, 0xE3, 0xCF, 0xFE, 0x7F,
  0xE7, 0x8F, 0x1E, 0x3F, 0xC7, 0x9F, 0x1F, 0x1F, 0x8F, 0x9F, 0x1F, 0x00,
  0x0F, 0x1E, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00,
  0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00,
  0x7C, 0x1E, 0x1F, 0x00, 0x78, 0x1F, 0x1F, 0x00, 0x78, 0x0F, 0x1E, 0x00,
  0xF0, 0x0F, 0xBE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x07, 0xFC, 0x01,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0x87, 0xFF,
  0x07, 0xE3, 0xFF, 0xE1, 0xF9, 0xFD, 0xF8, 0x7C, 0x7E, 0x3F, 0x3F, 0x1F,
  0x07, 0xEF, 0xC7, 0xC0, 0xFF, 0xE3, 0xF0, 0x3F, 0xF8, 0xFC, 0x07, 0xFC,
  0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xF0, 0x7F, 0x8F,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x7E, 0x07,
  0xFC, 0x1F, 0xC0, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE,
  0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0xC1, 0xE1, 0x9F, 0xB9, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x07,
  0xC7, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0x00, 0xC1, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBE, 0x7C, 0xF9, 0xE3, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE2, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xE0, 0x3E, 0xFC, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3F, 0x0F, 0xC3,
  0xF3, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF,
  0xDF, 0xFC, 0xFB, 0xC7, 0xCC, 0x3E, 0x41, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0x7F, 0x9E, 0x07, 0xE2, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x7F, 0x9C, 0x07, 0xE2, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7,
  0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7D, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x88, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0xF8, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFE, 0x18, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x8F,
  0xC1, 0xF3, 0xFE, 0x3E, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x3F, 0xDF, 0xC1,
  0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07,
  0xE3, 0xF1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE1, 0xF8,
  0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xF3, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x1F, 0xCF,
  0xC0, 0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xEF, 0xE0, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xF7, 0xF9, 0xF8, 0x3F, 0x3F, 0x03, 0xE7,
  0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x3F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFB, 0xE0, 0xFE, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x84, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x3C, 0xFD,
  0xFB, 0xF7, 0xEF, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBE, 0x7C, 0xFB, 0xE7, 0xCF, 0x9E,
  0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xE7, 0xF1, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x0F, 0xF8, 0x78, 0xF0, 0x7F, 0xF0,
  0xF3, 0xC1, 0xFF, 0xE1, 0xE7, 0x83, 0xE3, 0xC3, 0xCF, 0x0F, 0x87, 0x83,
  0xFE, 0x1E, 0x0F, 0x07, 0xF8, 0x7C, 0x1E, 0x0F, 0xF0, 0xF0, 0x3C, 0x1F,
  0xE1, 0xE0, 0x78, 0x3F, 0xC3, 0xC0, 0xF0, 0x7F, 0x87, 0x81, 0xE1, 0xFF,
  0x0F, 0x03, 0xC3, 0xDE, 0x1E, 0x0F, 0x87, 0xBC, 0x3E, 0x1F, 0x0F, 0x78,
  0x3C, 0x3E, 0x3C, 0xF8, 0x7F, 0xFF, 0xF8, 0xF0, 0x7F, 0x9F, 0xE1, 0xE0,
  0x7F, 0x1F, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x80, 0x0F, 0xE0,
  0x0F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC1,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xE0, 0x10, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x21, 0xFF, 0xBF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0x03, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xDF, 0xC3, 0xFC, 0x01, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF1,
  0xFF, 0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0x1F, 0xCF, 0x80, 0xFC, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0,
  0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7D, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xF1, 0xF0, 0x1F, 0x8F,
  0x80, 0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xF8, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0xF0, 0x01, 0xFF,
  0xF7, 0xC0, 0x1F, 0xFF, 0xBE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xBF, 0xF7,
  0x80, 0x7D, 0xFF, 0xBE, 0x03, 0xEF, 0xFD, 0xF0, 0x1E, 0x7F, 0xE7, 0x80,
  0xF3, 0xFF, 0x3E, 0x0F, 0x9F, 0xF9, 0xF0, 0x7C, 0xFF, 0xCF, 0x83, 0xC7,
  0xFE, 0x3C, 0x3E, 0x3F, 0xF1, 0xF1, 0xF1, 0xFF, 0x8F, 0x8F, 0x0F, 0xFC,
  0x3C, 0xF8, 0x7F, 0xE1, 0xF7, 0xC3, 0xFF, 0x0F, 0xBC, 0x1F, 0xF8, 0x7D,
  0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0x81,
  0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x7E, 0x03, 0xFF,
  0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF7, 0xC0, 0x3F, 0xEF, 0xC0, 0x7F,
  0xCF, 0x80, 0xFF, 0x9F, 0x81, 0xFF, 0x9F, 0x03, 0xFF, 0x3F, 0x07, 0xFE,
  0x3E, 0x0F, 0xFC, 0x7E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xFC, 0x7F, 0xE1,
  0xF8, 0xFF, 0xC1, 0xF9, 0xFF, 0x83, 0xF3, 0xFF, 0x03, 0xF7, 0xFE, 0x07,
  0xEF, 0xFC, 0x07, 0xDF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFC, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC1, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x0F, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xF0, 0x3B, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD,
  0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0xCF, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC1,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0x00,
  0x7E, 0x00, 0x7C, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F,
  0x3E, 0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F,
  0xC0, 0x7C, 0x3E, 0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F, 0x0F,
  0x80, 0xF7, 0x81, 0xF8, 0x7E, 0x0F, 0xBC, 0x0F, 0xC1, 0xF0, 0x7D, 0xF0,
  0x7C, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0x7C, 0x1E, 0x7C, 0x3F, 0x03, 0xE1,
  0xF1, 0xE1, 0xF8, 0x1F, 0x8F, 0x8F, 0x0F, 0x80, 0x7C, 0x7C, 0x7C, 0x7C,
  0x03, 0xE3, 0xC3, 0xE3, 0xE0, 0x1F, 0x1E, 0x0F, 0x3F, 0x00, 0xF9, 0xF0,
  0x79, 0xF8, 0x03, 0xEF, 0x83, 0xEF, 0x80, 0x1F, 0x7C, 0x1F, 0x7C, 0x00,
  0xFB, 0xC0, 0xFB, 0xE0, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x1E,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07,
  0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0xC0, 0x07, 0xCF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0,
  0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x3C,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1C, 0x1F, 0x84, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0x7D, 0xFF, 0x9F, 0x3F, 0xC7, 0xC0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE3, 0xF8, 0x7C, 0xFF, 0x8F, 0xBF, 0xF9, 0xFF, 0xFF, 0xBF, 0xC7, 0xF7,
  0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xBF,
  0xC3, 0xF7, 0xFF, 0xFE, 0xFB, 0xFF, 0x9F, 0x7F, 0xE3, 0xC3, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x0E, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x01, 0x7F, 0x07, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x3F, 0x8F, 0x8F, 0xFD, 0xF3, 0xFF, 0xBE, 0x7F, 0xFF, 0xDF,
  0xC7, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xFC,
  0x0F, 0xDF, 0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0x3C, 0x3F,
  0xC7, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3,
  0xE0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x23, 0xF0, 0x18, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFC, 0xC3,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xF1, 0xE3, 0xFF,
  0x3C, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFE, 0xFC, 0x0F, 0xDF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFE, 0xF8, 0xFF, 0xDF, 0x0F, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xD8, 0x03, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xE3, 0xEF,
  0xFC, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7C, 0x33, 0xEF, 0xFF, 0xFF, 0xE3, 0x00, 0x00,
  0x0F, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x03, 0x03, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0xBF,
  0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xEF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C,
  0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F,
  0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xFE, 0x0F, 0xF1,
  0xE7, 0xFE, 0x3F, 0xF3, 0xEF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF1, 0xFF, 0x9F, 0xDF, 0xC1, 0xFC, 0x1F, 0xBF, 0x03, 0xF8, 0x1F, 0xFE,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xF0, 0x0F, 0x80, 0xFF, 0xF0,
  0x1F, 0x01, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0x80, 0x7C, 0x07, 0xFF, 0x00,
  0xF8, 0x0F, 0xFE, 0x01, 0xF0, 0x1F, 0xFC, 0x03, 0xE0, 0x3F, 0xF8, 0x07,
  0xC0, 0x7F, 0xF0, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0x3E,
  0x03, 0xFF, 0x80, 0x7C, 0x07, 0xFF, 0x00, 0xF8, 0x0F, 0xFE, 0x01, 0xF0,
  0x1F, 0xFC, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x7E, 0xF0, 0xFE, 0x3C,
  0xFF, 0xCF, 0xBF, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0xFE, 0x1F,
  0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF1, 0xFD, 0xFC, 0x1F, 0xBF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xEF, 0xF1, 0xFD, 0xFF,
  0xFF, 0xBE, 0xFF, 0xE7, 0xCF, 0xF8, 0xF8, 0xFE, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xF1, 0xE3, 0xFF, 0x3C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7, 0xF1, 0xFE, 0xFC,
  0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xF0,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFE, 0xF8, 0xFF, 0xDF, 0x0F, 0xE3, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0xF0, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xEF, 0xC1, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x47,
  0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xBC, 0xFF, 0xCF,
  0x1F, 0xE3, 0xC0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0xFC,
  0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x7C, 0x07, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0,
  0x3E, 0x7E, 0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0x78,
  0x7E, 0x3E, 0x0F, 0x78, 0x7C, 0x3F, 0x1E, 0x78, 0x7C, 0x1F, 0x1E, 0x78,
  0x7C, 0x1F, 0x1E, 0x78, 0xFC, 0x1F, 0x1E, 0x3C, 0xF8, 0x1F, 0x1E, 0x3C,
  0xF8, 0x0F, 0xBC, 0x3C, 0xF8, 0x0F, 0xBC, 0x3C, 0xF8, 0x0F, 0xBC, 0x3D,
  0xF0, 0x0F, 0xBC, 0x1D, 0xF0, 0x0F, 0xBC, 0x1F, 0xF0, 0x07, 0xB8, 0x1F,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF7, 0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xF0, 0x7C, 0x1F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFD, 0xF0, 0x0F, 0x9F,
  0x81, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0,
  0x3F, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x87, 0xE0,
  0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x0F, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x0E, 0x00, 0x13, 0xFC, 0x01, 0x7F,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 34, 12, 3, -33 },
  { 27, 15, 12, 20, 2, -33 },
  { 50, 23, 33, 25, 1, -33 },
  { 145, 18, 38, 22, 2, -35 },
  { 231, 32, 33, 36, 2, -33 },
  { 363, 26, 33, 27, 1, -33 },
  { 471, 6, 12, 11, 2, -33 },
  { 480, 11, 40, 14, 2, -33 },
  { 535, 11, 40, 14, 1, -33 },
  { 590, 19, 18, 21, 1, -35 },
  { 633, 19, 22, 22, 2, -27 },
  { 686, 7, 11, 12, 2, -5 },
  { 696, 12, 5, 14, 1, -15 },
  { 704, 6, 7, 12, 3, -6 },
  { 710, 18, 33, 18, 0, -33 },
  { 785, 19, 33, 22, 2, -33 },
  { 864, 13, 33, 22, 3, -33 },
  { 918, 18, 33, 22, 2, -33 },
  { 993, 18, 33, 22, 2, -33 },
  { 1068, 21, 33, 22, 1, -33 },
  { 1155, 18, 33, 22, 2, -33 },
  { 1230, 19, 33, 22, 2, -33 },
  { 1309, 20, 33, 22, 1, -33 },
  { 1392, 19, 33, 22, 2, -33 },
  { 1471, 19, 33, 22, 2, -33 },
  { 1550, 6, 26, 12, 3, -25 },
  { 1570, 7, 31, 12, 2, -25 },
  { 1598, 20, 23, 22, 1, -28 },
  { 1656, 19, 14, 22, 2, -23 },
  { 1690, 19, 23, 22, 2, -28 },
  { 1745, 17, 34, 18, 0, -33 },
  { 1818, 31, 37, 35, 2, -33 },
  { 1962, 25, 33, 25, 0, -33 },
  { 2066, 20, 33, 25, 3, -33 },
  { 2149, 21, 33, 24, 2, -33 },
  { 2236, 22, 33, 28, 3, -33 },
  { 2327, 15, 33, 21, 4, -33 },
  { 2389, 15, 33, 21, 4, -33 },
  { 2451, 23, 33, 28, 2, -33 },
  { 2546, 21, 33, 29, 4, -33 },
  { 2633, 12, 33, 15, 1, -33 },
  { 2683, 12, 42, 12, -3, -33 },
  { 2746, 21, 33, 25, 4, -33 },
  { 2833, 16, 33, 20, 3, -33 },
  { 2899, 29, 33, 37, 4, -33 },
  { 3019, 23, 33, 31, 4, -33 },
  { 3114, 25, 33, 29, 2, -33 },
  { 3218, 19, 33, 24, 3, -33 },
  { 3297, 25, 41, 29, 2, -33 },
  { 3426, 21, 33, 25, 3, -33 },
  { 3513, 17, 33, 21, 2, -33 },
  { 3584, 19, 33, 21, 1, -33 },
  { 3663, 22, 33, 28, 3, -33 },
  { 3754, 24, 33, 24, 0, -33 },
  { 3853, 37, 33, 37, 0, -33 },
  { 4006, 23, 33, 23, 0, -33 },
  { 4101, 23, 33, 23, 0, -33 },
  { 4196, 19, 33, 21, 1, -33 },
  { 4275, 10, 40, 15, 3, -33 },
  { 4325, 18, 33, 18, 0, -33 },
  { 4400, 11, 40, 15, 1, -33 },
  { 4455, 22, 20, 24, 1, -33 },
  { 4510, 19, 3, 19, 0, 4 },
  { 4518, 10, 7, 14, 2, -35 },
  { 4527, 18, 25, 22, 2, -25 },
  { 4584, 19, 35, 24, 3, -35 },
  { 4668, 16, 25, 19, 2, -25 },
  { 4718, 19, 35, 24, 2, -35 },
  { 4802, 19, 25, 22, 2, -25 },
  { 4862, 15, 35, 14, 1, -35 },
  { 4928, 19, 36, 24, 2, -25 },
  { 5014, 18, 35, 24, 3, -35 },
  { 5093, 6, 35, 11, 3, -35 },
  { 5120, 10, 46, 11, -1, -35 },
  { 5178, 20, 35, 23, 3, -35 },
  { 5266, 5, 35, 11, 3, -35 },
  { 5288, 31, 25, 37, 3, -25 },
  { 5385, 18, 25, 24, 3, -25 },
  { 5442, 20, 25, 24, 2, -25 },
  { 5505, 19, 36, 24, 3, -25 },
  { 5591, 19, 36, 24, 2, -25 },
  { 5677, 13, 25, 17, 3, -25 },
  { 5718, 15, 25, 18, 2, -25 },
  { 5765, 13, 30, 15, 1, -30 },
  { 5814, 18, 25, 24, 3, -25 },
  { 5871, 21, 25, 21, 0, -25 },
  { 5937, 32, 25, 32, 0, -25 },
  { 6037, 20, 25, 21, 0, -25 },
  { 6100, 21, 36, 21, 0, -25 },
  { 6195, 16, 25, 18, 1, -25 },
  { 6245, 14, 40, 17, 1, -33 },
  { 6315, 5, 46, 21, 8, -35 },
  { 6344, 14, 40, 17, 2, -33 },
  { 6414, 20, 7, 22, 1, -20 },
};

const GFXfont NotoSans_Condensed_SemiBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD46PT7B_H_
