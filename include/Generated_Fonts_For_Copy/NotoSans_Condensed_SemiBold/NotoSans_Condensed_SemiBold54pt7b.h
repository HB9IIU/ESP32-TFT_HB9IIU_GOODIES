#ifndef _NOTOSANS_CONDENSED_SEMIBOLD54PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7C, 0x1F,
  0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF8, 0x7C, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x7C, 0x1E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0xF3, 0x83, 0x1F, 0x8E, 0x00, 0xFC, 0x38, 0x03, 0xF0,
  0xE0, 0x07, 0xE3, 0x80, 0x1F, 0x8E, 0x00, 0x7F, 0x38, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xEF, 0xE0, 0x03,
  0x9F, 0xC0, 0x0E, 0x3F, 0x00, 0x38, 0xFC, 0x00, 0xE3, 0xF0, 0x03, 0x8F,
  0xF0, 0x0E, 0x7F, 0xF8, 0x3B, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x7E, 0xFC, 0x01, 0xF0, 0x01,
  0xF1, 0xF0, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0x3E,
  0x0F, 0x8F, 0x83, 0xC0, 0xF8, 0x3E, 0x3E, 0x3F, 0xC3, 0xE0, 0xF9, 0xF1,
  0xFF, 0x87, 0xC7, 0xC7, 0xC7, 0xFF, 0x1F, 0xBF, 0x3E, 0x3F, 0xFC, 0x3F,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xE3, 0xE7, 0xC3, 0xE1, 0xFF, 0x1F, 0x1F,
  0x0F, 0x81, 0xF0, 0x7C, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x7C, 0x00,
  0x0F, 0x87, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x0F,
  0x80, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFD,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0xFE, 0x1F, 0xFE, 0x03,
  0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xFB, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0xFE, 0x1F, 0xC7, 0xE3, 0xF8, 0x3F, 0xBF, 0x8F, 0xC0, 0x7F, 0xFE, 0x3F,
  0x00, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xC3, 0xF0, 0x07, 0xFE, 0x0F, 0xC0,
  0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7,
  0xF0, 0x7F, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0x08, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xC3,
  0xE1, 0xDF, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xFB,
  0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0x80,
  0x60, 0x30, 0x01, 0x01, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F,
  0xC0, 0xFE, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF,
  0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC0, 0x7F, 0x8E, 0x00, 0xFE, 0x10, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFE, 0x7F, 0xC3, 0x80, 0x7F, 0x8C, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x80, 0x03, 0xFB, 0xC0, 0x3F, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x00,
  0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F,
  0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC3, 0x83, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x80,
  0x0F, 0xF7, 0x80, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x28, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF0,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x3F, 0x1F, 0xF0, 0xFC, 0xFF, 0xE3, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFB, 0xFE, 0xFF, 0x83, 0xFB, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F,
  0x3F, 0x01, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF8, 0x7F, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFC,
  0xFF, 0x1F, 0xC1, 0xFE, 0x7E, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x16, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0x7F, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFE, 0xFE, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xEF, 0xC7, 0xFF, 0x3F, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x0C, 0x1F, 0x9F,
  0xCF, 0xF7, 0xFB, 0xFC, 0xFC, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F,
  0x1F, 0x0F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xF3, 0xFE, 0x38, 0x0F, 0xE2, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x38, 0x03, 0xE1, 0xF0, 0x1F, 0xFC, 0x3E,
  0x3E, 0x03, 0xFF, 0xE1, 0xF3, 0xE0, 0x7F, 0xFE, 0x1F, 0x3E, 0x0F, 0xC7,
  0xE1, 0xF7, 0xC1, 0xF8, 0x3C, 0x1F, 0x7C, 0x1F, 0x03, 0xC0, 0xF7, 0xC3,
  0xF0, 0x7C, 0x0F, 0x7C, 0x3E, 0x07, 0xC0, 0xF7, 0x83, 0xE0, 0x7C, 0x0F,
  0x78, 0x3E, 0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07,
  0xC0, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83,
  0xE0, 0x7C, 0x1F, 0x78, 0x3E, 0x0F, 0xC1, 0xE7, 0xC3, 0xF0, 0xFC, 0x3E,
  0x7C, 0x1F, 0x9F, 0xE7, 0xE7, 0xC1, 0xFF, 0xDF, 0xFC, 0x7C, 0x0F, 0xFC,
  0xFF, 0x87, 0xE0, 0x7F, 0x87, 0xF0, 0x3E, 0x01, 0xE0, 0x3E, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x00,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFE, 0x7F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xE0, 0x1C, 0x3F, 0xC0, 0x04, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x04, 0x1F,
  0xF8, 0x3C, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F,
  0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0xE1, 0xFF, 0x00, 0x38, 0x7F, 0x80,
  0x04, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x03,
  0xF3, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x3F, 0xE0, 0x0F, 0xC7, 0xFE,
  0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF8, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F,
  0xF8, 0xFF, 0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF3, 0xFC,
  0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF7, 0xC0, 0x07, 0xFF, 0xFE, 0xF8, 0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x1F,
  0x7F, 0xFB, 0xF0, 0x07, 0xEF, 0xFF, 0x3E, 0x00, 0xF9, 0xFF, 0xE7, 0xC0,
  0x1F, 0x3F, 0xFC, 0xFC, 0x03, 0xE7, 0xFF, 0x8F, 0x80, 0xFC, 0xFF, 0xF1,
  0xF0, 0x1F, 0x1F, 0xFE, 0x3F, 0x03, 0xE3, 0xFF, 0xC7, 0xE0, 0xFC, 0x7F,
  0xF8, 0x7C, 0x1F, 0x0F, 0xFF, 0x0F, 0x83, 0xE1, 0xFF, 0xE1, 0xF8, 0xFC,
  0x3F, 0xFC, 0x1F, 0x1F, 0x07, 0xFF, 0x83, 0xE3, 0xE0, 0xFF, 0xF0, 0x7E,
  0x7C, 0x1F, 0xFE, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFB, 0xE0, 0x7F, 0xF8,
  0x1F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xE0,
  0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0x80,
  0x3F, 0xFD, 0xFC, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF,
  0xC7, 0xE0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x3F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0xC3, 0xFF, 0xC0, 0xFC, 0x3F,
  0xFC, 0x0F, 0xE3, 0xFF, 0xC0, 0x7E, 0x3F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0,
  0x7F, 0x3F, 0xFC, 0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0xBF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0xBF, 0x80, 0xFE, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xF8, 0x3F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x1F,
  0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFE, 0x07, 0x8F, 0xE0, 0x04, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0xE0, 0x07, 0xF7,
  0xF0, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0xE0, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0xF0, 0x03, 0xF3, 0xF8,
  0x03, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x1F, 0xC0, 0x7D, 0xF0,
  0x0F, 0xC3, 0xF8, 0x0F, 0xBE, 0x03, 0xF8, 0x3F, 0x01, 0xF7, 0xC0, 0x7F,
  0x07, 0xE0, 0x3E, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xCF, 0x81, 0xF8, 0x1F,
  0xC1, 0xF1, 0xF0, 0x3F, 0x01, 0xF8, 0x3E, 0x3E, 0x0F, 0xE0, 0x3F, 0x07,
  0xC7, 0xE1, 0xFC, 0x07, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x0F,
  0x87, 0xE0, 0x1F, 0xC7, 0xC1, 0xF0, 0xFC, 0x01, 0xF8, 0xF8, 0x3E, 0x3F,
  0x80, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x0F, 0x9F, 0x80, 0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0x01, 0xFB,
  0xE0, 0x3E, 0xFE, 0x00, 0x3F, 0x7C, 0x07, 0xDF, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0x83, 0xF8, 0x20, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xC1, 0xFB, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFD, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xF9, 0xF3, 0xFF, 0x8F, 0x8F, 0xF8, 0x7C, 0x06, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0x80, 0xFC, 0xFF, 0x83,
  0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFC,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F,
  0xBF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xBF, 0xFE, 0x3E,
  0x7F, 0xF0, 0xF8, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xE0,
  0x11, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x01, 0x3F, 0xC0, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0x83, 0xF0, 0x7F, 0xC7, 0xE1,
  0xFF, 0xCF, 0xC7, 0xFF, 0xDF, 0x9F, 0xFF, 0xFF, 0x3F, 0xEF, 0xFE, 0x7F,
  0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x07, 0xF9, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xDF, 0x87, 0xFF, 0x1F, 0x03, 0xFC, 0x3E, 0x00, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0xFF, 0x1F, 0xC3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x02, 0x3F, 0xC0, 0x38, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0x08, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x7C, 0x3F,
  0xF9, 0xF8, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xE7, 0xFD, 0xFF, 0xCF, 0xE0,
  0xFF, 0xBF, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0xFF, 0x3F, 0x83, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFB, 0xF0, 0xFF, 0xE7, 0xE0, 0x7F, 0x8F, 0xC0, 0x30, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE3, 0x00, 0x3F, 0xC7, 0xE3, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x3E, 0x0F, 0xCF, 0xFC, 0x7E, 0xFF, 0xF3, 0xFF, 0xFF,
  0xDF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x38, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x18, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x01, 0xC0, 0x3E,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xDF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFC, 0xFF, 0x87, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xDF, 0x80, 0x7F, 0x3F, 0x01,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0xFE,
  0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x7C, 0x1F, 0x1F, 0xF0, 0x3F, 0xE3, 0xE7, 0xFF, 0x0F, 0xFE,
  0x7D, 0xFF, 0xF3, 0xFF, 0xEF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x3E, 0x07, 0xC7, 0xFE, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF, 0xBF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE7, 0xF8,
  0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x1E, 0x03, 0xE3, 0xFE, 0x0F, 0x9F, 0xFE, 0x3E,
  0xFF, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF, 0x3F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0xFE, 0xFF, 0x07, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x7F, 0xF8, 0xFC, 0xFF, 0xC3, 0xF1,
  0xFE, 0x0F, 0xC0, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x7C, 0x3F, 0xF9, 0xF8, 0xFF,
  0xFB, 0xF1, 0xFF, 0xFF, 0xE7, 0xFD, 0xFF, 0xCF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFF, 0x7F, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x3F,
  0x83, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFD, 0xF8, 0xFF, 0xFB, 0xF0, 0xFF,
  0xE7, 0xE0, 0x7F, 0x8F, 0xC0, 0x38, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE,
  0x7F, 0xFF, 0xBF, 0xC3, 0xCF, 0xC0, 0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0xC1, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x30, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF, 0x1F, 0x0F, 0xF8, 0x7C, 0x06,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFD, 0xF8, 0x07,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x80, 0x7E,
  0x3F, 0x03, 0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xCF, 0x07, 0xF0,
  0x7E, 0x1F, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0xF8, 0x7E, 0x07, 0xE1, 0xF3,
  0xE1, 0xF8, 0x1F, 0xC7, 0xC7, 0x87, 0xE0, 0x3F, 0x1E, 0x1E, 0x3F, 0x00,
  0xFC, 0xF8, 0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x0F, 0xCF, 0x87,
  0xCF, 0xC0, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x7E, 0xF0, 0x3D, 0xF8, 0x01,
  0xFB, 0xC0, 0xF7, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07,
  0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x03,
  0xF7, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFE, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x02, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xA0,
  0x07, 0xFE, 0x40, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 17, 14, 23, 3, -39 },
  { 71, 27, 39, 29, 1, -39 },
  { 203, 22, 44, 26, 2, -41 },
  { 324, 38, 39, 42, 2, -39 },
  { 510, 30, 40, 32, 2, -39 },
  { 660, 7, 14, 13, 3, -39 },
  { 673, 14, 48, 17, 2, -39 },
  { 757, 13, 48, 17, 1, -39 },
  { 835, 21, 22, 25, 2, -41 },
  { 893, 22, 26, 26, 2, -32 },
  { 965, 9, 13, 14, 2, -6 },
  { 980, 13, 5, 16, 2, -17 },
  { 989, 8, 9, 14, 3, -8 },
  { 998, 20, 39, 21, 1, -39 },
  { 1096, 22, 40, 26, 2, -39 },
  { 1206, 16, 39, 26, 3, -39 },
  { 1284, 22, 39, 26, 2, -39 },
  { 1392, 22, 40, 26, 2, -39 },
  { 1502, 24, 39, 26, 1, -39 },
  { 1619, 21, 40, 26, 3, -39 },
  { 1724, 22, 40, 26, 2, -39 },
  { 1834, 22, 39, 26, 2, -39 },
  { 1942, 22, 40, 26, 2, -39 },
  { 2052, 22, 40, 26, 2, -39 },
  { 2162, 8, 31, 14, 3, -30 },
  { 2193, 9, 37, 14, 2, -30 },
  { 2235, 22, 26, 26, 2, -32 },
  { 2307, 22, 16, 26, 2, -27 },
  { 2351, 23, 26, 26, 2, -32 },
  { 2426, 20, 40, 21, 0, -39 },
  { 2526, 36, 43, 41, 2, -39 },
  { 2720, 30, 39, 30, 0, -39 },
  { 2867, 24, 39, 30, 4, -39 },
  { 2984, 24, 40, 28, 3, -39 },
  { 3104, 26, 39, 32, 4, -39 },
  { 3231, 18, 39, 25, 4, -39 },
  { 3319, 18, 39, 24, 4, -39 },
  { 3407, 26, 40, 33, 3, -39 },
  { 3537, 26, 39, 34, 4, -39 },
  { 3664, 14, 39, 17, 2, -39 },
  { 3733, 14, 50, 15, -3, -39 },
  { 3821, 25, 39, 29, 4, -39 },
  { 3943, 19, 39, 24, 4, -39 },
  { 4036, 35, 39, 43, 4, -39 },
  { 4207, 28, 39, 36, 4, -39 },
  { 4344, 29, 40, 35, 3, -39 },
  { 4489, 22, 39, 28, 4, -39 },
  { 4597, 29, 48, 35, 3, -39 },
  { 4771, 25, 39, 29, 4, -39 },
  { 4893, 21, 40, 25, 2, -39 },
  { 4998, 23, 39, 25, 1, -39 },
  { 5111, 25, 40, 33, 4, -39 },
  { 5236, 28, 39, 28, 0, -39 },
  { 5373, 43, 39, 43, 0, -39 },
  { 5583, 27, 39, 27, 0, -39 },
  { 5715, 27, 39, 27, 0, -39 },
  { 5847, 22, 39, 24, 1, -39 },
  { 5955, 12, 48, 17, 4, -39 },
  { 6027, 20, 39, 21, 1, -39 },
  { 6125, 13, 48, 17, 1, -39 },
  { 6203, 26, 24, 28, 1, -39 },
  { 6281, 23, 3, 23, 0, 5 },
  { 6290, 12, 8, 17, 2, -41 },
  { 6302, 21, 31, 26, 2, -30 },
  { 6384, 22, 42, 29, 4, -41 },
  { 6500, 19, 31, 23, 2, -30 },
  { 6574, 23, 42, 29, 2, -41 },
  { 6695, 22, 31, 26, 2, -30 },
  { 6781, 17, 41, 17, 1, -41 },
  { 6869, 23, 43, 29, 2, -30 },
  { 6993, 21, 41, 29, 4, -41 },
  { 7101, 7, 41, 13, 3, -41 },
  { 7137, 12, 54, 13, -2, -41 },
  { 7218, 23, 41, 27, 4, -41 },
  { 7336, 6, 41, 13, 4, -41 },
  { 7367, 35, 30, 43, 4, -30 },
  { 7499, 21, 30, 29, 4, -30 },
  { 7578, 24, 31, 28, 2, -30 },
  { 7671, 22, 43, 29, 4, -30 },
  { 7790, 23, 43, 29, 2, -30 },
  { 7914, 15, 30, 20, 4, -30 },
  { 7971, 18, 31, 22, 2, -30 },
  { 8041, 16, 37, 18, 1, -36 },
  { 8115, 22, 30, 29, 3, -29 },
  { 8198, 24, 29, 25, 0, -29 },
  { 8285, 38, 29, 38, 0, -29 },
  { 8423, 24, 29, 24, 0, -29 },
  { 8510, 24, 42, 25, 0, -29 },
  { 8636, 18, 29, 21, 1, -29 },
  { 8702, 17, 48, 20, 1, -39 },
  { 8804, 5, 54, 25, 10, -41 },
  { 8838, 16, 48, 20, 2, -39 },
  { 8934, 23, 8, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_SemiBold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD54PT7B_H_
