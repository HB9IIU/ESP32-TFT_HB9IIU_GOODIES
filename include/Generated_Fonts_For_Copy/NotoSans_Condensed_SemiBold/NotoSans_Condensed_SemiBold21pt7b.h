#ifndef _NOTOSANS_CONDENSED_SEMIBOLD21PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x6C, 0x07, 0xF8, 0xEF, 0xDF, 0xBF, 0x3C, 0x60,
  0x0C, 0x81, 0xB0, 0x26, 0x0C, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xC8, 0x1B,
  0x1F, 0xFB, 0xFF, 0x19, 0x83, 0x30, 0x64, 0x0D, 0x80, 0x08, 0x08, 0x7F,
  0xFF, 0xC8, 0xC8, 0xE8, 0x78, 0x3E, 0x0F, 0x0B, 0x0B, 0x8B, 0xFF, 0x7C,
  0x08, 0x08, 0x70, 0x61, 0xF0, 0xC3, 0x23, 0x06, 0x66, 0x0C, 0xD8, 0x19,
  0xB0, 0x32, 0x4E, 0x7D, 0xB6, 0x73, 0x6C, 0x0C, 0xC8, 0x19, 0x98, 0x63,
  0x20, 0xC6, 0xC1, 0x8F, 0x86, 0x0E, 0x00, 0x3E, 0x0F, 0xC1, 0x9C, 0x33,
  0x86, 0x60, 0xFC, 0x0F, 0x03, 0xE7, 0xEC, 0xF9, 0xDB, 0x1F, 0x61, 0xCE,
  0x39, 0xFF, 0x9F, 0xB8, 0xFF, 0xFC, 0x19, 0x9C, 0xC6, 0x73, 0x18, 0xC6,
  0x31, 0x8E, 0x31, 0x8E, 0x31, 0xC0, 0xE1, 0xC3, 0x0E, 0x18, 0x61, 0x87,
  0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x33, 0x80, 0x18, 0x18, 0x99, 0xFF,
  0xFE, 0x3C, 0x6E, 0xE6, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x7F, 0x6C, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x3C,
  0x7E, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7,
  0x7E, 0x3C, 0x0C, 0x73, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC0, 0x7C, 0xFE, 0xC7, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x1C, 0x18,
  0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0x47, 0x07, 0x07, 0x06, 0x3C,
  0x3C, 0x0F, 0x07, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x03, 0x01, 0xC0, 0xF0,
  0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCF, 0xFF, 0xFF, 0x03,
  0x00, 0xC0, 0x30, 0x7E, 0x7E, 0x60, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0x07,
  0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x1F, 0x3F, 0x70, 0x60, 0xC0, 0xCC,
  0xDE, 0xF7, 0xE3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F, 0x3E, 0xFF, 0xFF, 0x03,
  0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x70,
  0x3E, 0x7F, 0xE7, 0xC3, 0xE3, 0x67, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3,
  0xC3, 0xFF, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F,
  0x33, 0x03, 0x07, 0x0E, 0xFE, 0xF8, 0x5F, 0xA0, 0x00, 0x0F, 0xF0, 0x5F,
  0xA0, 0x00, 0x01, 0xFD, 0xB0, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x86, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xC0, 0x20, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x3C, 0x78, 0xF0, 0x60, 0x20,
  0x00, 0x7C, 0xFE, 0x47, 0x07, 0x07, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x00,
  0x00, 0x38, 0x38, 0x38, 0x0F, 0xC0, 0x7B, 0xC3, 0x03, 0x98, 0x06, 0x67,
  0xCF, 0x3B, 0x3C, 0xCC, 0xF3, 0x33, 0xC8, 0xCF, 0x33, 0x3C, 0xCC, 0xB3,
  0xDE, 0x62, 0x31, 0x80, 0x03, 0x02, 0x07, 0xF8, 0x07, 0x80, 0x0E, 0x00,
  0xF0, 0x1F, 0x01, 0xB0, 0x1B, 0x81, 0xB8, 0x39, 0x83, 0x98, 0x31, 0xC3,
  0xFC, 0x7F, 0xC7, 0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0x70, 0xFC, 0x7F, 0xB1,
  0xD8, 0x6C, 0x36, 0x3B, 0xF9, 0xFC, 0xC7, 0x61, 0xF0, 0xF8, 0x7C, 0x77,
  0xFB, 0xF8, 0x1F, 0x9F, 0xDC, 0x2E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x09, 0xFC, 0x7E, 0xFC, 0x3F, 0xCC, 0x73, 0x0E,
  0xC1, 0xB0, 0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0x0E, 0xC7, 0x3F,
  0x8F, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0x7E, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xFD,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x1F, 0xCF, 0xF7, 0x85, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x8F, 0xE3, 0xF8, 0x3E, 0x0D, 0x83, 0x70, 0xCF, 0xF1,
  0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x7F, 0xE0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x3F, 0xFC, 0xC3, 0xE1, 0xB1, 0xD9, 0xCC, 0xC6, 0xE3, 0xE1,
  0xF0, 0xFC, 0x67, 0x33, 0x98, 0xEC, 0x76, 0x1F, 0x0E, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x80, 0xE0,
  0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xEC, 0x6F, 0x63, 0x7B, 0x1B,
  0xDD, 0x9E, 0x6C, 0xF3, 0x67, 0x9E, 0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x60,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0xF6, 0x3D, 0xCF, 0x33, 0xCE, 0xF1,
  0xBC, 0x7F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1C, 0x1F, 0x87, 0xF9, 0xC7, 0x30,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB0, 0x77,
  0x1C, 0x7F, 0x87, 0xE0, 0xFC, 0xFE, 0xC7, 0xC7, 0xC3, 0xC7, 0xC7, 0xFE,
  0xFC, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x87, 0xF9, 0xC7, 0x30,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB0, 0x77,
  0x1C, 0x7F, 0x87, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xFC, 0x7F,
  0x31, 0xD8, 0xEC, 0x36, 0x3B, 0x1D, 0xFC, 0xFC, 0x66, 0x33, 0x98, 0xCC,
  0x76, 0x1B, 0x0E, 0x3E, 0x7F, 0xE2, 0xC0, 0xC0, 0xE0, 0x78, 0x3C, 0x1E,
  0x07, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3E, 0x3F, 0xF8, 0xF8, 0xE0, 0xFC, 0x1D, 0x83, 0x30, 0x67, 0x1C, 0x63,
  0x8C, 0x61, 0x8C, 0x3B, 0x83, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x1C, 0x03,
  0x80, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xCC, 0x78, 0x66, 0x36, 0x73,
  0x9B, 0x39, 0xCD, 0x98, 0x66, 0xCC, 0x36, 0x66, 0x1B, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0x70, 0xE1, 0xCE, 0x30,
  0xCE, 0x1D, 0xC1, 0xB0, 0x3E, 0x07, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xEC,
  0x19, 0xC7, 0x18, 0xC3, 0xB8, 0x38, 0xE1, 0xD8, 0x77, 0x19, 0xCE, 0x33,
  0x0E, 0xC1, 0xF0, 0x78, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x07, 0xFF, 0xFE, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0xFF, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x0C, 0x03, 0x80, 0xE0, 0x6C, 0x1B,
  0x0C, 0x63, 0x19, 0x83, 0xE0, 0xC0, 0xFF, 0x80, 0xE3, 0x8E, 0x18, 0x7E,
  0x67, 0x07, 0x07, 0x3F, 0xFF, 0xC7, 0xC7, 0xC7, 0xFF, 0x7B, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x47, 0xFB, 0xDF, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3F, 0x1F, 0xFD, 0x9E, 0x1C, 0xFD, 0xDF, 0x0E, 0x18, 0x30, 0x60, 0xE1,
  0xC5, 0xF9, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x71, 0x3B, 0xFD, 0xDF, 0xC7,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1D, 0xFE, 0x7B, 0x18, 0x7E, 0x67,
  0xE3, 0xC3, 0xFF, 0xFF, 0xC0, 0xE0, 0xE1, 0x7F, 0x3F, 0x1E, 0x7C, 0xC1,
  0x83, 0x1F, 0xBF, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10,
  0x3E, 0xDD, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xDF, 0xE7,
  0x70, 0x38, 0x1E, 0x1D, 0xFE, 0x7C, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x47, 0xFB, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x19, 0xCE, 0x00, 0x1C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xEF, 0x00, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x1F, 0x9D, 0xDC, 0xEC, 0x7E, 0x3F, 0x1D, 0xCE, 0x67,
  0x3B, 0x8D, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x33, 0x7D,
  0xFF, 0xFF, 0xF8, 0xE3, 0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3,
  0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0x06, 0x6F, 0xBF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x18, 0x3F, 0x1D, 0xDC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0x9F, 0xC7, 0xC0, 0x04, 0x7F,
  0xBD, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xFF, 0xDD, 0xEE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x10, 0x3E, 0xDD, 0xFC, 0x7E, 0x3E,
  0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xDF, 0xE7, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x07, 0x7F, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x39,
  0xFF, 0x96, 0x0E, 0x1F, 0x1F, 0x0F, 0x0F, 0x1F, 0xF7, 0xC0, 0x30, 0x60,
  0xC7, 0xEF, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xE7, 0xC0, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xBF, 0xDF, 0x60,
  0xE1, 0xD8, 0xE6, 0x39, 0xCC, 0x33, 0x0D, 0xC3, 0x60, 0xF8, 0x1E, 0x07,
  0x81, 0xC0, 0xE3, 0x8E, 0xC7, 0x19, 0x9A, 0x33, 0x36, 0xE7, 0x6D, 0x86,
  0xDB, 0x0D, 0x36, 0x1E, 0x2C, 0x3C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0xB9, 0x8D, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x6C, 0x77, 0x39, 0xF8, 0xE0,
  0xE1, 0xD8, 0xE6, 0x39, 0xCC, 0x33, 0x0D, 0xC3, 0x60, 0x78, 0x1E, 0x07,
  0x80, 0xC0, 0x70, 0x1C, 0x06, 0x07, 0x81, 0xC0, 0xFD, 0xF8, 0x70, 0xC3,
  0x86, 0x1C, 0x30, 0xE1, 0xFF, 0xF8, 0x0E, 0x3C, 0x60, 0xC1, 0x83, 0x06,
  0x1C, 0xF1, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1E, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0x73,
  0x8C, 0x30, 0xC3, 0x0C, 0xF3, 0x80, 0xF0, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 7, 5, 9, 1, -15 },
  { 12, 11, 15, 11, 0, -15 },
  { 33, 8, 17, 10, 1, -16 },
  { 50, 15, 15, 16, 1, -15 },
  { 79, 11, 15, 12, 1, -15 },
  { 100, 3, 5, 5, 1, -15 },
  { 102, 5, 18, 7, 1, -15 },
  { 114, 6, 18, 7, 0, -15 },
  { 128, 8, 8, 10, 1, -16 },
  { 136, 8, 10, 10, 1, -12 },
  { 146, 3, 5, 5, 1, -2 },
  { 148, 5, 2, 6, 1, -7 },
  { 150, 3, 3, 5, 1, -3 },
  { 152, 8, 15, 8, 0, -15 },
  { 167, 8, 15, 10, 1, -15 },
  { 182, 6, 15, 10, 1, -15 },
  { 194, 8, 15, 10, 1, -15 },
  { 209, 8, 15, 10, 1, -15 },
  { 224, 10, 15, 10, 0, -15 },
  { 243, 8, 15, 10, 1, -15 },
  { 258, 8, 15, 10, 1, -15 },
  { 273, 8, 15, 10, 1, -15 },
  { 288, 8, 15, 10, 1, -15 },
  { 303, 8, 15, 10, 1, -15 },
  { 318, 3, 12, 5, 1, -12 },
  { 323, 3, 15, 5, 1, -12 },
  { 329, 9, 11, 10, 1, -13 },
  { 342, 8, 6, 10, 1, -10 },
  { 348, 9, 11, 10, 1, -13 },
  { 361, 8, 15, 8, 0, -15 },
  { 376, 14, 17, 16, 1, -15 },
  { 406, 12, 15, 12, 0, -15 },
  { 429, 9, 15, 12, 2, -15 },
  { 446, 9, 15, 11, 1, -15 },
  { 463, 10, 15, 13, 2, -15 },
  { 482, 7, 15, 10, 2, -15 },
  { 496, 7, 15, 9, 2, -15 },
  { 510, 10, 15, 13, 1, -15 },
  { 529, 9, 15, 13, 2, -15 },
  { 546, 5, 15, 7, 1, -15 },
  { 556, 5, 19, 6, -1, -15 },
  { 568, 9, 15, 11, 2, -15 },
  { 585, 7, 15, 9, 2, -15 },
  { 599, 13, 15, 17, 2, -15 },
  { 624, 10, 15, 14, 2, -15 },
  { 643, 11, 15, 13, 1, -15 },
  { 664, 8, 15, 11, 2, -15 },
  { 679, 11, 19, 13, 1, -15 },
  { 706, 9, 15, 11, 2, -15 },
  { 723, 8, 15, 10, 1, -15 },
  { 738, 9, 15, 10, 0, -15 },
  { 755, 9, 15, 13, 2, -15 },
  { 772, 11, 15, 11, 0, -15 },
  { 793, 17, 15, 17, 0, -15 },
  { 825, 11, 15, 11, 0, -15 },
  { 846, 10, 15, 10, 0, -15 },
  { 865, 9, 15, 9, 0, -15 },
  { 882, 5, 18, 7, 1, -15 },
  { 894, 8, 15, 8, 0, -15 },
  { 909, 4, 18, 7, 1, -15 },
  { 918, 10, 9, 11, 0, -15 },
  { 930, 9, 1, 9, 0, 2 },
  { 932, 5, 3, 6, 1, -16 },
  { 934, 8, 12, 10, 1, -12 },
  { 946, 9, 16, 11, 1, -16 },
  { 964, 7, 12, 9, 1, -12 },
  { 975, 9, 16, 11, 1, -16 },
  { 993, 8, 12, 10, 1, -12 },
  { 1005, 7, 16, 6, 0, -16 },
  { 1019, 9, 17, 11, 1, -12 },
  { 1039, 9, 16, 11, 1, -16 },
  { 1057, 3, 16, 5, 1, -16 },
  { 1063, 5, 21, 5, -1, -16 },
  { 1077, 9, 16, 10, 1, -16 },
  { 1095, 3, 16, 5, 1, -16 },
  { 1101, 14, 12, 17, 1, -12 },
  { 1122, 9, 12, 11, 1, -12 },
  { 1136, 9, 12, 11, 1, -12 },
  { 1150, 9, 17, 11, 1, -12 },
  { 1170, 9, 17, 11, 1, -12 },
  { 1190, 6, 12, 8, 1, -12 },
  { 1199, 7, 12, 8, 1, -12 },
  { 1210, 7, 14, 7, 0, -14 },
  { 1223, 9, 11, 11, 1, -11 },
  { 1236, 10, 11, 10, 0, -11 },
  { 1250, 15, 11, 15, 0, -11 },
  { 1271, 9, 11, 9, 0, -11 },
  { 1284, 10, 16, 10, 0, -11 },
  { 1304, 7, 11, 8, 1, -11 },
  { 1314, 7, 18, 8, 0, -15 },
  { 1330, 2, 21, 10, 4, -16 },
  { 1336, 6, 18, 8, 1, -15 },
  { 1350, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD21PT7B_H_
