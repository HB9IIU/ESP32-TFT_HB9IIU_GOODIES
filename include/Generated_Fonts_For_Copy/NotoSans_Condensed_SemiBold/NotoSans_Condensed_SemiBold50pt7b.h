#ifndef _NOTOSANS_CONDENSED_SEMIBOLD50PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07,
  0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x01, 0xE1, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xE7, 0x1C, 0xFC, 0x70, 0x2F, 0xC7, 0x00, 0xFC,
  0x70, 0x0F, 0xC7, 0x00, 0x7C, 0x70, 0x07, 0xF7, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x73, 0xF0, 0x07, 0x3F, 0x00, 0x71,
  0xF0, 0x07, 0x1F, 0x80, 0x71, 0xFE, 0x07, 0x3F, 0xF8, 0x77, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F,
  0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x07, 0x8F, 0x80, 0x78, 0x01, 0xF0, 0xF0,
  0x1F, 0x00, 0x3E, 0x1E, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x78, 0x00, 0xF0,
  0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xF0, 0xF8, 0x00,
  0x78, 0x3E, 0x1E, 0x00, 0x0F, 0x07, 0xC7, 0xC0, 0x01, 0xE0, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x1E, 0x1F, 0x07, 0xC3, 0xC7, 0xC7, 0xF8, 0xF8, 0x78,
  0xF1, 0xFF, 0x8F, 0x1F, 0x3E, 0x7F, 0xF1, 0xFF, 0xC7, 0x8F, 0x9F, 0x1F,
  0xF9, 0xF1, 0xE1, 0xE1, 0xFE, 0x3E, 0x7C, 0x3C, 0x1F, 0x87, 0x8F, 0x87,
  0xC0, 0x01, 0xF1, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x0F,
  0x83, 0xE1, 0xF0, 0x01, 0xE0, 0x7C, 0x3E, 0x00, 0x7C, 0x0F, 0x87, 0xC0,
  0x0F, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0x1E, 0x3E, 0x00, 0x78, 0x03, 0xFF,
  0xC0, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xC3, 0xFF, 0xE0, 0xFC,
  0x7F, 0x7E, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0x3F, 0x9F, 0x8F, 0xC1,
  0xFD, 0xF8, 0xFC, 0x0F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0, 0xFC, 0x07, 0xFF,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFD,
  0xFC, 0x1F, 0xFF, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0x9E, 0x78, 0x01, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20,
  0x7C, 0x09, 0xF1, 0xE3, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x01, 0xC1, 0xC0,
  0x04, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F,
  0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF,
  0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x7F, 0x7F, 0xF9, 0xF7, 0xC7,
  0xCC, 0x1F, 0x10, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xE0, 0xFE, 0x38,
  0x07, 0xE2, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xC0, 0xFE, 0x30, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0x3F, 0x00, 0x3E, 0x7E,
  0x00, 0x78, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xC3, 0xF0, 0x0F, 0x87, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F,
  0x80, 0xFC, 0x1E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE2, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0xE0, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x3F, 0x03, 0xF3, 0xFE, 0x1F, 0x3F, 0xF8, 0xFB, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xC1, 0xFD, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xBF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC,
  0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x03,
  0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x1F, 0xC7, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xFB, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0x7E, 0x01, 0xFB, 0xF8, 0x0F, 0xCF, 0xE1, 0xFE, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xF0, 0xFC, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xDF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x0F, 0xF3, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x83, 0xBF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0x08, 0x3E,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8E, 0x07, 0xF2, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x08,
  0x07, 0xC3, 0xE0, 0x3F, 0xF8, 0xF0, 0xF8, 0x3F, 0xFC, 0x3E, 0x3C, 0x1F,
  0xFF, 0x07, 0x9F, 0x07, 0xC3, 0xC1, 0xE7, 0xC3, 0xE0, 0xF0, 0x79, 0xE0,
  0xF8, 0x3C, 0x1E, 0x78, 0x7C, 0x0F, 0x07, 0xFE, 0x1F, 0x03, 0xC1, 0xFF,
  0x87, 0xC0, 0xF0, 0x7F, 0xE1, 0xF0, 0x3C, 0x1F, 0xF8, 0x78, 0x1F, 0x07,
  0xBE, 0x1E, 0x07, 0xC1, 0xEF, 0x87, 0xC1, 0xF0, 0x7B, 0xE1, 0xF0, 0x7C,
  0x1E, 0xF8, 0x7C, 0x1F, 0x0F, 0xBE, 0x0F, 0x0F, 0xC3, 0xC7, 0x83, 0xF7,
  0xFF, 0xF1, 0xE0, 0xFF, 0xCF, 0xF8, 0x7C, 0x1F, 0xF3, 0xFC, 0x1F, 0x03,
  0xF8, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00,
  0x1F, 0xC0, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8,
  0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xF0, 0x7F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0x07, 0xF8, 0x02, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x1E, 0x3F, 0xC0, 0x04, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0, 0x3F, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x04, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x87, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF,
  0xCF, 0xFC, 0x7F, 0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8,
  0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x1F,
  0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xE0, 0x07, 0xDF, 0xFB, 0xE0, 0x07,
  0xDF, 0xFB, 0xE0, 0x07, 0xDF, 0xF9, 0xF0, 0x0F, 0x9F, 0xF9, 0xF0, 0x0F,
  0x9F, 0xF9, 0xF0, 0x0F, 0x9F, 0xF9, 0xF8, 0x0F, 0x1F, 0xF8, 0xF8, 0x1F,
  0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0x7C, 0x3E,
  0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x7E, 0x7C,
  0x1F, 0xF8, 0x3E, 0x7C, 0x1F, 0xF8, 0x3E, 0x7C, 0x1F, 0xF8, 0x3E, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFE, 0xFC, 0x03, 0xFF, 0x7E, 0x01, 0xFF, 0x9F, 0x80, 0xFF, 0xCF, 0xC0,
  0x7F, 0xE3, 0xF0, 0x3F, 0xF1, 0xF8, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3F,
  0x07, 0xFE, 0x0F, 0xC3, 0xFF, 0x07, 0xE1, 0xFF, 0x81, 0xF8, 0xFF, 0xC0,
  0xFC, 0x7F, 0xE0, 0x3F, 0x3F, 0xF0, 0x1F, 0x9F, 0xF8, 0x07, 0xEF, 0xFC,
  0x03, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC7, 0xFE, 0xFC,
  0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xC3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x05, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x8F, 0xFC, 0x3F, 0x03, 0xFC,
  0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E,
  0x07, 0xF0, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0x1F, 0x9F, 0x80, 0x27, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0xFF, 0x00, 0x7E,
  0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00,
  0xFF, 0x00, 0x7E, 0x3E, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80,
  0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x1F,
  0x01, 0xE7, 0x80, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7,
  0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8,
  0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7,
  0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3,
  0xF0, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x07,
  0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x03, 0xEF, 0x81,
  0xF7, 0xE0, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F,
  0xDF, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x9F, 0x80,
  0x1F, 0xCF, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0,
  0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3C, 0x1F, 0xC4, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFB, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0x7C, 0xFF, 0xC7, 0x8F, 0xF0, 0xF0, 0x20,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x06, 0x01, 0xF8, 0xFF, 0x0F, 0xDF, 0xFC, 0x7E,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xF9, 0xFE, 0xFF, 0x03, 0xF7, 0xF0, 0x1F,
  0xBF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x7E, 0xFF, 0x07, 0xF7, 0xFE, 0x7F, 0xBF, 0xFF, 0xF9, 0xFB, 0xFF, 0xCF,
  0x9F, 0xFC, 0x7C, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xF1, 0xC3, 0xF0, 0x11,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x08,
  0xFF, 0xBE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x70, 0x7E, 0x0F, 0xF3, 0xF0, 0xFF, 0xDF,
  0x8F, 0xFF, 0x7C, 0xFF, 0xFF, 0xE7, 0xF1, 0xFF, 0x7F, 0x03, 0xFB, 0xF0,
  0x1F, 0xDF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7F, 0x7F, 0x03, 0xF9, 0xFC, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFD,
  0xF0, 0xFF, 0xCF, 0x83, 0xFC, 0x7C, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x7E, 0x03, 0xE7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x23, 0xFC, 0x3E, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0x01, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xC7, 0xC3, 0xFF, 0x3E, 0x3F, 0xFD,
  0xF3, 0xFF, 0xFF, 0x9F, 0xC7, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xFD,
  0xFC, 0x0F, 0xE7, 0xFB, 0xFF, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0x7E, 0x0F, 0xF3, 0xF0, 0x08, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFA, 0x00, 0x1F, 0x9E, 0x03, 0xFC, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x0C, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFD, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x31, 0xFF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0xF0, 0x3E, 0x3F, 0xE0, 0xFF, 0x0F, 0x9F,
  0xFC, 0x7F, 0xF3, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF7, 0xFF, 0x9F, 0xEF, 0xF0, 0x7F, 0xC1, 0xFB, 0xF8, 0x1F, 0xE0, 0x7E,
  0xFE, 0x03, 0xF0, 0x1F, 0xBF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x0C, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFD, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFE, 0x3F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xE3,
  0xF0, 0x3F, 0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x07, 0xC3, 0xFC,
  0x3E, 0x7F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xC7, 0xFB, 0xFC,
  0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFB, 0xFC, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xEF, 0xFF, 0x3F, 0x3F, 0xF1, 0xF8, 0xFE, 0x0F, 0xC0, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xC7, 0xC3, 0xFF, 0x3E,
  0x3F, 0xFD, 0xF3, 0xFF, 0xFF, 0x9F, 0xC7, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x01, 0xFD, 0xFC, 0x0F, 0xE7, 0xFB, 0xFF, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0x7E, 0x0F, 0xF3, 0xF0, 0x08, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x1D, 0xF0, 0xFF, 0xE3, 0xF7, 0xCF, 0xEF, 0xBF, 0xDF, 0xFF,
  0xBF, 0xF1, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFC, 0x0E, 0xFC, 0x02, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFE, 0xE3, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x00, 0x80, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFD, 0xF1, 0xFF,
  0x9F, 0x0F, 0xF0, 0xF0, 0x10, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x00, 0xF9, 0xF8, 0x0F, 0xE0,
  0x1F, 0x3F, 0x01, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0xC0, 0xFC, 0x7C, 0x0F,
  0x78, 0x1F, 0x0F, 0xC1, 0xEF, 0x03, 0xE1, 0xF8, 0x3D, 0xF0, 0xFC, 0x3F,
  0x07, 0xBE, 0x1F, 0x83, 0xE1, 0xF3, 0xC3, 0xF0, 0x7E, 0x3E, 0x78, 0x7C,
  0x0F, 0xC7, 0x8F, 0x0F, 0x81, 0xF8, 0xF1, 0xF3, 0xF0, 0x1F, 0x3E, 0x3E,
  0x7E, 0x03, 0xE7, 0xC3, 0xCF, 0x80, 0x7C, 0xF8, 0x79, 0xF0, 0x0F, 0xDE,
  0x0F, 0x3E, 0x00, 0xFB, 0xC1, 0xEF, 0xC0, 0x1F, 0x78, 0x3F, 0xF0, 0x03,
  0xEF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFA, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 16, 13, 21, 3, -36 },
  { 60, 25, 36, 27, 1, -36 },
  { 173, 20, 41, 24, 2, -38 },
  { 276, 35, 36, 39, 2, -36 },
  { 434, 28, 37, 30, 2, -36 },
  { 564, 6, 13, 12, 3, -36 },
  { 574, 12, 44, 16, 2, -36 },
  { 640, 12, 44, 16, 1, -36 },
  { 706, 21, 20, 23, 1, -38 },
  { 759, 21, 24, 24, 2, -30 },
  { 822, 8, 13, 13, 2, -6 },
  { 835, 13, 5, 15, 1, -16 },
  { 844, 7, 8, 13, 3, -7 },
  { 851, 18, 36, 20, 1, -36 },
  { 932, 20, 37, 24, 2, -36 },
  { 1025, 14, 36, 24, 3, -36 },
  { 1088, 20, 36, 24, 2, -36 },
  { 1178, 20, 37, 24, 2, -36 },
  { 1271, 23, 36, 24, 1, -36 },
  { 1375, 20, 37, 24, 2, -36 },
  { 1468, 21, 37, 24, 2, -36 },
  { 1566, 22, 36, 24, 1, -36 },
  { 1665, 21, 37, 24, 2, -36 },
  { 1763, 20, 37, 24, 2, -36 },
  { 1856, 7, 29, 13, 3, -28 },
  { 1882, 8, 35, 13, 2, -28 },
  { 1917, 21, 24, 24, 2, -30 },
  { 1980, 21, 15, 24, 2, -25 },
  { 2020, 21, 24, 24, 2, -30 },
  { 2083, 18, 37, 19, 0, -36 },
  { 2167, 34, 40, 38, 2, -36 },
  { 2337, 27, 36, 28, 0, -36 },
  { 2459, 22, 36, 28, 4, -36 },
  { 2558, 23, 37, 26, 2, -36 },
  { 2665, 24, 36, 30, 4, -36 },
  { 2773, 17, 36, 23, 4, -36 },
  { 2850, 17, 36, 23, 4, -36 },
  { 2927, 24, 37, 30, 3, -36 },
  { 3038, 23, 36, 31, 4, -36 },
  { 3142, 14, 36, 16, 1, -36 },
  { 3205, 13, 46, 14, -3, -36 },
  { 3280, 23, 36, 27, 4, -36 },
  { 3384, 17, 36, 22, 4, -36 },
  { 3461, 32, 36, 40, 4, -36 },
  { 3605, 25, 36, 33, 4, -36 },
  { 3718, 28, 37, 32, 2, -36 },
  { 3848, 20, 36, 26, 4, -36 },
  { 3938, 28, 45, 32, 2, -36 },
  { 4096, 23, 36, 27, 4, -36 },
  { 4200, 19, 37, 23, 2, -36 },
  { 4288, 21, 36, 23, 1, -36 },
  { 4383, 23, 37, 31, 4, -36 },
  { 4490, 26, 36, 26, 0, -36 },
  { 4607, 40, 36, 40, 0, -36 },
  { 4787, 25, 36, 25, 0, -36 },
  { 4900, 25, 36, 25, 0, -36 },
  { 5013, 20, 36, 22, 1, -36 },
  { 5103, 12, 44, 16, 3, -36 },
  { 5169, 18, 36, 20, 1, -36 },
  { 5250, 12, 44, 16, 1, -36 },
  { 5316, 24, 22, 26, 1, -36 },
  { 5382, 21, 4, 21, 0, 4 },
  { 5393, 11, 8, 15, 2, -38 },
  { 5404, 19, 29, 24, 2, -28 },
  { 5473, 21, 39, 26, 3, -38 },
  { 5576, 18, 29, 21, 2, -28 },
  { 5642, 21, 39, 26, 2, -38 },
  { 5745, 20, 29, 24, 2, -28 },
  { 5818, 16, 38, 15, 1, -38 },
  { 5894, 21, 40, 26, 2, -28 },
  { 5999, 20, 38, 27, 3, -38 },
  { 6094, 6, 38, 12, 3, -38 },
  { 6123, 11, 50, 12, -2, -38 },
  { 6192, 22, 38, 25, 3, -38 },
  { 6297, 6, 38, 12, 3, -38 },
  { 6326, 34, 28, 40, 3, -28 },
  { 6445, 20, 28, 27, 3, -28 },
  { 6515, 22, 29, 26, 2, -28 },
  { 6595, 21, 40, 26, 3, -28 },
  { 6700, 21, 40, 26, 2, -28 },
  { 6805, 15, 28, 18, 3, -28 },
  { 6858, 16, 29, 20, 2, -28 },
  { 6916, 15, 34, 17, 1, -33 },
  { 6980, 20, 28, 27, 3, -27 },
  { 7050, 23, 27, 23, 0, -27 },
  { 7128, 35, 27, 35, 0, -27 },
  { 7247, 22, 27, 23, 0, -27 },
  { 7322, 23, 39, 23, 0, -27 },
  { 7435, 17, 27, 19, 1, -27 },
  { 7493, 15, 44, 18, 1, -36 },
  { 7576, 5, 50, 23, 9, -38 },
  { 7608, 15, 44, 18, 2, -36 },
  { 7691, 21, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_SemiBold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD50PT7B_H_
