#ifndef _NOTOSANS_CONDENSED_SEMIBOLD51PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x07, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x81, 0xE0, 0xF0,
  0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFB, 0x9F, 0x1F, 0x9C, 0x19, 0xF8, 0xE0,
  0x0F, 0xC7, 0x00, 0x7E, 0x38, 0x03, 0xF1, 0xC0, 0x0F, 0xCE, 0x00, 0x7F,
  0x70, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x77, 0xF0, 0x03,
  0x9F, 0x80, 0x1C, 0x7E, 0x00, 0xE3, 0xF0, 0x07, 0x1F, 0xC0, 0x38, 0xFB,
  0x81, 0xCF, 0xDF, 0x8F, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x10,
  0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0x00,
  0x3E, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x07, 0x87, 0x80, 0x7C, 0x00, 0xF8,
  0x7C, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0xF8, 0x7C, 0x0F, 0x00,
  0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0xC3,
  0xE0, 0x00, 0xF0, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0xF8,
  0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC7, 0x87, 0xF0, 0xF8, 0x7C, 0xF8, 0xFF,
  0x87, 0x87, 0x8F, 0x9F, 0xFC, 0x7C, 0xF9, 0xF1, 0xFF, 0xC7, 0xFF, 0x9F,
  0x3E, 0x3E, 0x3F, 0xF1, 0xE3, 0xE3, 0xE1, 0xFE, 0x3E, 0x3C, 0x1E, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x07, 0xC7, 0xC1,
  0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF0,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x3C, 0x1E, 0x00,
  0x3E, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0x3E, 0x3E, 0x00, 0x3C, 0x03, 0xE3,
  0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0xC0, 0x0F, 0x80,
  0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x07, 0xE1, 0xFF, 0xC0, 0x7E, 0x3F, 0xFE, 0x0F, 0xC7, 0xF7, 0xF0, 0xFC,
  0xFE, 0x3F, 0x8F, 0xCF, 0xE1, 0xF9, 0xFC, 0xFC, 0x1F, 0xDF, 0x8F, 0xC0,
  0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0xFC, 0x01, 0xFE,
  0x0F, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xDF, 0xC1, 0xFF, 0xF8,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0x9E, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x01, 0xC1, 0xE1, 0xCF, 0xEF, 0x7E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xC1, 0xF0,
  0x0E, 0x06, 0x00, 0x10, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x3F, 0x3F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x08, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xCF, 0xF0, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF,
  0xBF, 0xFE, 0x7E, 0xF8, 0xFD, 0xE1, 0xF9, 0x83, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0x9F, 0xF1, 0xF0, 0x1F,
  0x86, 0x00, 0xFE, 0x20, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x0F, 0xF0,
  0xC0, 0x1F, 0x84, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFA, 0x00, 0x1F, 0xDC, 0x01, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1E,
  0x7E, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x3C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x06, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x40, 0x03, 0xFB, 0xC0, 0x3F, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xF8, 0x10, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF1, 0xFC, 0x1F, 0xBF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00,
  0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x1F, 0x87, 0xF0, 0xFF, 0x7F, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0xCF, 0xF1, 0xFC, 0x3F, 0xCF, 0xC0, 0xFE, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7E, 0x7F, 0x8F, 0xF3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xCF, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xDF,
  0xC3, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F, 0xE7,
  0xC0, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xF8, 0xF8, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C, 0x7F, 0x8C,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xE0,
  0x1F, 0xE0, 0xF8, 0xF8, 0x1F, 0xFE, 0x1E, 0x3E, 0x0F, 0xFF, 0x87, 0xDF,
  0x07, 0xFF, 0xE1, 0xF7, 0xC1, 0xF0, 0xF8, 0x3D, 0xF0, 0xF8, 0x3E, 0x0F,
  0x78, 0x3E, 0x0F, 0x83, 0xDE, 0x0F, 0x03, 0xE0, 0xFF, 0x87, 0xC0, 0xF8,
  0x3F, 0xE1, 0xF0, 0x3E, 0x0F, 0xF8, 0x7C, 0x0F, 0x83, 0xFE, 0x1F, 0x03,
  0xE0, 0xFF, 0x87, 0xC0, 0xF8, 0x3F, 0xE1, 0xF0, 0x3E, 0x1F, 0xF8, 0x7C,
  0x1F, 0x87, 0xFE, 0x0F, 0x07, 0xE1, 0xE7, 0x83, 0xE3, 0xF8, 0xF9, 0xE0,
  0xFF, 0xEF, 0xFC, 0x7C, 0x1F, 0xFB, 0xFF, 0x1F, 0x03, 0xFC, 0x7F, 0x87,
  0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x80, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC1, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0x9F, 0x87, 0xF8, 0x03, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x01, 0x0F, 0xF8, 0x0E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x07, 0xF8, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE1, 0xF0, 0x7F, 0x80, 0x18, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xF0, 0x01, 0xFB, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0xC0, 0x3F,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x87,
  0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0xFC, 0x00, 0xFE,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00,
  0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF7, 0xC0, 0x07, 0xDF, 0xFB,
  0xE0, 0x03, 0xEF, 0xFD, 0xF0, 0x01, 0xF7, 0xFE, 0xFC, 0x01, 0xF7, 0xFF,
  0x3E, 0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x7D, 0xFF, 0xEF, 0x80, 0x7E, 0xFF,
  0xF3, 0xE0, 0x3E, 0x7F, 0xF9, 0xF0, 0x1F, 0x3F, 0xFC, 0xF8, 0x0F, 0x9F,
  0xFE, 0x7E, 0x0F, 0x8F, 0xFF, 0x1F, 0x07, 0xC7, 0xFF, 0x8F, 0x83, 0xE3,
  0xFF, 0xC7, 0xC3, 0xE1, 0xFF, 0xE1, 0xF1, 0xF0, 0xFF, 0xF0, 0xF8, 0xF8,
  0x7F, 0xF8, 0x7C, 0x7C, 0x3F, 0xFC, 0x3F, 0x7C, 0x1F, 0xFE, 0x0F, 0xBE,
  0x0F, 0xFF, 0x07, 0xDF, 0x07, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01,
  0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFE, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0xFF, 0xE7, 0xE0, 0x3F, 0xF9, 0xFC,
  0x0F, 0xFE, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0xFF, 0xF1, 0xF8, 0x3F, 0xFC,
  0x7E, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0x7E, 0x3F,
  0xFC, 0x1F, 0x8F, 0xFF, 0x03, 0xF3, 0xFF, 0xC0, 0xFC, 0xFF, 0xF0, 0x1F,
  0xBF, 0xFC, 0x07, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x7F, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC,
  0x0F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0x81, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x8F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0x01, 0xC7, 0xE0,
  0x04, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE8, 0x00, 0x7E, 0xC0, 0x0F, 0xEF, 0x81,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x7F,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0,
  0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xCF,
  0xC0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x03, 0xF3, 0xF0, 0x07,
  0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFF, 0x00,
  0xFC, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0xFB, 0xC0, 0x3F, 0x0F,
  0xC0, 0x7D, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x03,
  0xF0, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x0F, 0x83, 0xE3, 0xE1, 0xF8, 0x07,
  0xE1, 0xF1, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0xF8, 0x7E, 0x01, 0xF8, 0xF8,
  0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x0F, 0x9F,
  0x80, 0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x03, 0xE7, 0xE0, 0x07,
  0xEF, 0x80, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x1F, 0xFC, 0x00, 0x3E, 0xF0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xE7,
  0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xF3, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0x9F, 0x3F, 0xF1, 0xF1, 0xFE, 0x1F, 0x03, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0xFF,
  0xC3, 0xF7, 0xFF, 0x8F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x87, 0xF3,
  0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xEF,
  0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xFE,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFD, 0xFF, 0xE3, 0xE3, 0xFF, 0x0F, 0x87, 0xF8,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xE0, 0x67, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x08, 0xFF, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F, 0xFC, 0xFC, 0x7F, 0xFB, 0xF1,
  0xFF, 0xEF, 0xCF, 0xFF, 0xFF, 0x7F, 0x87, 0xFD, 0xFC, 0x0F, 0xF7, 0xE0,
  0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0x80,
  0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x0F, 0xF3, 0xFD, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFE, 0xFC, 0x3F, 0xF1, 0xF0, 0x7F, 0x87, 0xC0, 0x10, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x87,
  0xFC, 0x7C, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xC2, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0,
  0x7C, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFC,
  0xFE, 0x1F, 0xF7, 0xF0, 0x3F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0,
  0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF0, 0xFF, 0xCF,
  0xC1, 0xFE, 0x3F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF9, 0x00, 0x0F, 0xE3, 0x80, 0x7F, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xCF, 0xFC, 0x7E, 0xFF,
  0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x87, 0xF7, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xCF,
  0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x7F, 0x01, 0xFC, 0x3E, 0x3F, 0xF0, 0xFF, 0xCF, 0x9F,
  0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0xF8, 0x3F, 0x07, 0xC7, 0xFE, 0x3E, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xC3, 0xFB, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01,
  0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xF8,
  0x3F, 0x03, 0xE3, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0x7F, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFE, 0x1F, 0xCF, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB,
  0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xFC, 0x0F, 0xEF,
  0xF0, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF7, 0xFF, 0x8F, 0xCF,
  0xFC, 0x3F, 0x1F, 0xE0, 0xFC, 0x0C, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x7C, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF, 0xBF,
  0x3F, 0xFF, 0xFC, 0xFE, 0x1F, 0xF7, 0xF0, 0x3F, 0xDF, 0x80, 0x7F, 0x7E,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xF7, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFB,
  0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF8, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xE7, 0xE0, 0x33, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x01, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x03, 0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xE7,
  0xC7, 0xFE, 0x3E, 0x1F, 0xE1, 0xF0, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x3F, 0xC0, 0x3E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x7E,
  0x7E, 0x03, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3F, 0x07, 0xFE,
  0x0F, 0xC3, 0xF0, 0x7F, 0xE0, 0xFC, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xF0,
  0x79, 0xE0, 0xF8, 0x1F, 0x8F, 0x9E, 0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8,
  0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x8F, 0x0F,
  0x1F, 0x00, 0xFD, 0xF0, 0xF3, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD,
  0xF0, 0xFB, 0xE0, 0x07, 0xDE, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x7B, 0xE0,
  0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF8,
  0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8,
  0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x7F, 0x81,
  0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xD0, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 16, 13, 22, 3, -36 },
  { 60, 25, 36, 27, 1, -36 },
  { 173, 21, 42, 25, 2, -39 },
  { 284, 36, 37, 39, 2, -37 },
  { 451, 28, 38, 30, 2, -37 },
  { 584, 6, 13, 12, 3, -36 },
  { 594, 13, 45, 16, 2, -37 },
  { 668, 13, 45, 16, 1, -37 },
  { 742, 21, 21, 24, 1, -39 },
  { 798, 21, 24, 25, 2, -30 },
  { 861, 8, 13, 13, 2, -6 },
  { 874, 13, 5, 15, 1, -16 },
  { 883, 7, 8, 13, 3, -7 },
  { 890, 19, 37, 20, 1, -37 },
  { 978, 21, 38, 25, 2, -37 },
  { 1078, 15, 36, 25, 3, -36 },
  { 1146, 21, 37, 25, 2, -37 },
  { 1244, 21, 38, 25, 2, -37 },
  { 1344, 23, 37, 25, 1, -37 },
  { 1451, 21, 37, 25, 2, -36 },
  { 1549, 21, 38, 25, 2, -37 },
  { 1649, 22, 36, 25, 1, -36 },
  { 1748, 21, 38, 25, 2, -37 },
  { 1848, 21, 38, 25, 2, -37 },
  { 1948, 7, 29, 13, 3, -28 },
  { 1974, 8, 35, 13, 2, -28 },
  { 2009, 21, 25, 25, 2, -31 },
  { 2075, 21, 15, 25, 2, -25 },
  { 2115, 21, 25, 25, 2, -31 },
  { 2181, 19, 38, 20, 0, -37 },
  { 2272, 34, 41, 39, 2, -37 },
  { 2447, 28, 36, 28, 0, -36 },
  { 2573, 22, 36, 28, 4, -36 },
  { 2672, 23, 38, 27, 2, -37 },
  { 2782, 24, 36, 31, 4, -36 },
  { 2890, 17, 36, 24, 4, -36 },
  { 2967, 17, 36, 23, 4, -36 },
  { 3044, 25, 38, 31, 3, -37 },
  { 3163, 24, 36, 32, 4, -36 },
  { 3271, 13, 36, 16, 2, -36 },
  { 3330, 13, 46, 14, -3, -36 },
  { 3405, 24, 36, 27, 4, -36 },
  { 3513, 17, 36, 22, 4, -36 },
  { 3590, 33, 36, 41, 4, -36 },
  { 3739, 26, 36, 34, 4, -36 },
  { 3856, 28, 38, 33, 2, -37 },
  { 3989, 21, 36, 26, 4, -36 },
  { 4084, 28, 46, 33, 2, -37 },
  { 4245, 23, 36, 27, 4, -36 },
  { 4349, 20, 38, 23, 2, -37 },
  { 4444, 22, 36, 23, 1, -36 },
  { 4543, 23, 37, 31, 4, -36 },
  { 4650, 27, 36, 27, 0, -36 },
  { 4772, 41, 36, 41, 0, -36 },
  { 4957, 26, 36, 26, 0, -36 },
  { 5074, 25, 36, 25, 0, -36 },
  { 5187, 21, 36, 23, 1, -36 },
  { 5282, 12, 45, 16, 3, -37 },
  { 5350, 19, 37, 20, 1, -37 },
  { 5438, 12, 45, 16, 1, -37 },
  { 5506, 24, 21, 27, 1, -36 },
  { 5569, 22, 4, 21, 0, 4 },
  { 5580, 12, 8, 16, 2, -39 },
  { 5592, 20, 29, 25, 2, -28 },
  { 5665, 22, 40, 27, 3, -39 },
  { 5775, 18, 29, 21, 2, -28 },
  { 5841, 22, 40, 27, 2, -39 },
  { 5951, 21, 29, 25, 2, -28 },
  { 6028, 16, 39, 16, 1, -39 },
  { 6106, 22, 40, 27, 2, -28 },
  { 6216, 21, 39, 27, 3, -39 },
  { 6319, 7, 38, 13, 3, -38 },
  { 6353, 12, 50, 13, -2, -38 },
  { 6428, 22, 39, 25, 3, -39 },
  { 6536, 6, 39, 13, 3, -39 },
  { 6566, 34, 28, 41, 3, -28 },
  { 6685, 21, 28, 27, 3, -28 },
  { 6759, 22, 29, 26, 2, -28 },
  { 6839, 22, 40, 27, 3, -28 },
  { 6949, 22, 40, 27, 2, -28 },
  { 7059, 15, 28, 18, 3, -28 },
  { 7112, 17, 29, 20, 2, -28 },
  { 7174, 15, 35, 17, 1, -34 },
  { 7240, 21, 29, 27, 3, -28 },
  { 7317, 23, 28, 23, 0, -28 },
  { 7398, 36, 28, 36, 0, -28 },
  { 7524, 23, 28, 23, 0, -28 },
  { 7605, 23, 40, 23, 0, -28 },
  { 7720, 17, 28, 19, 1, -28 },
  { 7780, 16, 44, 19, 1, -36 },
  { 7868, 5, 51, 24, 9, -39 },
  { 7900, 15, 44, 19, 2, -36 },
  { 7983, 21, 8, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD51PT7B_H_
