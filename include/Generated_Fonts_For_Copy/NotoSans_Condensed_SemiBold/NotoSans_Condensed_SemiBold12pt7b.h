#ifndef _NOTOSANS_CONDENSED_SEMIBOLD12PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xBA, 0xAA, 0x28, 0xA2, 0x9F, 0x28, 0xAF, 0xD4, 0x50,
  0x4F, 0xCC, 0xE3, 0x5F, 0x44, 0x62, 0x3B, 0x35, 0x1A, 0x87, 0xB3, 0x54,
  0x5A, 0x25, 0x33, 0x00, 0x30, 0xF1, 0x23, 0xC7, 0x0A, 0xF3, 0x66, 0x7E,
  0xF0, 0x5A, 0xAA, 0xB4, 0xC9, 0x92, 0x49, 0x6B, 0x00, 0x23, 0x6C, 0xF5,
  0x00, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0, 0xC0, 0x18, 0x84, 0x42, 0x31,
  0x08, 0xC0, 0x33, 0xD3, 0x9C, 0xE5, 0x29, 0x70, 0x2E, 0x92, 0x49, 0x20,
  0x37, 0xC2, 0x11, 0x98, 0x88, 0xF8, 0x37, 0xC2, 0x37, 0x0C, 0x31, 0xF8,
  0x18, 0x63, 0x8E, 0x59, 0x6F, 0xC6, 0x18, 0xFF, 0x88, 0xF1, 0x1B, 0xE0,
  0x1B, 0xD0, 0xAF, 0xE5, 0x29, 0x78, 0xFF, 0xC2, 0x31, 0x18, 0xC4, 0x60,
  0x33, 0xD2, 0xB3, 0x2F, 0x39, 0x78, 0x33, 0xF3, 0x94, 0xBC, 0x23, 0x70,
  0xC6, 0x50, 0x05, 0x80, 0x09, 0xB0, 0xE1, 0x84, 0xF8, 0x3F, 0xF0, 0xC3,
  0x86, 0x7E, 0x40, 0x6F, 0x11, 0x26, 0x06, 0x60, 0x18, 0x64, 0x82, 0xBA,
  0xAB, 0xAA, 0xAA, 0x94, 0xC0, 0x7C, 0x30, 0x60, 0xE1, 0x46, 0x8F, 0x9F,
  0x62, 0xC6, 0xE7, 0xE7, 0x3F, 0x4E, 0x33, 0xF0, 0x37, 0xF1, 0x08, 0x42,
  0x19, 0x78, 0xE3, 0xE8, 0xA3, 0x8E, 0x38, 0xA6, 0xF0, 0xFF, 0x88, 0xF8,
  0x88, 0xF0, 0xFF, 0x88, 0xFF, 0x88, 0x80, 0x39, 0xEC, 0x20, 0x9E, 0x78,
  0xF3, 0x7C, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xF6, 0x66, 0x66,
  0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x8C, 0xE5, 0x4E, 0x7A, 0x53,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC3, 0xC7, 0xE7, 0xA7, 0xA7, 0xAB,
  0xBB, 0x9B, 0x9B, 0xC7, 0x1E, 0x69, 0xB6, 0x59, 0xE3, 0x8C, 0x33, 0xE8,
  0xE3, 0x86, 0x18, 0xF3, 0x78, 0xE7, 0xA7, 0x39, 0x7A, 0x10, 0x80, 0x33,
  0xE8, 0xE3, 0x86, 0x18, 0xF3, 0x78, 0x60, 0xC0, 0xE7, 0xA7, 0x3F, 0x7A,
  0x53, 0x88, 0x33, 0xD0, 0x87, 0x0C, 0x33, 0xF0, 0xFF, 0xC8, 0x42, 0x10,
  0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x39, 0x78, 0x87, 0x14, 0xD2, 0x49,
  0xA3, 0x8C, 0x30, 0x88, 0xF3, 0x2C, 0xC9, 0x72, 0x55, 0x95, 0xE7, 0x30,
  0xCC, 0x33, 0x00, 0xCD, 0x27, 0x8C, 0x30, 0xC7, 0x92, 0xCC, 0xCF, 0x24,
  0x9E, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xC6, 0x22, 0x11, 0x08, 0xF8, 0xEA,
  0xAA, 0xAC, 0x82, 0x10, 0xC2, 0x10, 0xC2, 0x18, 0xE4, 0x92, 0x49, 0x27,
  0x80, 0x10, 0xC3, 0x12, 0x4B, 0x10, 0xF8, 0xC4, 0x32, 0xC2, 0xFC, 0xED,
  0xE0, 0x84, 0x29, 0xE9, 0xCE, 0x73, 0xF0, 0x3B, 0x91, 0x84, 0x21, 0xE0,
  0x0C, 0x32, 0xDF, 0x4F, 0x34, 0xD3, 0x7C, 0x33, 0xD3, 0xF4, 0x21, 0xE0,
  0x74, 0x7F, 0x44, 0x44, 0x40, 0x2D, 0xF4, 0xF3, 0x4D, 0x37, 0xC3, 0x49,
  0xC0, 0x84, 0x2D, 0xE9, 0xCE, 0x73, 0x98, 0xFF, 0x80, 0x55, 0x55, 0x57,
  0x84, 0x27, 0x2A, 0x73, 0xD2, 0x98, 0xFF, 0x80, 0xA6, 0xFF, 0x9B, 0x93,
  0x93, 0x93, 0x93, 0xB7, 0xA7, 0x39, 0xCE, 0x60, 0x31, 0xE4, 0xF3, 0x4D,
  0x27, 0x80, 0xA7, 0xA7, 0x39, 0xCF, 0xD0, 0x84, 0x00, 0x2D, 0xF4, 0xF3,
  0x4D, 0x37, 0xC3, 0x0C, 0x30, 0xBE, 0x49, 0x20, 0x35, 0xC7, 0x19, 0xF0,
  0x47, 0xF4, 0x44, 0x47, 0x9C, 0xE7, 0x39, 0xCF, 0xE0, 0x8E, 0x56, 0xB5,
  0x18, 0xC0, 0x99, 0xD9, 0x59, 0x57, 0x56, 0x66, 0x26, 0xCA, 0xDC, 0x67,
  0x2F, 0x20, 0x8E, 0x56, 0xB7, 0x18, 0xC4, 0x66, 0x00, 0xFF, 0x32, 0x64,
  0xF0, 0x13, 0x22, 0x2C, 0x62, 0x22, 0x30, 0xFF, 0xF0, 0x8E, 0x66, 0x63,
  0x26, 0x66, 0xC0, 0xFC, 0xC0,
};

const GFXglyph NotoSans_Condensed_SemiBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 4, 4, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 4, 10, 6, 1, -9 },
  { 17, 9, 9, 9, 0, -9 },
  { 28, 7, 9, 7, 0, -9 },
  { 36, 1, 4, 3, 1, -9 },
  { 37, 2, 11, 4, 1, -9 },
  { 40, 3, 11, 4, 0, -9 },
  { 45, 5, 5, 6, 0, -9 },
  { 49, 5, 6, 6, 0, -7 },
  { 53, 2, 3, 3, 0, -1 },
  { 54, 3, 1, 4, 0, -4 },
  { 55, 1, 2, 3, 1, -2 },
  { 56, 5, 9, 5, 0, -9 },
  { 62, 5, 9, 6, 0, -9 },
  { 68, 3, 9, 6, 1, -9 },
  { 72, 5, 9, 6, 0, -9 },
  { 78, 5, 9, 6, 0, -9 },
  { 84, 6, 9, 6, 0, -9 },
  { 91, 4, 9, 6, 1, -9 },
  { 96, 5, 9, 6, 0, -9 },
  { 102, 5, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 0, -9 },
  { 114, 5, 9, 6, 0, -9 },
  { 120, 1, 7, 3, 1, -7 },
  { 121, 2, 9, 3, 0, -7 },
  { 124, 5, 6, 6, 0, -7 },
  { 128, 5, 4, 6, 0, -6 },
  { 131, 5, 6, 6, 0, -7 },
  { 135, 4, 9, 5, 0, -9 },
  { 140, 8, 10, 9, 1, -9 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 5, 9, 7, 1, -9 },
  { 164, 5, 9, 6, 1, -9 },
  { 170, 6, 9, 7, 1, -9 },
  { 177, 4, 9, 6, 1, -9 },
  { 182, 4, 9, 5, 1, -9 },
  { 187, 6, 9, 7, 1, -9 },
  { 194, 6, 9, 7, 1, -9 },
  { 201, 4, 9, 4, 0, -9 },
  { 206, 3, 11, 3, -1, -9 },
  { 211, 5, 9, 6, 1, -9 },
  { 217, 4, 9, 5, 1, -9 },
  { 222, 8, 9, 10, 1, -9 },
  { 231, 6, 9, 8, 1, -9 },
  { 238, 6, 9, 8, 1, -9 },
  { 245, 5, 9, 6, 1, -9 },
  { 251, 6, 11, 8, 1, -9 },
  { 260, 5, 9, 6, 1, -9 },
  { 266, 5, 9, 6, 0, -9 },
  { 272, 5, 9, 6, 0, -9 },
  { 278, 5, 9, 7, 1, -9 },
  { 284, 6, 9, 6, 0, -9 },
  { 291, 10, 9, 10, 0, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 6, 0, -9 },
  { 317, 5, 9, 5, 0, -9 },
  { 323, 2, 11, 4, 1, -9 },
  { 326, 5, 9, 5, 0, -9 },
  { 332, 3, 11, 4, 0, -9 },
  { 337, 6, 6, 6, 0, -9 },
  { 342, 5, 1, 5, 0, 1 },
  { 343, 3, 2, 4, 0, -9 },
  { 344, 5, 7, 6, 0, -7 },
  { 349, 5, 9, 6, 1, -9 },
  { 355, 5, 7, 5, 0, -7 },
  { 360, 6, 9, 6, 0, -9 },
  { 367, 5, 7, 6, 0, -7 },
  { 372, 4, 9, 4, 0, -9 },
  { 377, 6, 10, 6, 0, -7 },
  { 385, 5, 9, 6, 1, -9 },
  { 391, 1, 9, 3, 1, -9 },
  { 393, 2, 12, 3, 0, -9 },
  { 396, 5, 9, 6, 1, -9 },
  { 402, 1, 9, 3, 1, -9 },
  { 404, 8, 7, 10, 1, -7 },
  { 411, 5, 7, 6, 1, -7 },
  { 416, 6, 7, 6, 0, -7 },
  { 422, 5, 10, 6, 1, -7 },
  { 429, 6, 10, 6, 0, -7 },
  { 437, 3, 7, 4, 1, -7 },
  { 440, 4, 7, 5, 0, -7 },
  { 444, 4, 8, 4, 0, -8 },
  { 448, 5, 7, 6, 1, -7 },
  { 453, 5, 7, 5, 0, -7 },
  { 458, 8, 7, 8, 0, -7 },
  { 465, 5, 7, 5, 0, -7 },
  { 470, 5, 10, 5, 0, -7 },
  { 477, 4, 7, 5, 0, -7 },
  { 481, 4, 11, 4, 0, -9 },
  { 487, 1, 12, 6, 2, -9 },
  { 489, 4, 11, 4, 0, -9 },
  { 495, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_SemiBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD12PT7B_H_
