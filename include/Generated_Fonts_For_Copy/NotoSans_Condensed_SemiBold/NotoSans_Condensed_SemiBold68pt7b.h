#ifndef _NOTOSANS_CONDENSED_SEMIBOLD68PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x7F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0x7F, 0x07, 0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF,
  0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80,
  0xFE, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFE,
  0xF3, 0xF8, 0xFF, 0x1E, 0x07, 0x3F, 0xC3, 0xC0, 0x27, 0xF8, 0x78, 0x00,
  0xFF, 0x0F, 0x00, 0x1F, 0xE1, 0xE0, 0x03, 0xFC, 0x3C, 0x00, 0x7F, 0x87,
  0x80, 0x07, 0xF8, 0xF0, 0x00, 0xFF, 0x9E, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x7F, 0xC0, 0x01, 0xE7,
  0xFC, 0x00, 0x3C, 0x7F, 0x80, 0x07, 0x87, 0xF0, 0x00, 0xF0, 0xFE, 0x00,
  0x1E, 0x1F, 0xC0, 0x03, 0xC3, 0xFC, 0x00, 0x78, 0xFF, 0xE0, 0x0F, 0x1F,
  0xFF, 0x81, 0xEF, 0xFB, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE1,
  0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0xE0, 0x7E, 0x07, 0xE1,
  0xF8, 0x7F, 0xF0, 0x7E, 0x0F, 0xE3, 0xF0, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF1, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0x0F,
  0xC3, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x03, 0xFC, 0x1F,
  0x87, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0x07,
  0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0x87, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0xCF, 0xF8, 0xFF,
  0x80, 0xFF, 0xBF, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xFF,
  0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xCF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xF1, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x02, 0x00, 0xFC, 0x01, 0x78, 0x1F, 0x81, 0xCF, 0xE3, 0xE1,
  0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x9F, 0xC0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFC,
  0x0F, 0xE0, 0x7E, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x00, 0xC0, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x08, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x87, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xEF, 0xF7, 0xFC, 0xFF, 0xFF, 0x8F, 0xF7,
  0xF0, 0xFF, 0x3E, 0x0F, 0xF3, 0xC0, 0xFF, 0x18, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xFC, 0x1F, 0x00,
  0x3F, 0xE1, 0xC0, 0x03, 0xFE, 0x08, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xF0,
  0x07, 0xFC, 0x1C, 0x00, 0x3F, 0xE0, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x40, 0x00, 0x3F, 0xE7, 0x00, 0x07,
  0xFE, 0x7F, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xD0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x03, 0xF7, 0xF8, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x7E, 0x3F, 0xC0, 0x01,
  0xFC, 0x7F, 0x80, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x18, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x83, 0xE0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0xC0, 0x00, 0x7F, 0xDE, 0x00, 0x3F,
  0xF3, 0xFC, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE3,
  0xFF, 0xC0, 0xFE, 0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x00,
  0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x3F,
  0xE0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF,
  0x7F, 0x0F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0x8F, 0xF0,
  0x03, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x10, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x7F, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFB, 0xFE, 0x7F, 0x07, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x7C, 0x03, 0xFE, 0x18, 0x00, 0xFF, 0x08, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xF8,
  0x7E, 0x00, 0xFF, 0xFE, 0x0F, 0xC7, 0xF0, 0x0F, 0xFF, 0xF0, 0x7E, 0x3F,
  0x00, 0xFF, 0xFF, 0x83, 0xF9, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xDF, 0xC0,
  0xFF, 0x07, 0xE0, 0x7E, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0x7F,
  0x01, 0xF8, 0x1F, 0xBF, 0x03, 0xF0, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F,
  0x81, 0xFF, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x0F, 0xE0,
  0x7F, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xF8, 0x1F,
  0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xFF,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF7, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xBF, 0x01, 0xF8, 0x1F, 0xE0, 0xFD, 0xFC, 0x0F,
  0xE1, 0xFF, 0x0F, 0xC7, 0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0x01, 0xFF,
  0xF3, 0xFF, 0xE1, 0xF8, 0x07, 0xFF, 0x8F, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xFC, 0xFF, 0x00, 0x3F, 0xF3,
  0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0xFF,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFB,
  0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0x7C, 0x0F, 0xFC, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x08, 0x1F, 0xFC, 0x00,
  0x70, 0x1F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x00,
  0x41, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xDF, 0xE0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xC3, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFD, 0x8F, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x00,
  0x3F, 0x7F, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xFF, 0xFD, 0xFC, 0x00, 0x1F,
  0xDF, 0xFF, 0xEF, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0xE7,
  0xFF, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0, 0x03, 0xF9, 0xFF,
  0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xFF, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0xFF,
  0x8F, 0xE0, 0x0F, 0xE3, 0xFF, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xFF, 0xE3,
  0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0x01, 0xF8, 0x3F, 0xFF, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F,
  0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFF, 0xFF, 0x03, 0xF8, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0xFD, 0xFE,
  0x00, 0x3F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xF3, 0xFC, 0x00, 0xFF, 0xFF,
  0x3F, 0xC0, 0x1F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x7F,
  0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF,
  0x80, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xFE, 0x01, 0xFE, 0x3F,
  0xFF, 0xC0, 0x3F, 0xE7, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0x00, 0x7F,
  0xCF, 0xFF, 0xE0, 0x07, 0xF9, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0x80,
  0x0F, 0xF7, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xEF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F,
  0xCF, 0xF0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x00,
  0x7F, 0xE1, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x01,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFC, 0x7F, 0xC0, 0x0E, 0x3F, 0xE0, 0x00, 0x8F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFA, 0x00, 0x01, 0xFE, 0xE0,
  0x00, 0xFF, 0xBF, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xFE, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFB, 0xF0,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFC, 0x7E, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xC3, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x07, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x3F,
  0x87, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x1F,
  0xC0, 0x7E, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x80, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x03, 0xF9, 0xFE,
  0x00, 0x07, 0xFB, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x07,
  0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xDF, 0xE0, 0x00, 0x1F, 0xDF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3E,
  0x03, 0xFE, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFE, 0x7F, 0xE0,
  0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xFB, 0xFE, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0x3F, 0x8F, 0xFF, 0xE7,
  0xF0, 0xFF, 0xF8, 0x7E, 0x0F, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x03, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x1F, 0xFE,
  0x07, 0xF9, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0x9F, 0xF8,
  0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03,
  0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xF0, 0x03, 0xFD, 0xFF,
  0x80, 0x3F, 0xEF, 0xFE, 0x03, 0xFE, 0x7F, 0xF8, 0x3F, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x87, 0xF1, 0xFF, 0xF8,
  0x3F, 0x87, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x7C,
  0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x06, 0x3F, 0xF8, 0x3E,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x18,
  0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x07, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE, 0x7F,
  0x0F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0x0F, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF,
  0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7,
  0xF0, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x3F, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03,
  0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x31,
  0xFF, 0x80, 0x3E, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0x02, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x03, 0xFF, 0xC3,
  0xF0, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0x7F, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0x7F, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xC7, 0xF0,
  0x1F, 0xF8, 0x7F, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF2, 0x00, 0x01, 0xFE, 0x38, 0x00, 0x7F, 0xE3, 0xFE,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0x0F, 0xF3,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x8F, 0xFE, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x01, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xC0, 0x00,
  0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x8F,
  0xE0, 0x0F, 0xF8, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0xFE, 0x00,
  0x7F, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFE,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xE1,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xEF, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0xFE, 0x1F, 0xFF,
  0x0F, 0xE3, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFE, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x01,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3,
  0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x3F, 0x87, 0xFF, 0x81,
  0xFC, 0x7F, 0xFE, 0x0F, 0xF7, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xE7, 0xFE, 0x00,
  0xFF, 0xBF, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF,
  0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFB, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xE1, 0xFE, 0x7F, 0xFE, 0x0F,
  0xF1, 0xFF, 0xE0, 0x7F, 0x87, 0xFE, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF8, 0x3F,
  0x03, 0xFF, 0xC3, 0xF0, 0x7F, 0xFE, 0x7F, 0x0F, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0x3F, 0xE0, 0x3F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x7F, 0x07,
  0xFF, 0xC7, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0x38, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xCF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFE, 0xFE, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFE,
  0x6F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xC0, 0x3C,
  0x7F, 0x00, 0x11, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x10, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01,
  0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xF7, 0xFC, 0x07, 0xFF, 0x7F, 0xE1,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F,
  0x1F, 0xFF, 0xC7, 0xF0, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0x07, 0xF0, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x3F, 0xF0, 0x03, 0xF9, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF7, 0xE0, 0x1F, 0xC3,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x3F, 0x03, 0xFC, 0x3F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xFE,
  0x1F, 0x8F, 0xC1, 0xFE, 0x07, 0xF8, 0x7E, 0x1F, 0x87, 0xF8, 0x1F, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xE1, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0x87, 0xE3, 0xFC, 0x03, 0xFC, 0xFC, 0x1F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF0,
  0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x03,
  0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x3F,
  0x7F, 0x80, 0x0F, 0xDF, 0x80, 0x7D, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xF7,
  0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x09, 0xFF, 0xE0,
  0x00, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0xC0,
  0x01, 0xFF, 0xE4, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 50, 17, 4, -49 },
  { 64, 22, 18, 29, 4, -49 },
  { 114, 34, 48, 36, 1, -48 },
  { 318, 27, 56, 33, 3, -52 },
  { 507, 48, 50, 53, 2, -49 },
  { 807, 38, 50, 40, 2, -49 },
  { 1045, 8, 18, 16, 4, -49 },
  { 1063, 17, 60, 21, 3, -49 },
  { 1191, 16, 60, 21, 2, -49 },
  { 1311, 27, 28, 31, 2, -52 },
  { 1406, 29, 32, 33, 2, -40 },
  { 1522, 12, 17, 17, 2, -8 },
  { 1548, 17, 7, 21, 2, -22 },
  { 1563, 9, 11, 17, 4, -10 },
  { 1576, 25, 49, 27, 1, -49 },
  { 1730, 27, 50, 33, 3, -49 },
  { 1899, 20, 49, 33, 4, -49 },
  { 2022, 28, 49, 33, 2, -49 },
  { 2194, 28, 50, 33, 2, -49 },
  { 2369, 31, 49, 33, 1, -49 },
  { 2559, 27, 50, 33, 3, -49 },
  { 2728, 28, 50, 33, 3, -49 },
  { 2903, 29, 49, 33, 2, -49 },
  { 3081, 29, 50, 33, 2, -49 },
  { 3263, 28, 50, 33, 2, -49 },
  { 3438, 10, 38, 17, 4, -37 },
  { 3486, 12, 46, 17, 2, -37 },
  { 3555, 29, 33, 33, 2, -41 },
  { 3675, 29, 20, 33, 2, -34 },
  { 3748, 29, 33, 33, 2, -41 },
  { 3868, 25, 50, 26, 0, -49 },
  { 4025, 45, 55, 51, 3, -49 },
  { 4335, 37, 49, 37, 0, -49 },
  { 4562, 30, 49, 38, 5, -49 },
  { 4746, 31, 50, 35, 3, -49 },
  { 4940, 32, 49, 41, 5, -49 },
  { 5136, 23, 49, 31, 5, -49 },
  { 5277, 23, 49, 31, 5, -49 },
  { 5418, 34, 50, 41, 3, -49 },
  { 5631, 32, 49, 42, 5, -49 },
  { 5827, 18, 49, 22, 2, -49 },
  { 5938, 17, 63, 18, -4, -49 },
  { 6072, 32, 49, 36, 5, -49 },
  { 6268, 23, 49, 30, 5, -49 },
  { 6409, 45, 49, 55, 5, -49 },
  { 6685, 35, 49, 45, 5, -49 },
  { 6900, 37, 50, 44, 3, -49 },
  { 7132, 28, 49, 35, 5, -49 },
  { 7304, 37, 61, 44, 3, -49 },
  { 7587, 31, 49, 37, 5, -49 },
  { 7777, 26, 50, 31, 3, -49 },
  { 7940, 29, 49, 31, 1, -49 },
  { 8118, 32, 50, 42, 5, -49 },
  { 8318, 36, 49, 36, 0, -49 },
  { 8539, 55, 49, 54, 0, -49 },
  { 8876, 34, 49, 34, 0, -49 },
  { 9085, 33, 49, 33, 0, -49 },
  { 9288, 28, 49, 30, 1, -49 },
  { 9460, 16, 60, 22, 4, -49 },
  { 9580, 25, 49, 27, 1, -49 },
  { 9734, 15, 60, 22, 2, -49 },
  { 9847, 33, 30, 35, 1, -49 },
  { 9971, 29, 4, 29, 0, 6 },
  { 9986, 15, 11, 21, 3, -52 },
  { 10007, 27, 39, 33, 2, -38 },
  { 10139, 29, 53, 36, 4, -52 },
  { 10332, 24, 39, 28, 3, -38 },
  { 10449, 28, 53, 36, 3, -52 },
  { 10635, 27, 39, 33, 3, -38 },
  { 10767, 22, 52, 21, 1, -52 },
  { 10910, 28, 54, 36, 3, -38 },
  { 11099, 28, 52, 36, 4, -52 },
  { 11281, 9, 51, 17, 4, -51 },
  { 11339, 15, 67, 17, -2, -51 },
  { 11465, 28, 52, 33, 5, -52 },
  { 11647, 8, 52, 17, 4, -52 },
  { 11699, 46, 38, 54, 4, -38 },
  { 11918, 28, 38, 36, 4, -38 },
  { 12051, 29, 39, 35, 3, -38 },
  { 12193, 29, 54, 36, 4, -38 },
  { 12389, 28, 54, 36, 3, -38 },
  { 12578, 20, 38, 25, 4, -38 },
  { 12673, 23, 39, 27, 2, -38 },
  { 12786, 20, 46, 23, 1, -45 },
  { 12901, 28, 38, 36, 4, -37 },
  { 13034, 31, 37, 31, 0, -37 },
  { 13178, 46, 37, 48, 1, -37 },
  { 13391, 29, 37, 31, 1, -37 },
  { 13526, 31, 53, 31, 0, -37 },
  { 13732, 22, 37, 26, 2, -37 },
  { 13834, 21, 60, 25, 1, -49 },
  { 13992, 7, 68, 32, 12, -52 },
  { 14052, 20, 60, 25, 3, -49 },
  { 14202, 29, 10, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_SemiBold68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD68PT7B_H_
