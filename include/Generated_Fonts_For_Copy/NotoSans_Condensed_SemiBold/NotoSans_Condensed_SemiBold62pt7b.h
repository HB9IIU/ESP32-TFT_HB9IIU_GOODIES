#ifndef _NOTOSANS_CONDENSED_SEMIBOLD62PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLD62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x7E,
  0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xE3,
  0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x9F, 0xF3, 0x87, 0x8F, 0xF1, 0xC0, 0x47, 0xF0, 0xE0,
  0x03, 0xF8, 0x70, 0x01, 0xFC, 0x38, 0x00, 0xFE, 0x1C, 0x00, 0x7F, 0x0E,
  0x00, 0x3F, 0xC7, 0x00, 0x0F, 0xF3, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xEF, 0xF8, 0x00, 0x71, 0xFC, 0x00, 0x38, 0xFE, 0x00, 0x1C, 0x3F,
  0x80, 0x0E, 0x1F, 0xC0, 0x07, 0x0F, 0xF0, 0x03, 0x8F, 0xEE, 0x01, 0xC7,
  0xF7, 0xC0, 0xEF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xF3, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x07, 0xC0, 0xF8, 0x7C, 0x3F, 0xF0, 0x7E,
  0x1F, 0x8F, 0xC7, 0xFF, 0x87, 0xE1, 0xF8, 0xF8, 0xFF, 0xFC, 0x3F, 0x3F,
  0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF1, 0xF1, 0xFC, 0xFE, 0x1F, 0xFE, 0x3F,
  0x1F, 0x87, 0xE1, 0xFF, 0xC3, 0xF1, 0xF8, 0x7E, 0x0F, 0xF8, 0x3E, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x00,
  0x1F, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0x87,
  0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF0, 0x7F, 0xCF, 0xF1, 0xFE, 0x07, 0xF9, 0xFC, 0x3F, 0xC0, 0x7F,
  0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xC0,
  0x0F, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F,
  0xFC, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00, 0xF8, 0x04, 0xF0, 0x7C,
  0x1E, 0x7F, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xFC, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x07, 0xC0,
  0x07, 0x01, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xF3,
  0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFE, 0xFF, 0x3F, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF,
  0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xDF, 0xDF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0x7C, 0x3F, 0xCE, 0x0F, 0xF1, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFC, 0x07, 0xFC, 0x1C, 0x00, 0xFF, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0x3F, 0xFC, 0x7C, 0x03, 0xFE, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xE0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3E,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0x3F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFE, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xF8, 0x60, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0x00,
  0x1F, 0xC7, 0xFC, 0x07, 0xE3, 0xFF, 0x81, 0xF9, 0xFF, 0xF0, 0x7E, 0xFF,
  0xFE, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFE, 0xFF,
  0x80, 0x7F, 0xBF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x83, 0xFE,
  0x3F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0xDF, 0xE0, 0x3F, 0xF7, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xDF, 0x87, 0xFF, 0xF7, 0xE0, 0xFF, 0xF9, 0xF8, 0x1F, 0xFC, 0xFE, 0x03,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x0F, 0x0F, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xCF, 0xF3, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xF7,
  0xFF, 0x1E, 0x01, 0xFE, 0x10, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x03,
  0xE1, 0xF8, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x7C,
  0x07, 0xFF, 0xF8, 0x3E, 0x7E, 0x07, 0xFF, 0xFC, 0x1F, 0xBF, 0x07, 0xF0,
  0x7E, 0x0F, 0xDF, 0x03, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF0, 0x1F, 0x81,
  0xFF, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0xF0,
  0x7C, 0x03, 0xF0, 0x3F, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x3E, 0x03,
  0xFF, 0x03, 0xE0, 0x3F, 0x03, 0xFF, 0x81, 0xF0, 0x1F, 0x81, 0xFF, 0xC0,
  0xF8, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x07, 0xE0, 0x7D, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0xFC, 0x1F, 0xC3, 0xFC, 0x3E, 0x7E, 0x07, 0xFF, 0xDF, 0xFF,
  0x1F, 0x03, 0xFF, 0xEF, 0xFF, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F,
  0x9F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0,
  0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xFC,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFD, 0xFC,
  0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3C, 0x1F, 0xF0, 0x00, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x04,
  0x0F, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xF8, 0xFE, 0x00, 0x7F,
  0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF9, 0xFC,
  0x00, 0xFF, 0x8F, 0xE0, 0x1F, 0xFC, 0x7F, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00,
  0x3C, 0x0F, 0xF8, 0x00, 0x10, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0x00,
  0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x1C, 0x00, 0xFE, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x07,
  0xF8, 0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x7F, 0xC0, 0x07, 0xF3, 0xFC, 0x00,
  0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xFF, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0xFD, 0xF8, 0x00,
  0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0x7F, 0xFD, 0xFC, 0x00, 0x3F, 0x7F,
  0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0xFE, 0xFE,
  0x00, 0x7E, 0x7F, 0xFE, 0x7E, 0x00, 0x7E, 0x7F, 0xFE, 0x7E, 0x00, 0x7E,
  0x7F, 0xFE, 0x7E, 0x00, 0xFC, 0x7F, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0xFE,
  0x3F, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x01, 0xF8, 0x7F, 0xFE, 0x3F, 0x81,
  0xF8, 0x7F, 0xFE, 0x1F, 0x81, 0xF8, 0x7F, 0xFE, 0x1F, 0x83, 0xF8, 0x7F,
  0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC3, 0xF0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xE0,
  0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFE,
  0x07, 0xEF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xDF, 0xE0,
  0x0F, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0x3F, 0xC0, 0x3F, 0xFE, 0x3F, 0x80,
  0x7F, 0xFE, 0x7F, 0x80, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xF8, 0xFF, 0x03,
  0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x1F,
  0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0x03, 0xF8, 0x7F, 0xFE, 0x07, 0xF8, 0xFF,
  0xFC, 0x07, 0xF0, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF,
  0xE0, 0x1F, 0xE7, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x80, 0x3F, 0xDF, 0xFF,
  0x00, 0x3F, 0xBF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xF8, 0x1F, 0xFD, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xEF, 0xE0, 0x3F, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0x0F, 0xE0,
  0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xE0, 0x7C, 0x7F, 0x80, 0x0C, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x9F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0xFE, 0x07,
  0xE3, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7E, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xE0, 0x07,
  0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0,
  0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E, 0x01, 0xFB, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x1F, 0xBF,
  0x80, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFB,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF7, 0xFE, 0x07, 0x00, 0xFF, 0x04, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0x7F, 0x80,
  0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF,
  0x3F, 0x1F, 0xFE, 0x1F, 0x0F, 0xFC, 0x1F, 0x00, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xFF, 0x83, 0xF9,
  0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3,
  0xFF, 0x83, 0xFC, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF0, 0x03,
  0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF,
  0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xF8, 0xFC, 0xFF, 0xFC,
  0x3F, 0x1F, 0xFE, 0x0F, 0xC1, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0x81, 0xCF, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x02, 0xFF, 0x80, 0x73,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0xF1, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF,
  0xDF, 0xCF, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0x7F,
  0x80, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFD, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0xFF, 0xCF, 0xFC, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0x9F, 0xC3, 0xFF, 0xC3, 0xF0,
  0x3F, 0xE0, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F,
  0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x87, 0xF8, 0x00, 0xC3, 0xFF, 0x07,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC1, 0xFF, 0xC7,
  0xF0, 0xFF, 0xF9, 0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xDF, 0xCF, 0xFF,
  0xFF, 0xF7, 0xFC, 0x1F, 0xFD, 0xFE, 0x03, 0xFF, 0x7F, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x03,
  0xFF, 0x3F, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0x7F,
  0xFE, 0x7F, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF, 0x87, 0xF0, 0x06, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x40, 0x00, 0x7F, 0x9C, 0x00, 0x3F, 0xC7, 0xF0,
  0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0xFF, 0xE1, 0xFC, 0xFF, 0xF8,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFC, 0x3F,
  0xEF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x00, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0xA3, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xBF, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F,
  0xBF, 0x80, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7E, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3F, 0xFF, 0x1F,
  0xFF, 0x9F, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x1F, 0xF0, 0x7E, 0x1F, 0xFC, 0x3F,
  0x1F, 0xFF, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0x87, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F,
  0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x1F,
  0xE0, 0x3F, 0x0F, 0xFE, 0x0F, 0xC7, 0xFF, 0xC3, 0xFB, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x0F, 0xF3, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x07, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xEF, 0xFF, 0xE3, 0xFB, 0xFF, 0xF0, 0xFE, 0x7F, 0xF8, 0x3F, 0x87, 0xFC,
  0x0F, 0xE0, 0x38, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xC1, 0xFF, 0xC7, 0xF0, 0xFF, 0xF9, 0xFC,
  0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x1F,
  0xFD, 0xFE, 0x03, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x3F, 0xF7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0x7F, 0xFE, 0x7F, 0x0F, 0xFF,
  0x1F, 0xC0, 0xFF, 0x87, 0xF0, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xFE, 0xFC, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xF7, 0xF3, 0xFC, 0x03, 0x9F, 0xC0, 0x04, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F,
  0xEF, 0xF7, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x06, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0x3F, 0x1F, 0xFF,
  0x1F, 0x83, 0xFE, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xBF,
  0x80, 0x3F, 0xF0, 0x0F, 0xE7, 0xF8, 0x07, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xFF,
  0x00, 0xFC, 0x3F, 0x80, 0xFB, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x7E, 0x07,
  0xF0, 0x7F, 0x03, 0xE7, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0x9F, 0x07, 0xF0, 0x1F, 0xC3, 0xE3, 0xF0, 0xFE, 0x03, 0xF8,
  0x7C, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0x87, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0,
  0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0x83, 0xF3,
  0xF8, 0x03, 0xF9, 0xF0, 0x7E, 0x7F, 0x00, 0x7F, 0x3E, 0x07, 0xCF, 0xC0,
  0x0F, 0xEF, 0xC0, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x1F, 0x7F, 0x00, 0x1F,
  0xBF, 0x03, 0xEF, 0xE0, 0x03, 0xF7, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8,
  0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x23, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x47, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x80, 0x03, 0xFF, 0x20, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 20, 16, 27, 3, -44 },
  { 86, 31, 44, 33, 1, -44 },
  { 257, 25, 51, 30, 3, -47 },
  { 417, 44, 46, 48, 2, -45 },
  { 670, 35, 46, 37, 2, -45 },
  { 872, 8, 16, 14, 3, -44 },
  { 888, 15, 54, 19, 3, -44 },
  { 990, 15, 54, 19, 1, -44 },
  { 1092, 25, 25, 29, 2, -47 },
  { 1171, 26, 30, 30, 2, -37 },
  { 1269, 10, 15, 16, 2, -7 },
  { 1288, 15, 7, 19, 2, -20 },
  { 1302, 9, 10, 16, 3, -9 },
  { 1314, 23, 45, 24, 1, -45 },
  { 1444, 26, 46, 30, 2, -45 },
  { 1594, 18, 44, 30, 4, -44 },
  { 1693, 26, 45, 30, 2, -45 },
  { 1840, 25, 46, 30, 2, -45 },
  { 1984, 28, 44, 30, 1, -44 },
  { 2138, 24, 45, 30, 3, -44 },
  { 2273, 26, 46, 30, 2, -45 },
  { 2423, 26, 44, 30, 2, -44 },
  { 2566, 26, 46, 30, 2, -45 },
  { 2716, 26, 46, 30, 2, -45 },
  { 2866, 8, 35, 16, 4, -34 },
  { 2901, 10, 42, 16, 2, -34 },
  { 2954, 26, 30, 30, 2, -37 },
  { 3052, 26, 18, 30, 2, -31 },
  { 3111, 26, 30, 30, 2, -37 },
  { 3209, 23, 46, 24, 0, -45 },
  { 3342, 41, 50, 47, 3, -45 },
  { 3599, 34, 44, 34, 0, -44 },
  { 3786, 27, 44, 34, 5, -44 },
  { 3935, 28, 46, 32, 3, -45 },
  { 4096, 29, 44, 37, 5, -44 },
  { 4256, 21, 44, 29, 5, -44 },
  { 4372, 20, 44, 28, 5, -44 },
  { 4482, 31, 46, 38, 3, -45 },
  { 4661, 29, 44, 39, 5, -44 },
  { 4821, 16, 44, 20, 2, -44 },
  { 4909, 16, 57, 17, -4, -44 },
  { 5023, 29, 44, 33, 5, -44 },
  { 5183, 21, 44, 27, 5, -44 },
  { 5299, 40, 44, 50, 5, -44 },
  { 5519, 31, 44, 41, 5, -44 },
  { 5690, 34, 46, 40, 3, -45 },
  { 5886, 25, 44, 32, 5, -44 },
  { 6024, 34, 56, 40, 3, -45 },
  { 6262, 28, 44, 33, 5, -44 },
  { 6416, 24, 46, 28, 2, -45 },
  { 6554, 27, 44, 28, 1, -44 },
  { 6703, 29, 45, 38, 4, -44 },
  { 6867, 33, 44, 33, 0, -44 },
  { 7049, 50, 44, 50, 0, -44 },
  { 7324, 31, 44, 31, 0, -44 },
  { 7495, 30, 44, 30, 0, -44 },
  { 7660, 25, 44, 28, 1, -44 },
  { 7798, 14, 54, 20, 4, -44 },
  { 7893, 23, 45, 24, 1, -45 },
  { 8023, 14, 54, 20, 2, -44 },
  { 8118, 30, 26, 32, 1, -44 },
  { 8216, 26, 4, 26, 0, 5 },
  { 8229, 14, 9, 19, 2, -47 },
  { 8245, 24, 35, 30, 2, -34 },
  { 8350, 26, 48, 33, 4, -47 },
  { 8506, 21, 35, 26, 3, -34 },
  { 8598, 26, 48, 33, 3, -47 },
  { 8754, 25, 35, 30, 3, -34 },
  { 8864, 20, 47, 19, 1, -47 },
  { 8982, 26, 49, 33, 3, -34 },
  { 9142, 25, 47, 33, 4, -47 },
  { 9289, 8, 47, 15, 4, -47 },
  { 9336, 14, 62, 15, -2, -47 },
  { 9445, 27, 47, 31, 4, -47 },
  { 9604, 7, 47, 15, 4, -47 },
  { 9646, 41, 34, 49, 4, -34 },
  { 9821, 25, 34, 33, 4, -34 },
  { 9928, 26, 35, 32, 3, -34 },
  { 10042, 26, 49, 33, 4, -34 },
  { 10202, 26, 49, 33, 3, -34 },
  { 10362, 18, 34, 22, 4, -34 },
  { 10439, 21, 35, 25, 2, -34 },
  { 10531, 18, 42, 21, 1, -41 },
  { 10626, 25, 35, 33, 4, -34 },
  { 10736, 28, 34, 28, 0, -34 },
  { 10855, 43, 34, 44, 0, -34 },
  { 11038, 27, 34, 28, 0, -34 },
  { 11153, 28, 49, 28, 0, -34 },
  { 11325, 20, 34, 24, 2, -34 },
  { 11410, 19, 54, 23, 1, -44 },
  { 11539, 6, 61, 29, 11, -47 },
  { 11585, 19, 54, 23, 2, -44 },
  { 11714, 26, 10, 30, 2, -27 },
};

const GFXfont NotoSans_Condensed_SemiBold62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBold62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBold62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLD62PT7B_H_
