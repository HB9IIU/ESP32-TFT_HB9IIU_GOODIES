#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_ExtraLightItalic6pt7b, 6, "RobotoMono_ExtraLightItalic6pt7b" },
  { &RobotoMono_ExtraLightItalic7pt7b, 7, "RobotoMono_ExtraLightItalic7pt7b" },
  { &RobotoMono_ExtraLightItalic8pt7b, 8, "RobotoMono_ExtraLightItalic8pt7b" },
  { &RobotoMono_ExtraLightItalic9pt7b, 9, "RobotoMono_ExtraLightItalic9pt7b" },
  { &RobotoMono_ExtraLightItalic10pt7b, 10, "RobotoMono_ExtraLightItalic10pt7b" },
  { &RobotoMono_ExtraLightItalic11pt7b, 11, "RobotoMono_ExtraLightItalic11pt7b" },
  { &RobotoMono_ExtraLightItalic12pt7b, 12, "RobotoMono_ExtraLightItalic12pt7b" },
  { &RobotoMono_ExtraLightItalic13pt7b, 13, "RobotoMono_ExtraLightItalic13pt7b" },
  { &RobotoMono_ExtraLightItalic14pt7b, 14, "RobotoMono_ExtraLightItalic14pt7b" },
  { &RobotoMono_ExtraLightItalic15pt7b, 15, "RobotoMono_ExtraLightItalic15pt7b" },
  { &RobotoMono_ExtraLightItalic16pt7b, 16, "RobotoMono_ExtraLightItalic16pt7b" },
  { &RobotoMono_ExtraLightItalic17pt7b, 17, "RobotoMono_ExtraLightItalic17pt7b" },
  { &RobotoMono_ExtraLightItalic18pt7b, 18, "RobotoMono_ExtraLightItalic18pt7b" },
  { &RobotoMono_ExtraLightItalic19pt7b, 19, "RobotoMono_ExtraLightItalic19pt7b" },
  { &RobotoMono_ExtraLightItalic20pt7b, 20, "RobotoMono_ExtraLightItalic20pt7b" },
  { &RobotoMono_ExtraLightItalic21pt7b, 21, "RobotoMono_ExtraLightItalic21pt7b" },
  { &RobotoMono_ExtraLightItalic22pt7b, 22, "RobotoMono_ExtraLightItalic22pt7b" },
  { &RobotoMono_ExtraLightItalic23pt7b, 23, "RobotoMono_ExtraLightItalic23pt7b" },
  { &RobotoMono_ExtraLightItalic24pt7b, 24, "RobotoMono_ExtraLightItalic24pt7b" },
  { &RobotoMono_ExtraLightItalic25pt7b, 25, "RobotoMono_ExtraLightItalic25pt7b" },
  { &RobotoMono_ExtraLightItalic26pt7b, 26, "RobotoMono_ExtraLightItalic26pt7b" },
  { &RobotoMono_ExtraLightItalic27pt7b, 27, "RobotoMono_ExtraLightItalic27pt7b" },
  { &RobotoMono_ExtraLightItalic28pt7b, 28, "RobotoMono_ExtraLightItalic28pt7b" },
  { &RobotoMono_ExtraLightItalic29pt7b, 29, "RobotoMono_ExtraLightItalic29pt7b" },
  { &RobotoMono_ExtraLightItalic30pt7b, 30, "RobotoMono_ExtraLightItalic30pt7b" },
  { &RobotoMono_ExtraLightItalic31pt7b, 31, "RobotoMono_ExtraLightItalic31pt7b" },
  { &RobotoMono_ExtraLightItalic32pt7b, 32, "RobotoMono_ExtraLightItalic32pt7b" },
  { &RobotoMono_ExtraLightItalic33pt7b, 33, "RobotoMono_ExtraLightItalic33pt7b" },
  { &RobotoMono_ExtraLightItalic34pt7b, 34, "RobotoMono_ExtraLightItalic34pt7b" },
  { &RobotoMono_ExtraLightItalic35pt7b, 35, "RobotoMono_ExtraLightItalic35pt7b" },
  { &RobotoMono_ExtraLightItalic36pt7b, 36, "RobotoMono_ExtraLightItalic36pt7b" },
  { &RobotoMono_ExtraLightItalic37pt7b, 37, "RobotoMono_ExtraLightItalic37pt7b" },
  { &RobotoMono_ExtraLightItalic38pt7b, 38, "RobotoMono_ExtraLightItalic38pt7b" },
  { &RobotoMono_ExtraLightItalic39pt7b, 39, "RobotoMono_ExtraLightItalic39pt7b" },
  { &RobotoMono_ExtraLightItalic40pt7b, 40, "RobotoMono_ExtraLightItalic40pt7b" },
  { &RobotoMono_ExtraLightItalic41pt7b, 41, "RobotoMono_ExtraLightItalic41pt7b" },
  { &RobotoMono_ExtraLightItalic42pt7b, 42, "RobotoMono_ExtraLightItalic42pt7b" },
  { &RobotoMono_ExtraLightItalic43pt7b, 43, "RobotoMono_ExtraLightItalic43pt7b" },
  { &RobotoMono_ExtraLightItalic44pt7b, 44, "RobotoMono_ExtraLightItalic44pt7b" },
  { &RobotoMono_ExtraLightItalic45pt7b, 45, "RobotoMono_ExtraLightItalic45pt7b" },
  { &RobotoMono_ExtraLightItalic46pt7b, 46, "RobotoMono_ExtraLightItalic46pt7b" },
  { &RobotoMono_ExtraLightItalic47pt7b, 47, "RobotoMono_ExtraLightItalic47pt7b" },
  { &RobotoMono_ExtraLightItalic48pt7b, 48, "RobotoMono_ExtraLightItalic48pt7b" },
  { &RobotoMono_ExtraLightItalic49pt7b, 49, "RobotoMono_ExtraLightItalic49pt7b" },
  { &RobotoMono_ExtraLightItalic50pt7b, 50, "RobotoMono_ExtraLightItalic50pt7b" },
  { &RobotoMono_ExtraLightItalic51pt7b, 51, "RobotoMono_ExtraLightItalic51pt7b" },
  { &RobotoMono_ExtraLightItalic52pt7b, 52, "RobotoMono_ExtraLightItalic52pt7b" },
  { &RobotoMono_ExtraLightItalic53pt7b, 53, "RobotoMono_ExtraLightItalic53pt7b" },
  { &RobotoMono_ExtraLightItalic54pt7b, 54, "RobotoMono_ExtraLightItalic54pt7b" },
  { &RobotoMono_ExtraLightItalic55pt7b, 55, "RobotoMono_ExtraLightItalic55pt7b" },
  { &RobotoMono_ExtraLightItalic56pt7b, 56, "RobotoMono_ExtraLightItalic56pt7b" },
  { &RobotoMono_ExtraLightItalic57pt7b, 57, "RobotoMono_ExtraLightItalic57pt7b" },
  { &RobotoMono_ExtraLightItalic58pt7b, 58, "RobotoMono_ExtraLightItalic58pt7b" },
  { &RobotoMono_ExtraLightItalic59pt7b, 59, "RobotoMono_ExtraLightItalic59pt7b" },
  { &RobotoMono_ExtraLightItalic60pt7b, 60, "RobotoMono_ExtraLightItalic60pt7b" },
  { &RobotoMono_ExtraLightItalic61pt7b, 61, "RobotoMono_ExtraLightItalic61pt7b" },
  { &RobotoMono_ExtraLightItalic62pt7b, 62, "RobotoMono_ExtraLightItalic62pt7b" },
  { &RobotoMono_ExtraLightItalic63pt7b, 63, "RobotoMono_ExtraLightItalic63pt7b" },
  { &RobotoMono_ExtraLightItalic64pt7b, 64, "RobotoMono_ExtraLightItalic64pt7b" },
  { &RobotoMono_ExtraLightItalic65pt7b, 65, "RobotoMono_ExtraLightItalic65pt7b" },
  { &RobotoMono_ExtraLightItalic66pt7b, 66, "RobotoMono_ExtraLightItalic66pt7b" },
  { &RobotoMono_ExtraLightItalic67pt7b, 67, "RobotoMono_ExtraLightItalic67pt7b" },
  { &RobotoMono_ExtraLightItalic68pt7b, 68, "RobotoMono_ExtraLightItalic68pt7b" },
  { &RobotoMono_ExtraLightItalic69pt7b, 69, "RobotoMono_ExtraLightItalic69pt7b" },
  { &RobotoMono_ExtraLightItalic70pt7b, 70, "RobotoMono_ExtraLightItalic70pt7b" },
  { &RobotoMono_ExtraLightItalic71pt7b, 71, "RobotoMono_ExtraLightItalic71pt7b" },
  { &RobotoMono_ExtraLightItalic72pt7b, 72, "RobotoMono_ExtraLightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
