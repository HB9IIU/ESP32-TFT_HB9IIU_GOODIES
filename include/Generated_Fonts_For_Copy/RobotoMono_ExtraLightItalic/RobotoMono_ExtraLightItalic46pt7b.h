#ifndef _ROBOTOMONO_EXTRALIGHTITALIC46PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0x60, 0x20, 0xD8,
  0x26, 0x19, 0x86, 0x61, 0x98, 0x64, 0x11, 0x04, 0xC3, 0x30, 0xC0, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x08,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x40,
  0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x02, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x10, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x04, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0xE0, 0x1E, 0x3F, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x77, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x33,
  0x01, 0x80, 0xCC, 0x06, 0x06, 0x30, 0x18, 0x30, 0xC0, 0x60, 0xC3, 0x01,
  0x06, 0x0C, 0x0C, 0x30, 0x30, 0x30, 0x80, 0x61, 0x86, 0x01, 0xFC, 0x30,
  0x01, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x30, 0xFC, 0x01, 0x87, 0x18, 0x04, 0x30, 0x20, 0x30,
  0xC0, 0xC1, 0x86, 0x03, 0x0C, 0x18, 0x0C, 0x30, 0x60, 0x31, 0x81, 0x00,
  0xCC, 0x04, 0x02, 0x70, 0x10, 0x18, 0x80, 0x60, 0x60, 0x01, 0x83, 0x00,
  0x03, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0x83, 0x00, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x38, 0xC0, 0x00,
  0xC0, 0xC0, 0x33, 0x80, 0xC0, 0xC6, 0x01, 0x81, 0x98, 0x01, 0x83, 0x30,
  0x03, 0x8C, 0xC0, 0x03, 0x19, 0x80, 0x03, 0x63, 0x00, 0x07, 0xC6, 0x00,
  0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x7C, 0x0C, 0x01, 0xCC, 0x0F, 0x1E,
  0x1C, 0x0F, 0xF8, 0x1C, 0x33, 0x26, 0x66, 0x64, 0x4C, 0x00, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x40, 0x60, 0x2F, 0x06, 0x1F, 0x7E, 0x67, 0xC0, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x00, 0x06, 0x18, 0x00, 0xC0,
  0xC0, 0x18, 0x0C, 0x07, 0x00, 0x60, 0x20, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x63, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x60, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07,
  0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x86,
  0x00, 0x02, 0x18, 0x00, 0x0C, 0x60, 0x00, 0xF3, 0x00, 0x07, 0xCC, 0x00,
  0x33, 0x30, 0x01, 0x88, 0xC0, 0x0C, 0x66, 0x00, 0xE1, 0x98, 0x07, 0x06,
  0x60, 0x38, 0x19, 0x81, 0x80, 0x66, 0x0C, 0x01, 0x98, 0x60, 0x0C, 0xC7,
  0x00, 0x33, 0x38, 0x00, 0xCD, 0x80, 0x03, 0x3C, 0x00, 0x18, 0xE0, 0x00,
  0x63, 0x00, 0x01, 0x84, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x80,
  0xC0, 0x0C, 0x03, 0x80, 0xE0, 0x07, 0x9F, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x10, 0x07, 0x03, 0xF0, 0xF3, 0x3C, 0x2F, 0x06, 0x80, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x0E,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x06, 0x07, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x07, 0x87, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xE0, 0x06,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x78, 0x00, 0x6F, 0xFC, 0x01, 0xF0, 0x78, 0x0F, 0x00, 0x70, 0x10, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C,
  0x03, 0x00, 0xE0, 0x07, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x01, 0x00, 0x31, 0xFF, 0x03, 0x3C, 0x78, 0x6E, 0x01, 0xC7, 0x80,
  0x0C, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x02, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x87, 0x00, 0x30,
  0x38, 0x06, 0x01, 0xE3, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x80, 0x1C, 0x07, 0x00, 0xE0, 0x06, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80,
  0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x70, 0x1C,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1E, 0x0E, 0x00, 0xC0, 0x0C, 0x0E,
  0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x18,
  0xE0, 0x00, 0xE1, 0x80, 0x07, 0x03, 0x00, 0x38, 0x07, 0x87, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0x01, 0xC0, 0xE0, 0x0E,
  0x1C, 0x00, 0x61, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x30,
  0x03, 0x61, 0x80, 0x76, 0x1F, 0x3C, 0x40, 0x7F, 0x8C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x0E, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x70,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF,
  0x07, 0x01, 0xC7, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0x80,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0x80, 0x60, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x18, 0x1F, 0x02, 0x0C, 0x1E, 0xE0,
  0xC6, 0x0E, 0x0C, 0x31, 0x83, 0x02, 0x0C, 0xC1, 0x81, 0x83, 0x30, 0x40,
  0x60, 0xC8, 0x30, 0x10, 0x26, 0x08, 0x04, 0x09, 0x86, 0x03, 0x02, 0x41,
  0x80, 0xC1, 0x90, 0x40, 0x20, 0x6C, 0x10, 0x08, 0x1B, 0x0C, 0x06, 0x04,
  0xC3, 0x01, 0x83, 0x30, 0xC0, 0xC0, 0xCC, 0x30, 0x70, 0x63, 0x0C, 0x34,
  0x18, 0xC1, 0x99, 0x8C, 0x30, 0x7C, 0x3E, 0x04, 0x04, 0x04, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x60, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x20, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x18, 0x03, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x00, 0x06, 0x06, 0x00,
  0x38, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x30, 0x03, 0xC0, 0x60, 0x01,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3,
  0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x10, 0x00, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1C,
  0x07, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x10, 0x00, 0x30, 0x60, 0x01,
  0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x8F, 0x80, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x03, 0x80, 0x30, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x88, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x06, 0x04, 0x00, 0x1C, 0x18,
  0x00, 0xF0, 0x30, 0x03, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x18,
  0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0xFF, 0xB0, 0x07, 0xFE, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x07,
  0xC7, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x81,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x20, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x10, 0x30,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x1E, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x18, 0x03, 0x80, 0x04, 0x01, 0xC0, 0x03,
  0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x1C, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x87, 0x00, 0x00, 0x63, 0x80, 0x00, 0x19, 0xB0,
  0x00, 0x06, 0xCC, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xA0, 0x01, 0xE0, 0xD0, 0x00,
  0xF0, 0x6C, 0x00, 0xD8, 0x36, 0x00, 0x6C, 0x1B, 0x00, 0x66, 0x0D, 0x80,
  0x32, 0x04, 0x40, 0x33, 0x06, 0x30, 0x31, 0x83, 0x18, 0x18, 0xC1, 0x8C,
  0x18, 0x60, 0xC6, 0x0C, 0x30, 0x61, 0x0C, 0x30, 0x20, 0xC6, 0x18, 0x30,
  0x66, 0x0C, 0x18, 0x33, 0x06, 0x0C, 0x1B, 0x03, 0x06, 0x07, 0x01, 0x03,
  0x03, 0x81, 0x81, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xE0, 0x00, 0x60, 0xF0, 0x00, 0x30, 0x68, 0x00, 0x18, 0x36, 0x00, 0x0C,
  0x1B, 0x00, 0x0C, 0x0C, 0x80, 0x06, 0x06, 0x60, 0x03, 0x06, 0x30, 0x01,
  0x83, 0x0C, 0x00, 0xC1, 0x86, 0x00, 0x60, 0xC3, 0x00, 0x60, 0x60, 0xC0,
  0x30, 0x20, 0x60, 0x18, 0x30, 0x10, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x06,
  0x02, 0x06, 0x01, 0x83, 0x03, 0x00, 0xC1, 0x81, 0x00, 0x60, 0xC1, 0x80,
  0x18, 0x60, 0xC0, 0x0C, 0x30, 0x60, 0x06, 0x10, 0x30, 0x01, 0x98, 0x18,
  0x00, 0xCC, 0x08, 0x00, 0x26, 0x0C, 0x00, 0x1B, 0x06, 0x00, 0x0D, 0x83,
  0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1C, 0x06, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x86, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0xC0, 0x0C, 0x03,
  0x80, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x06, 0x00, 0x78, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x10, 0x00, 0xF0, 0x30,
  0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x1C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x20, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0x1E, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0C, 0x01, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x82, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x0E, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x1C, 0x01, 0xC0, 0x0F, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08,
  0x30, 0x00, 0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x70, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x73, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x38, 0x06, 0xC0,
  0x38, 0x04, 0xC0, 0x78, 0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0xD8, 0x08, 0xC0,
  0xD8, 0x18, 0xC0, 0xD8, 0x18, 0xC1, 0x98, 0x18, 0xC1, 0x98, 0x30, 0xC1,
  0x98, 0x30, 0xC3, 0x18, 0x30, 0xC3, 0x18, 0x20, 0xC3, 0x18, 0x60, 0xC6,
  0x18, 0x60, 0xC6, 0x18, 0x40, 0xC6, 0x08, 0xC0, 0xCC, 0x08, 0xC0, 0xCC,
  0x08, 0xC0, 0xC8, 0x09, 0x80, 0xD8, 0x09, 0x80, 0x98, 0x09, 0x80, 0x90,
  0x09, 0x00, 0xB0, 0x0B, 0x00, 0xB0, 0x0B, 0x00, 0xA0, 0x0A, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0xC0, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C,
  0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC3, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0x81, 0x80, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x02, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x01, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0x90, 0x01, 0x98, 0x03, 0x18, 0x03, 0x18, 0x06, 0x08, 0x06, 0x0C, 0x0C,
  0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0x83, 0x0C, 0x18,
  0x30, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0x60,
  0xE0, 0x03, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07,
  0x80, 0x18, 0x70, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x80, 0x01, 0xC6, 0x00, 0x1E, 0x30, 0x01, 0xB1, 0xC0,
  0x39, 0x87, 0xCF, 0x8C, 0x1F, 0xF0, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x03, 0xC0,
  0x18, 0xFF, 0x80, 0xCE, 0x0E, 0x07, 0xC0, 0x38, 0x38, 0x00, 0xC1, 0x80,
  0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x06, 0x30,
  0x00, 0x71, 0xC0, 0x03, 0x0F, 0x00, 0x30, 0x7C, 0x03, 0x82, 0x78, 0xF0,
  0x30, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xC1, 0xC0, 0x70,
  0x06, 0x0C, 0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x36, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x01, 0xC3, 0x00, 0x38, 0x38, 0x07,
  0x01, 0xE3, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0xF0, 0x60, 0x0F, 0xF8, 0xC0, 0x38, 0x39, 0x80, 0xC0, 0x1B, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0x38, 0x0F, 0x80, 0x3C, 0x7B, 0x00, 0x3F, 0xC6, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x70, 0x0E, 0x00, 0xC0, 0xC0, 0x07,
  0x0E, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x02, 0x70, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0xE0, 0x0E, 0x01,
  0xE3, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x30,
  0x1C, 0x1C, 0xC0, 0xC0, 0x1B, 0x06, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0,
  0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0x7C, 0x03, 0xC7, 0xB0,
  0x07, 0xF8, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x82, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x38, 0x03, 0x80, 0x78, 0x3C,
  0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x01, 0xE0,
  0x18, 0x7F, 0xC0, 0xCF, 0x07, 0x06, 0xC0, 0x18, 0x2C, 0x00, 0x63, 0x40,
  0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x43, 0x00, 0x0E,
  0x0C, 0x00, 0x70, 0x20, 0x03, 0x81, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x18,
  0x0E, 0x00, 0x60, 0x70, 0x01, 0x87, 0x00, 0x0C, 0x38, 0x00, 0x31, 0xC0,
  0x00, 0xCE, 0x00, 0x03, 0xEC, 0x00, 0x0F, 0x38, 0x00, 0x38, 0x60, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x80, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x06, 0x00, 0x70, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x0C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x78, 0x1E, 0x02, 0x7F, 0x1F, 0xE1, 0xB0,
  0xEE, 0x18, 0x78, 0x1E, 0x03, 0x1C, 0x07, 0x00, 0xC6, 0x01, 0xC0, 0x31,
  0x80, 0x60, 0x0C, 0x40, 0x18, 0x03, 0x30, 0x06, 0x00, 0x8C, 0x01, 0x80,
  0x63, 0x00, 0x60, 0x18, 0xC0, 0x30, 0x06, 0x30, 0x0C, 0x01, 0x88, 0x03,
  0x00, 0x66, 0x00, 0xC0, 0x11, 0x80, 0x30, 0x0C, 0x60, 0x08, 0x03, 0x18,
  0x06, 0x00, 0xC6, 0x01, 0x80, 0x31, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x02,
  0x30, 0x06, 0x01, 0x8C, 0x01, 0x00, 0x63, 0x00, 0xC0, 0x18, 0x80, 0x30,
  0x06, 0x00, 0x00, 0x07, 0x80, 0x61, 0xFF, 0x03, 0x38, 0x3C, 0x1B, 0x00,
  0x60, 0xB0, 0x01, 0x8F, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xFF, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x30, 0x30, 0x00,
  0x61, 0x80, 0x01, 0x8E, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x24, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x01, 0x80, 0x38, 0x03,
  0xC7, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x18, 0xFF, 0x80, 0x6F,
  0x07, 0x01, 0xF0, 0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC2,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C,
  0x38, 0x00, 0x60, 0xE0, 0x03, 0x03, 0xC0, 0x38, 0x19, 0xE3, 0xC0, 0x61,
  0xFE, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0xC0, 0xE0, 0xE6, 0x0C,
  0x01, 0xB0, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x38, 0x01,
  0xC0, 0xC0, 0x3E, 0x03, 0xCF, 0xB0, 0x0F, 0xF1, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC1,
  0x87, 0xFC, 0x33, 0xE0, 0x84, 0xE0, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xFE, 0x01, 0xE0, 0x78, 0x1C, 0x00, 0xE0, 0xC0, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x0E, 0x30, 0x00, 0x61, 0xC0, 0x0E, 0x07, 0xC3, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x60, 0x0F, 0xF0, 0x30, 0x00, 0x33,
  0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x26, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0,
  0x07, 0x86, 0x01, 0xD8, 0x78, 0xF1, 0x01, 0xFE, 0x30, 0xC0, 0x00, 0x1D,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x0C, 0x01, 0x90, 0x0E, 0x00,
  0x88, 0x07, 0x00, 0xC4, 0x02, 0xC0, 0x62, 0x03, 0x60, 0x61, 0x01, 0xB0,
  0x30, 0xC1, 0x98, 0x10, 0x60, 0xCC, 0x18, 0x30, 0x46, 0x0C, 0x18, 0x63,
  0x0C, 0x0C, 0x21, 0x86, 0x06, 0x30, 0xC2, 0x03, 0x18, 0x23, 0x01, 0x98,
  0x11, 0x80, 0xCC, 0x08, 0x80, 0x64, 0x04, 0xC0, 0x36, 0x02, 0x60, 0x1A,
  0x01, 0x60, 0x0F, 0x00, 0xB0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x07,
  0x00, 0xC0, 0x03, 0x00, 0x70, 0x03, 0x00, 0x18, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1B,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x06, 0x01,
  0xC0, 0x03, 0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0x01, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xCF, 0x3C, 0x00, 0x66, 0x07, 0x00, 0x66,
  0x01, 0xC0, 0x32, 0x00, 0x70, 0x33, 0x00, 0x1F, 0xF1, 0x80, 0x03, 0xF0,
};

const GFXglyph RobotoMono_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 8, 33, 27, 9, -33 },
  { 34, 10, 10, 27, 11, -35 },
  { 47, 26, 33, 27, 1, -33 },
  { 155, 22, 43, 27, 3, -38 },
  { 274, 22, 33, 27, 3, -33 },
  { 365, 23, 33, 27, 2, -33 },
  { 460, 4, 10, 27, 13, -35 },
  { 465, 14, 48, 27, 8, -37 },
  { 549, 14, 48, 27, 4, -37 },
  { 633, 20, 19, 27, 6, -33 },
  { 681, 22, 24, 27, 3, -27 },
  { 747, 6, 10, 27, 5, -4 },
  { 755, 16, 2, 27, 5, -16 },
  { 759, 4, 3, 27, 10, -3 },
  { 761, 21, 36, 27, 4, -33 },
  { 856, 22, 33, 27, 3, -33 },
  { 947, 12, 33, 27, 7, -33 },
  { 997, 22, 33, 27, 1, -33 },
  { 1088, 22, 33, 27, 1, -33 },
  { 1179, 23, 33, 27, 1, -33 },
  { 1274, 22, 33, 27, 4, -33 },
  { 1365, 20, 33, 27, 3, -33 },
  { 1448, 20, 33, 27, 6, -33 },
  { 1531, 22, 33, 27, 3, -33 },
  { 1622, 20, 33, 27, 4, -33 },
  { 1705, 8, 23, 27, 11, -23 },
  { 1728, 9, 29, 27, 9, -23 },
  { 1761, 20, 18, 27, 4, -24 },
  { 1806, 21, 11, 27, 3, -20 },
  { 1835, 20, 18, 27, 3, -24 },
  { 1880, 17, 33, 27, 7, -33 },
  { 1951, 26, 33, 27, 1, -33 },
  { 2059, 23, 33, 27, 0, -33 },
  { 2154, 23, 33, 27, 2, -33 },
  { 2249, 22, 33, 27, 3, -33 },
  { 2340, 23, 33, 27, 2, -33 },
  { 2435, 24, 33, 27, 2, -33 },
  { 2534, 25, 33, 27, 2, -33 },
  { 2638, 22, 34, 27, 3, -33 },
  { 2732, 25, 33, 27, 1, -33 },
  { 2836, 24, 33, 27, 2, -33 },
  { 2935, 23, 33, 27, 2, -33 },
  { 3030, 26, 33, 27, 2, -33 },
  { 3138, 18, 33, 27, 3, -33 },
  { 3213, 25, 33, 27, 2, -33 },
  { 3317, 25, 33, 27, 1, -33 },
  { 3421, 22, 33, 27, 3, -33 },
  { 3512, 24, 33, 27, 3, -33 },
  { 3611, 24, 39, 27, 2, -33 },
  { 3728, 23, 33, 27, 2, -33 },
  { 3823, 24, 33, 27, 2, -33 },
  { 3922, 23, 33, 27, 5, -33 },
  { 4017, 24, 33, 27, 3, -33 },
  { 4116, 23, 33, 27, 5, -33 },
  { 4211, 24, 33, 27, 5, -33 },
  { 4310, 28, 33, 27, 0, -33 },
  { 4426, 23, 33, 27, 5, -33 },
  { 4521, 24, 33, 27, 1, -33 },
  { 4620, 14, 44, 27, 7, -37 },
  { 4697, 9, 36, 27, 9, -33 },
  { 4738, 14, 44, 27, 6, -37 },
  { 4815, 16, 18, 27, 6, -33 },
  { 4851, 19, 2, 27, 1, 0 },
  { 4856, 6, 6, 27, 13, -34 },
  { 4861, 21, 25, 27, 2, -25 },
  { 4927, 21, 35, 27, 2, -35 },
  { 5019, 20, 25, 27, 3, -25 },
  { 5082, 23, 35, 27, 3, -35 },
  { 5183, 21, 25, 27, 3, -25 },
  { 5249, 22, 35, 27, 6, -35 },
  { 5346, 22, 35, 27, 2, -25 },
  { 5443, 21, 35, 27, 2, -35 },
  { 5535, 19, 33, 27, 3, -33 },
  { 5614, 21, 43, 27, 0, -33 },
  { 5727, 22, 35, 27, 3, -35 },
  { 5824, 19, 35, 27, 3, -35 },
  { 5908, 26, 25, 27, 0, -25 },
  { 5990, 21, 25, 27, 2, -25 },
  { 6056, 22, 25, 27, 2, -25 },
  { 6125, 22, 34, 27, 1, -25 },
  { 6219, 21, 34, 27, 3, -25 },
  { 6309, 19, 25, 27, 6, -25 },
  { 6369, 21, 25, 27, 3, -25 },
  { 6435, 17, 31, 27, 6, -31 },
  { 6501, 20, 24, 27, 4, -24 },
  { 6561, 22, 24, 27, 4, -24 },
  { 6627, 25, 24, 27, 3, -24 },
  { 6702, 25, 24, 27, 1, -24 },
  { 6777, 28, 34, 27, -1, -24 },
  { 6896, 23, 24, 27, 1, -24 },
  { 6965, 18, 45, 27, 7, -36 },
  { 7067, 8, 40, 27, 9, -33 },
  { 7107, 18, 46, 27, 4, -36 },
  { 7211, 25, 8, 27, 1, -18 },
};

const GFXfont RobotoMono_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC46PT7B_H_
