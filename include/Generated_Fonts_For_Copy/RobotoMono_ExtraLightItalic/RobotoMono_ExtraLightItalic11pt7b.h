#ifndef _ROBOTOMONO_EXTRALIGHTITALIC11PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xF0, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94, 0x28, 0x11,
  0x93, 0x04, 0x18, 0x31, 0xB2, 0x00, 0xC5, 0x75, 0x43, 0x36, 0xA7, 0x18,
  0xA2, 0x8C, 0x52, 0x58, 0x9D, 0xC0, 0x25, 0x49, 0x24, 0x92, 0x20, 0x44,
  0x92, 0x49, 0x29, 0x40, 0x15, 0x5C, 0xA5, 0x00, 0x21, 0x3E, 0x44, 0x00,
  0x70, 0xF0, 0x80, 0x08, 0x84, 0x42, 0x21, 0x10, 0x80, 0x74, 0x63, 0x3E,
  0xC6, 0x5C, 0x75, 0x24, 0x92, 0x3A, 0x42, 0x11, 0x11, 0x1F, 0x39, 0x10,
  0x42, 0x38, 0x28, 0x9C, 0x08, 0x61, 0x8A, 0x4B, 0xF0, 0x84, 0x7A, 0x10,
  0xE0, 0x86, 0x5E, 0x34, 0x8F, 0x99, 0x9E, 0xF8, 0x44, 0x22, 0x11, 0x10,
  0x32, 0x62, 0xAB, 0x46, 0x3E, 0x74, 0x63, 0x19, 0xB8, 0x5C, 0x84, 0x40,
  0x18, 0x1B, 0x20, 0xC1, 0x00, 0xF8, 0x3C, 0xC1, 0x06, 0xC8, 0x00, 0x69,
  0x12, 0x44, 0x08, 0x3D, 0x17, 0xEB, 0xAF, 0x5A, 0x9C, 0x08, 0x8A, 0x54,
  0xBE, 0x31, 0x74, 0x63, 0xE9, 0x46, 0x3E, 0x74, 0x63, 0x08, 0x46, 0x5C,
  0x39, 0x14, 0x51, 0x45, 0x18, 0xBC, 0x7C, 0x21, 0xE8, 0x42, 0x1E, 0x7C,
  0x21, 0x0F, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6, 0x3E, 0x45, 0x14, 0x5F,
  0x46, 0x18, 0x62, 0x3C, 0x41, 0x04, 0x10, 0x42, 0x3E, 0x04, 0x10, 0x41,
  0x04, 0x28, 0x9C, 0x46, 0x29, 0x38, 0xA2, 0x89, 0x22, 0x48, 0x88, 0x88,
  0x8F, 0x25, 0x96, 0xDB, 0x55, 0x58, 0x62, 0x45, 0x96, 0x55, 0x56, 0x58,
  0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x74, 0x63, 0x1F, 0x42, 0x10, 0x74,
  0x63, 0x18, 0xC6, 0x5C, 0x10, 0x74, 0x63, 0x1F, 0x4A, 0x52, 0x74, 0x60,
  0x83, 0x06, 0x3E, 0xFC, 0x82, 0x08, 0x20, 0x84, 0x10, 0x8C, 0x63, 0x18,
  0xC6, 0x5C, 0x86, 0x28, 0xA4, 0x51, 0x86, 0x10, 0xA6, 0x9A, 0xB6, 0xDA,
  0x49, 0x24, 0x42, 0x48, 0xA0, 0x81, 0x05, 0x12, 0x44, 0x86, 0x25, 0x14,
  0x21, 0x04, 0x10, 0x3C, 0x10, 0x84, 0x20, 0x84, 0x3E, 0x69, 0x49, 0x24,
  0x92, 0x00, 0xA9, 0x55, 0x40, 0x64, 0x94, 0x92, 0x4A, 0x00, 0x22, 0x5D,
  0xF8, 0x80, 0x74, 0x4B, 0xA9, 0x78, 0x44, 0x3D, 0x18, 0xC6, 0x5C, 0x74,
  0x61, 0x09, 0x78, 0x08, 0x5F, 0x18, 0xCA, 0x5E, 0x74, 0x7F, 0x08, 0x78,
  0x3C, 0x8F, 0x88, 0x41, 0x04, 0x10, 0x3D, 0x14, 0x52, 0x49, 0xE0, 0xBC,
  0x21, 0x07, 0x91, 0x45, 0x18, 0xA2, 0x10, 0x62, 0x22, 0x2F, 0x08, 0x0E,
  0x11, 0x08, 0x42, 0x17, 0x00, 0x42, 0x23, 0x6C, 0x52, 0x92, 0x71, 0x22,
  0x22, 0x2F, 0x6E, 0x59, 0x65, 0xA6, 0x90, 0x79, 0x14, 0x51, 0x8A, 0x20,
  0x74, 0x63, 0x19, 0x70, 0x79, 0x14, 0x51, 0x49, 0xC8, 0x20, 0x7C, 0x63,
  0x29, 0x78, 0x42, 0x7A, 0x10, 0x88, 0x40, 0x74, 0x50, 0x68, 0xF8, 0x27,
  0xC8, 0x84, 0x21, 0xC0, 0x8C, 0x63, 0x29, 0x78, 0x8C, 0x64, 0xA6, 0x20,
  0xA6, 0xAE, 0xBA, 0x92, 0x40, 0x44, 0xA1, 0x0C, 0x4A, 0x20, 0x45, 0x14,
  0x8A, 0x30, 0x82, 0x30, 0x7C, 0x21, 0x08, 0x43, 0xE0, 0x12, 0x44, 0x48,
  0x84, 0x88, 0x40, 0x55, 0x5A, 0xA0, 0x42, 0x22, 0x21, 0x22, 0x24, 0xC0,
  0xE6, 0x60,
};

const GFXglyph RobotoMono_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 2, 2, 6, 3, -8 },
  { 4, 7, 8, 6, 0, -8 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 1, 2, 6, 3, -8 },
  { 30, 3, 12, 6, 2, -9 },
  { 35, 3, 12, 6, 1, -9 },
  { 40, 5, 5, 6, 1, -8 },
  { 44, 5, 5, 6, 1, -6 },
  { 48, 2, 2, 6, 1, -1 },
  { 49, 4, 1, 6, 1, -4 },
  { 50, 1, 1, 6, 2, -1 },
  { 51, 5, 9, 6, 1, -8 },
  { 57, 5, 8, 6, 1, -8 },
  { 62, 3, 8, 6, 2, -8 },
  { 65, 5, 8, 6, 0, -8 },
  { 70, 6, 8, 6, 0, -8 },
  { 76, 6, 8, 6, 0, -8 },
  { 82, 5, 8, 6, 1, -8 },
  { 87, 4, 8, 6, 1, -8 },
  { 91, 5, 8, 6, 1, -8 },
  { 96, 5, 8, 6, 1, -8 },
  { 101, 5, 8, 6, 1, -8 },
  { 106, 1, 6, 6, 3, -6 },
  { 107, 2, 7, 6, 2, -6 },
  { 109, 5, 5, 6, 1, -6 },
  { 113, 5, 3, 6, 1, -5 },
  { 115, 5, 5, 6, 1, -6 },
  { 119, 4, 8, 6, 2, -8 },
  { 123, 6, 8, 6, 0, -8 },
  { 129, 5, 8, 6, 0, -8 },
  { 134, 5, 8, 6, 1, -8 },
  { 139, 5, 8, 6, 1, -8 },
  { 144, 6, 8, 6, 0, -8 },
  { 150, 5, 8, 6, 1, -8 },
  { 155, 5, 8, 6, 1, -8 },
  { 160, 5, 8, 6, 1, -8 },
  { 165, 6, 8, 6, 0, -8 },
  { 171, 6, 8, 6, 0, -8 },
  { 177, 6, 8, 6, 0, -8 },
  { 183, 6, 8, 6, 1, -8 },
  { 189, 4, 8, 6, 1, -8 },
  { 193, 6, 8, 6, 0, -8 },
  { 199, 6, 8, 6, 0, -8 },
  { 205, 5, 8, 6, 1, -8 },
  { 210, 5, 8, 6, 1, -8 },
  { 215, 5, 9, 6, 1, -8 },
  { 221, 5, 8, 6, 1, -8 },
  { 226, 5, 8, 6, 1, -8 },
  { 231, 6, 8, 6, 1, -8 },
  { 237, 5, 8, 6, 1, -8 },
  { 242, 6, 8, 6, 1, -8 },
  { 248, 6, 8, 6, 1, -8 },
  { 254, 7, 8, 6, 0, -8 },
  { 261, 6, 8, 6, 1, -8 },
  { 267, 6, 8, 6, 0, -8 },
  { 273, 3, 11, 6, 2, -9 },
  { 278, 2, 9, 6, 2, -8 },
  { 281, 3, 11, 6, 2, -9 },
  { 286, 4, 4, 6, 1, -8 },
  { 288, 5, 1, 6, 0, 0 },
  { 289, 1, 1, 6, 3, -8 },
  { 290, 5, 6, 6, 1, -6 },
  { 294, 5, 8, 6, 1, -8 },
  { 299, 5, 6, 6, 1, -6 },
  { 303, 5, 8, 6, 1, -8 },
  { 308, 5, 6, 6, 1, -6 },
  { 312, 6, 8, 6, 1, -8 },
  { 318, 6, 8, 6, 0, -6 },
  { 324, 6, 8, 6, 0, -8 },
  { 330, 4, 8, 6, 1, -8 },
  { 334, 5, 10, 6, 0, -8 },
  { 341, 5, 8, 6, 1, -8 },
  { 346, 4, 8, 6, 1, -8 },
  { 350, 6, 6, 6, 0, -6 },
  { 355, 6, 6, 6, 0, -6 },
  { 360, 5, 6, 6, 1, -6 },
  { 364, 6, 8, 6, 0, -6 },
  { 370, 5, 8, 6, 1, -6 },
  { 375, 5, 6, 6, 1, -6 },
  { 379, 5, 6, 6, 1, -6 },
  { 383, 5, 7, 6, 1, -7 },
  { 388, 5, 6, 6, 1, -6 },
  { 392, 5, 6, 6, 1, -6 },
  { 396, 6, 6, 6, 1, -6 },
  { 401, 6, 6, 6, 0, -6 },
  { 406, 6, 8, 6, 0, -6 },
  { 412, 6, 6, 6, 0, -6 },
  { 417, 4, 11, 6, 2, -9 },
  { 423, 2, 10, 6, 2, -8 },
  { 426, 4, 11, 6, 1, -9 },
  { 432, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC11PT7B_H_
