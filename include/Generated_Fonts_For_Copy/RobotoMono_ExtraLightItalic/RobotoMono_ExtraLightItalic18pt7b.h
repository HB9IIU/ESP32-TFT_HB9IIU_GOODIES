#ifndef _ROBOTOMONO_EXTRALIGHTITALIC18PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x92, 0x80, 0x08, 0x55, 0x99, 0x04, 0x40, 0x88, 0x12,
  0x04, 0x43, 0xFE, 0x12, 0x04, 0x40, 0x88, 0x12, 0x1D, 0xF0, 0x90, 0x12,
  0x04, 0x40, 0x04, 0x02, 0x03, 0x86, 0x22, 0x09, 0x04, 0x80, 0x40, 0x1C,
  0x01, 0x00, 0x50, 0x28, 0x12, 0x11, 0xF0, 0x20, 0x10, 0x00, 0x70, 0x44,
  0x22, 0x52, 0x49, 0x43, 0x20, 0x20, 0x26, 0x14, 0x94, 0x52, 0x29, 0x20,
  0x70, 0x0C, 0x09, 0x08, 0x84, 0x42, 0x40, 0xC0, 0xC0, 0x91, 0x88, 0xC2,
  0xA0, 0x90, 0xC7, 0x90, 0x5A, 0x0C, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x30, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x08, 0x08, 0x09, 0xEE, 0x18,
  0x28, 0x44, 0x44, 0x04, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x20,
  0x10, 0x08, 0x00, 0x56, 0xFC, 0x80, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00, 0x1E, 0x10,
  0x88, 0x28, 0x14, 0x3A, 0x26, 0x25, 0x22, 0xA1, 0x60, 0xA0, 0x88, 0x47,
  0xC0, 0x17, 0x91, 0x11, 0x12, 0x22, 0x22, 0x40, 0x0F, 0x08, 0x48, 0x28,
  0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0F, 0xF0, 0x0F,
  0x08, 0x48, 0x24, 0x10, 0x08, 0x08, 0x38, 0x02, 0x01, 0x40, 0xA0, 0x48,
  0x43, 0xC0, 0x00, 0x80, 0xC0, 0xC0, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x42,
  0x7F, 0xC0, 0x80, 0x40, 0x20, 0x3F, 0x20, 0x40, 0x40, 0x40, 0x7C, 0x42,
  0x02, 0x02, 0x02, 0x82, 0x84, 0x78, 0x07, 0x18, 0x20, 0x20, 0x48, 0x76,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0xFF, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x0E, 0x18, 0x88, 0x28,
  0x14, 0x09, 0x18, 0x70, 0xC6, 0x81, 0x40, 0xA0, 0x50, 0x47, 0xC0, 0x3C,
  0x42, 0x82, 0x81, 0x81, 0x82, 0x82, 0x86, 0x7A, 0x04, 0x04, 0x18, 0xE0,
  0x20, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x02, 0x44, 0xC0, 0x03, 0x1C,
  0x60, 0xC0, 0x30, 0x0C, 0x02, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x60, 0x1C,
  0x02, 0x03, 0x0C, 0x70, 0x80, 0x38, 0x8A, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x20, 0x80, 0x00, 0x04, 0x00, 0x07, 0x83, 0x08, 0x81, 0x13, 0x94, 0x92,
  0xA2, 0x54, 0x94, 0x92, 0x92, 0x52, 0xD1, 0x24, 0x20, 0x03, 0xE0, 0x02,
  0x01, 0x01, 0x80, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x3F, 0x10, 0x90, 0x28,
  0x18, 0x08, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x12, 0x19, 0xF8, 0x82, 0x81,
  0x40, 0xA0, 0x50, 0x4F, 0xC0, 0x0E, 0x18, 0x88, 0x28, 0x14, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0xA0, 0x48, 0x47, 0xC0, 0x3E, 0x10, 0x90, 0x48,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x81, 0x40, 0xA0, 0x90, 0x8F, 0x80, 0x3F,
  0x90, 0x08, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x0F, 0xE0, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0x01, 0xFC, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x0E, 0x18, 0x88, 0x28, 0x14, 0x04, 0x02,
  0x01, 0x1E, 0x81, 0x40, 0xA0, 0x48, 0x23, 0xE0, 0x20, 0xA0, 0x50, 0x28,
  0x14, 0x0A, 0x05, 0xFD, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x20, 0x3F,
  0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x0F, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x41, 0x20, 0x90, 0x87, 0x80, 0x20, 0x48, 0x22, 0x11, 0x08, 0x44, 0x16,
  0x07, 0x01, 0x20, 0x44, 0x21, 0x08, 0x22, 0x08, 0x81, 0x00, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x0F, 0xE0, 0x20, 0x90,
  0x58, 0x6A, 0x55, 0x2A, 0xA5, 0x53, 0x32, 0x89, 0x40, 0xA0, 0x50, 0x28,
  0x20, 0x20, 0x90, 0x58, 0x2A, 0x15, 0x0A, 0x45, 0x25, 0x12, 0x85, 0x42,
  0xA1, 0x50, 0x48, 0x20, 0x1E, 0x10, 0x88, 0x28, 0x14, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x40, 0xA0, 0x88, 0x47, 0xC0, 0x3F, 0x10, 0x48, 0x24, 0x14,
  0x0A, 0x05, 0x0C, 0xF8, 0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x1E, 0x10,
  0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x47,
  0xC0, 0x20, 0x08, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x09, 0x08, 0xF8,
  0x44, 0x41, 0x20, 0x90, 0x48, 0x10, 0x1E, 0x10, 0x90, 0x28, 0x14, 0x01,
  0x00, 0x70, 0x04, 0x01, 0x40, 0xA0, 0x50, 0x47, 0xC0, 0xFF, 0x84, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x06, 0x05, 0x02, 0x81, 0x40, 0xA0,
  0x88, 0x47, 0xC0, 0x80, 0xC0, 0xA0, 0x50, 0x44, 0x22, 0x21, 0x10, 0x90,
  0x48, 0x24, 0x14, 0x04, 0x02, 0x00, 0x88, 0xC4, 0x66, 0x33, 0x29, 0x95,
  0x4A, 0xA9, 0x54, 0xCA, 0x65, 0x21, 0x10, 0x88, 0x40, 0x20, 0x22, 0x08,
  0x42, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x0A, 0x02, 0x40, 0x84,
  0x20, 0x88, 0x08, 0x80, 0xC0, 0x90, 0x88, 0x44, 0x41, 0x40, 0xA0, 0x60,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3F, 0xC0, 0x20, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0xFF, 0x00, 0x39,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x87, 0x00, 0x92,
  0x48, 0x92, 0x48, 0x92, 0x40, 0x38, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84,
  0x42, 0x10, 0x84, 0x26, 0x00, 0x08, 0x61, 0x89, 0x25, 0x18, 0x40, 0xFE,
  0xD0, 0x1C, 0x23, 0x41, 0x01, 0x0F, 0x71, 0x81, 0x82, 0x86, 0x7A, 0x20,
  0x20, 0x20, 0x20, 0x4C, 0x72, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82,
  0xFC, 0x0C, 0x33, 0x41, 0x41, 0x80, 0x80, 0x80, 0x81, 0x42, 0x3C, 0x00,
  0x80, 0x40, 0x20, 0x11, 0xC9, 0x19, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x90,
  0x44, 0x23, 0xF0, 0x0C, 0x33, 0x41, 0x41, 0xFF, 0x80, 0x80, 0x80, 0x42,
  0x3C, 0x07, 0x84, 0x04, 0x02, 0x0F, 0xE0, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x00, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x81, 0x82,
  0x82, 0x42, 0x7E, 0x02, 0x04, 0x8C, 0x70, 0x20, 0x20, 0x20, 0x40, 0x4E,
  0x51, 0x61, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x06, 0x08, 0x01,
  0xE0, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x8F, 0xE0, 0x01, 0x01, 0x00,
  0x1F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0xF0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x0A, 0x19, 0x10, 0x90, 0x50,
  0x38, 0x12, 0x10, 0x88, 0x44, 0x10, 0x3C, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x9F, 0xC0, 0x59, 0x99, 0x94, 0x45, 0x11,
  0x44, 0x61, 0x18, 0x86, 0x22, 0x88, 0xA2, 0x20, 0x4E, 0x51, 0x61, 0x41,
  0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x1C, 0x22, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x7C, 0x26, 0x1C, 0x88, 0x24, 0x12, 0x09, 0x05, 0x02,
  0x82, 0x41, 0x3F, 0x10, 0x10, 0x08, 0x04, 0x00, 0x1D, 0x23, 0x41, 0x41,
  0x81, 0x81, 0x82, 0x82, 0x42, 0x7E, 0x02, 0x02, 0x04, 0x04, 0x27, 0x38,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1E, 0x21, 0x41, 0x40,
  0x30, 0x0E, 0x01, 0x81, 0x82, 0x7C, 0x10, 0x23, 0xF8, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0xE0, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x0A,
  0x05, 0x04, 0x42, 0x3F, 0x00, 0x81, 0x81, 0x82, 0x82, 0x44, 0x48, 0x48,
  0x50, 0x30, 0x20, 0x84, 0x62, 0x28, 0x8A, 0x52, 0x95, 0x29, 0x4A, 0x52,
  0x98, 0x46, 0x11, 0x00, 0x20, 0x44, 0x21, 0x10, 0x28, 0x0C, 0x03, 0x00,
  0xA0, 0x48, 0x21, 0x30, 0x60, 0x40, 0x24, 0x08, 0x82, 0x10, 0x42, 0x10,
  0x22, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x3F, 0xE0, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0xC0, 0x80, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x20, 0x20, 0x24, 0xA4, 0x92, 0x52, 0x49, 0x24,
  0x20, 0x40, 0x82, 0x08, 0x20, 0x82, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08,
  0x42, 0x00, 0x30, 0x53, 0x18, 0x38,
};

const GFXglyph RobotoMono_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 4, 4, 11, 4, -14 },
  { 8, 11, 13, 11, 0, -13 },
  { 26, 9, 17, 11, 1, -15 },
  { 46, 9, 13, 11, 1, -13 },
  { 61, 9, 13, 11, 1, -13 },
  { 76, 2, 4, 11, 5, -14 },
  { 77, 6, 18, 11, 3, -14 },
  { 91, 5, 18, 11, 2, -14 },
  { 103, 8, 8, 11, 2, -13 },
  { 111, 9, 10, 11, 1, -11 },
  { 123, 2, 4, 11, 2, -2 },
  { 124, 6, 1, 11, 2, -6 },
  { 125, 1, 1, 11, 4, -1 },
  { 126, 9, 14, 11, 1, -13 },
  { 142, 9, 13, 11, 1, -13 },
  { 157, 4, 13, 11, 3, -13 },
  { 164, 9, 13, 11, 0, -13 },
  { 179, 9, 13, 11, 0, -13 },
  { 194, 9, 13, 11, 0, -13 },
  { 209, 8, 13, 11, 2, -13 },
  { 222, 8, 13, 11, 1, -13 },
  { 235, 8, 13, 11, 2, -13 },
  { 248, 9, 13, 11, 1, -13 },
  { 263, 8, 13, 11, 2, -13 },
  { 276, 3, 9, 11, 4, -9 },
  { 280, 4, 11, 11, 3, -9 },
  { 286, 8, 7, 11, 1, -9 },
  { 293, 9, 4, 11, 1, -8 },
  { 298, 8, 7, 11, 1, -9 },
  { 305, 7, 13, 11, 3, -13 },
  { 317, 11, 13, 11, 0, -13 },
  { 335, 9, 13, 11, 0, -13 },
  { 350, 9, 13, 11, 1, -13 },
  { 365, 9, 13, 11, 1, -13 },
  { 380, 9, 13, 11, 1, -13 },
  { 395, 9, 13, 11, 1, -13 },
  { 410, 9, 13, 11, 1, -13 },
  { 425, 9, 13, 11, 1, -13 },
  { 440, 9, 13, 11, 1, -13 },
  { 455, 9, 13, 11, 1, -13 },
  { 470, 9, 13, 11, 1, -13 },
  { 485, 10, 13, 11, 1, -13 },
  { 502, 7, 13, 11, 1, -13 },
  { 514, 9, 13, 11, 1, -13 },
  { 529, 9, 13, 11, 1, -13 },
  { 544, 9, 13, 11, 1, -13 },
  { 559, 9, 13, 11, 1, -13 },
  { 574, 9, 15, 11, 1, -13 },
  { 591, 9, 13, 11, 1, -13 },
  { 606, 9, 13, 11, 1, -13 },
  { 621, 9, 13, 11, 2, -13 },
  { 636, 9, 13, 11, 1, -13 },
  { 651, 9, 13, 11, 2, -13 },
  { 666, 9, 13, 11, 2, -13 },
  { 681, 11, 13, 11, 0, -13 },
  { 699, 9, 13, 11, 2, -13 },
  { 714, 10, 13, 11, 0, -13 },
  { 731, 5, 18, 11, 3, -15 },
  { 743, 3, 14, 11, 4, -13 },
  { 749, 5, 18, 11, 3, -15 },
  { 761, 6, 7, 11, 2, -13 },
  { 767, 7, 1, 11, 1, 0 },
  { 768, 2, 2, 11, 5, -13 },
  { 769, 8, 10, 11, 1, -10 },
  { 779, 8, 14, 11, 1, -14 },
  { 793, 8, 10, 11, 1, -10 },
  { 803, 9, 14, 11, 1, -14 },
  { 819, 8, 10, 11, 1, -10 },
  { 829, 9, 14, 11, 2, -14 },
  { 845, 8, 14, 11, 1, -10 },
  { 859, 8, 14, 11, 1, -14 },
  { 873, 7, 13, 11, 1, -13 },
  { 885, 8, 17, 11, 0, -13 },
  { 902, 9, 14, 11, 1, -14 },
  { 918, 7, 14, 11, 1, -14 },
  { 931, 10, 10, 11, 0, -10 },
  { 944, 8, 10, 11, 1, -10 },
  { 954, 8, 10, 11, 1, -10 },
  { 964, 9, 14, 11, 0, -10 },
  { 980, 8, 14, 11, 1, -10 },
  { 994, 8, 10, 11, 2, -10 },
  { 1004, 8, 10, 11, 1, -10 },
  { 1014, 7, 12, 11, 2, -12 },
  { 1025, 9, 10, 11, 1, -10 },
  { 1037, 8, 10, 11, 2, -10 },
  { 1047, 10, 10, 11, 1, -10 },
  { 1060, 10, 10, 11, 0, -10 },
  { 1073, 11, 14, 11, 0, -10 },
  { 1093, 10, 10, 11, 0, -10 },
  { 1106, 7, 18, 11, 3, -14 },
  { 1122, 3, 16, 11, 4, -13 },
  { 1128, 6, 18, 11, 2, -14 },
  { 1142, 10, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC18PT7B_H_
