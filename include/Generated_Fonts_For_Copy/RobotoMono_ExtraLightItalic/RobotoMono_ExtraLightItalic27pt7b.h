#ifndef _ROBOTOMONO_EXTRALIGHTITALIC27PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x32, 0x22, 0x22, 0x64, 0x44, 0x40, 0x00, 0x08, 0x80, 0x65,
  0x14, 0x52, 0xC8, 0x00, 0xC2, 0x00, 0x84, 0x00, 0x84, 0x01, 0x04, 0x01,
  0x08, 0x1F, 0xFF, 0x02, 0x08, 0x02, 0x10, 0x06, 0x10, 0x04, 0x30, 0x04,
  0x20, 0x08, 0x20, 0x08, 0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0x80, 0x10,
  0x80, 0x20, 0x80, 0x21, 0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x0F, 0xC1,
  0x83, 0x08, 0x08, 0x80, 0x44, 0x03, 0x20, 0x01, 0x80, 0x04, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x24, 0x01, 0x20, 0x09,
  0x80, 0xC6, 0x0C, 0x1F, 0x80, 0x10, 0x01, 0x00, 0x08, 0x00, 0x7C, 0x02,
  0x20, 0x21, 0x0D, 0x08, 0x48, 0x44, 0x42, 0x42, 0x22, 0x1E, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x10, 0x11, 0x61, 0x91, 0x09, 0x04, 0x88, 0x28, 0x42,
  0x42, 0x10, 0x11, 0x80, 0x78, 0x07, 0xC0, 0x10, 0x80, 0x82, 0x02, 0x08,
  0x08, 0x20, 0x21, 0x00, 0x98, 0x03, 0xC0, 0x06, 0x00, 0x28, 0x03, 0x20,
  0x48, 0x42, 0x41, 0x89, 0x02, 0x6C, 0x05, 0x30, 0x1C, 0x40, 0x61, 0x83,
  0x43, 0xF1, 0x80, 0x7A, 0x80, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x0C, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x30, 0x00, 0x06, 0x00, 0x80, 0x10, 0x42, 0x1E, 0x5E, 0x3C, 0x03,
  0x00, 0x90, 0x22, 0x08, 0x23, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xFF, 0xFE, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x24, 0xB5, 0x00, 0xFF, 0xC0, 0xF0,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x07,
  0xE1, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x03, 0x40, 0x54, 0x09, 0x41,
  0x1C, 0x61, 0x8C, 0x19, 0x83, 0xA0, 0x2C, 0x02, 0x80, 0x28, 0x04, 0xC0,
  0xC4, 0x18, 0x3F, 0x00, 0x06, 0x3F, 0x8C, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x0F, 0xE1, 0x83,
  0x30, 0x12, 0x01, 0x60, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xFF, 0xE0, 0x07, 0xE0, 0xC0, 0x84, 0x04, 0x40, 0x12, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x01, 0xC0, 0x7C, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x12, 0x00, 0x90, 0x04, 0xC0, 0x42, 0x06, 0x0F, 0xC0, 0x00, 0x30, 0x03,
  0x80, 0x14, 0x01, 0x40, 0x12, 0x01, 0x10, 0x18, 0x81, 0x84, 0x08, 0x60,
  0x82, 0x08, 0x10, 0xC0, 0x8C, 0x04, 0x7F, 0xFC, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0B, 0xE0, 0x30, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x88, 0x02, 0x30, 0x18, 0x40, 0x41, 0x82, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0xC2,
  0xEE, 0xE0, 0x58, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0xC0, 0xCC, 0x30, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00,
  0x07, 0xE0, 0xC0, 0x84, 0x06, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x80, 0x46,
  0x04, 0x1C, 0xC0, 0xFC, 0x08, 0x18, 0x80, 0x48, 0x03, 0x40, 0x0A, 0x00,
  0xD0, 0x04, 0x80, 0x62, 0x06, 0x0F, 0xC0, 0x1F, 0x86, 0x09, 0x81, 0xA0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0x03, 0xB1, 0xA1,
  0xC4, 0x01, 0x00, 0x20, 0x08, 0x02, 0x01, 0x83, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xCC, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x00, 0x00, 0x30, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x00,
  0x80, 0x00, 0x1F, 0x88, 0x34, 0x07, 0x01, 0x00, 0x40, 0x10, 0x08, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x60, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x02, 0x00, 0x03, 0xF8, 0x08, 0x18, 0x60, 0x10, 0x80, 0x22, 0x3E, 0x2C,
  0xC4, 0x51, 0x08, 0xA4, 0x21, 0x88, 0x45, 0x10, 0x8A, 0x41, 0x14, 0x84,
  0x29, 0x08, 0x92, 0x31, 0x23, 0x9C, 0x40, 0x00, 0xC0, 0x00, 0xC1, 0x00,
  0x7F, 0x00, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90,
  0x08, 0xC0, 0x42, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x21, 0xFF, 0x08,
  0x0C, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x02, 0x1F, 0xE0, 0x40,
  0x61, 0x00, 0x84, 0x03, 0x10, 0x08, 0x40, 0x23, 0x00, 0x88, 0x04, 0x20,
  0xE0, 0xFF, 0x82, 0x03, 0x08, 0x04, 0x60, 0x19, 0x00, 0x24, 0x01, 0x10,
  0x04, 0x40, 0x21, 0x03, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0xC1, 0x8C, 0x04,
  0x40, 0x36, 0x00, 0xA0, 0x05, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x1A, 0x00, 0x90, 0x0C, 0xC0, 0x42, 0x0C,
  0x0F, 0xC0, 0x1F, 0xE0, 0x40, 0xC1, 0x01, 0x84, 0x02, 0x10, 0x0C, 0xC0,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x44, 0x01, 0x10, 0x08, 0xC0, 0x42, 0x06, 0x0F, 0xE0, 0x00,
  0x0F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xFF, 0xC2, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x00, 0x07, 0xE0,
  0xC1, 0x8C, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0xFD, 0x00, 0x28, 0x01, 0x40, 0x1A, 0x00, 0x90, 0x04,
  0xC0, 0x23, 0x06, 0x0F, 0xE0, 0x10, 0x06, 0x20, 0x08, 0x40, 0x11, 0x80,
  0x22, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0xFF, 0xF1,
  0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80,
  0x11, 0x00, 0x42, 0x00, 0x80, 0x1F, 0xFC, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC8, 0x02, 0x20, 0x08, 0xC0, 0x41, 0x86, 0x03, 0xF0,
  0x00, 0x08, 0x07, 0x18, 0x0C, 0x10, 0x18, 0x10, 0x30, 0x10, 0x60, 0x10,
  0xC0, 0x11, 0x80, 0x23, 0x00, 0x26, 0x00, 0x2E, 0x00, 0x31, 0x00, 0x21,
  0x00, 0x20, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x40, 0x20, 0x40,
  0x10, 0xC0, 0x18, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0xA2, 0x41, 0x44, 0x84, 0x89, 0x1B, 0x12, 0x24, 0x24, 0xC8, 0x4D,
  0x11, 0x0C, 0x22, 0x18, 0x44, 0x21, 0x88, 0x02, 0x10, 0x04, 0x60, 0x08,
  0x80, 0x11, 0x00, 0x22, 0x00, 0xC0, 0x10, 0x06, 0x30, 0x08, 0x60, 0x11,
  0xE0, 0x22, 0x40, 0x44, 0x81, 0x88, 0x82, 0x11, 0x04, 0x22, 0x08, 0xC2,
  0x11, 0x04, 0x22, 0x08, 0xC4, 0x09, 0x08, 0x12, 0x10, 0x34, 0x60, 0x28,
  0x80, 0x71, 0x00, 0x42, 0x00, 0x80, 0x0F, 0xE0, 0xC1, 0x0C, 0x04, 0x40,
  0x26, 0x01, 0xA0, 0x05, 0x00, 0x30, 0x03, 0x80, 0x14, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x12, 0x00, 0x90, 0x08, 0xC0, 0xC2, 0x0C, 0x0F,
  0x80, 0x1F, 0xE0, 0x40, 0x43, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x06, 0x60, 0x11, 0x01, 0x87, 0xF8, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xF0, 0x30, 0x61, 0x80, 0x84, 0x03, 0x20, 0x04, 0x80, 0x16, 0x00, 0x50,
  0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0xF0, 0x02, 0x80, 0x0B, 0x00, 0x64,
  0x01, 0x10, 0x0C, 0x40, 0x20, 0x83, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x0F, 0xE0, 0x60, 0x61, 0x00, 0x84, 0x03, 0x10, 0x04, 0x40,
  0x11, 0x00, 0x88, 0x02, 0x20, 0x10, 0x81, 0x83, 0xF8, 0x08, 0x20, 0x20,
  0x41, 0x01, 0x04, 0x04, 0x10, 0x08, 0x40, 0x21, 0x00, 0xCC, 0x01, 0x00,
  0x07, 0xF0, 0x30, 0x61, 0x00, 0xC4, 0x01, 0x30, 0x04, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x2C, 0x01, 0x90, 0x04, 0x40, 0x30, 0x81, 0x81, 0xFC, 0x00, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x98, 0x02,
  0x40, 0x09, 0x00, 0x64, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x01,
  0x20, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x10, 0xC0, 0xC1, 0x06,
  0x03, 0xF0, 0x00, 0x80, 0x0C, 0x00, 0xB0, 0x04, 0x80, 0x44, 0x02, 0x20,
  0x21, 0x01, 0x08, 0x18, 0x60, 0x81, 0x0C, 0x08, 0x40, 0x46, 0x02, 0x20,
  0x11, 0x00, 0x90, 0x06, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x82, 0x06,
  0x08, 0x28, 0x60, 0xA1, 0x82, 0x85, 0x12, 0x24, 0x48, 0x91, 0x22, 0x4C,
  0x91, 0x22, 0x44, 0x89, 0x12, 0x28, 0x50, 0xA1, 0x42, 0x85, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x00, 0x18, 0x03, 0x0C, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x02, 0x18, 0x02, 0x10, 0x03, 0x20, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x20,
  0x08, 0x20, 0x10, 0x10, 0x30, 0x10, 0x60, 0x18, 0xC0, 0x08, 0xC0, 0x1A,
  0x00, 0x90, 0x08, 0x80, 0xC2, 0x04, 0x10, 0x40, 0x86, 0x02, 0x20, 0x12,
  0x00, 0xB0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0xF0, 0xC1, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x82, 0x04, 0x0F, 0x01, 0x03,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0xF0, 0x02,
  0x01, 0x40, 0x50, 0x24, 0x09, 0x04, 0x63, 0x08, 0x82, 0x60, 0xB0, 0x30,
  0xFF, 0xE0, 0x89, 0x10, 0x01, 0x80, 0x7F, 0x06, 0x04, 0x60, 0x22, 0x01,
  0x80, 0x08, 0x00, 0x41, 0xFE, 0x30, 0x13, 0x00, 0x90, 0x0D, 0x80, 0x44,
  0x06, 0x30, 0x50, 0xFC, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x40, 0x5F, 0x83, 0x06, 0x30, 0x11, 0x00, 0x88, 0x06, 0x40,
  0x32, 0x01, 0xB0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x23, 0x03, 0x18, 0x31,
  0xBF, 0x00, 0x03, 0x00, 0xFC, 0x10, 0x22, 0x02, 0x40, 0x14, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x06, 0xC0, 0x46, 0x18, 0x3F,
  0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x01, 0x08, 0x7E,
  0x46, 0x0A, 0x20, 0x32, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x90, 0x08, 0x80, 0x46, 0x06, 0x10, 0x70, 0x7C, 0x80, 0x03, 0x00,
  0xFC, 0x30, 0x22, 0x02, 0x40, 0x14, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x46, 0x0C, 0x3F, 0x00, 0x00, 0x70, 0x0E,
  0x40, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x1F, 0xFC, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x46,
  0x0A, 0x20, 0x32, 0x01, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x01,
  0x90, 0x08, 0x80, 0x46, 0x06, 0x10, 0x70, 0x7C, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x30, 0x20, 0xC6, 0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x40, 0x5F, 0x85, 0x82, 0x30, 0x11, 0x80, 0xC8,
  0x06, 0x40, 0x22, 0x01, 0x30, 0x09, 0x00, 0x48, 0x02, 0x40, 0x32, 0x01,
  0x30, 0x09, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0xC0, 0xF0, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x04, 0x80, 0xC4, 0x08, 0x20, 0x83,
  0x18, 0x11, 0x80, 0x90, 0x05, 0xC0, 0x32, 0x01, 0x08, 0x18, 0x60, 0x81,
  0x04, 0x04, 0x20, 0x31, 0x00, 0xC0, 0x1F, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x02, 0x08,
  0x5F, 0x7C, 0xC3, 0x09, 0x04, 0x12, 0x08, 0x28, 0x10, 0x50, 0x60, 0xA0,
  0x83, 0x41, 0x04, 0x82, 0x09, 0x04, 0x14, 0x08, 0x28, 0x20, 0x50, 0x41,
  0xA0, 0x82, 0x00, 0x00, 0x80, 0xBF, 0x0A, 0x04, 0x60, 0x23, 0x01, 0x90,
  0x0C, 0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x64, 0x02,
  0x60, 0x12, 0x00, 0x80, 0x01, 0x00, 0x7F, 0x06, 0x0C, 0x60, 0x22, 0x00,
  0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x90, 0x04, 0x80, 0x64,
  0x06, 0x10, 0x60, 0x7E, 0x00, 0x00, 0x40, 0x2F, 0xC1, 0xC1, 0x86, 0x02,
  0x10, 0x08, 0x40, 0x31, 0x00, 0xC4, 0x02, 0x30, 0x08, 0x80, 0x22, 0x01,
  0x88, 0x04, 0x20, 0x30, 0xC1, 0x86, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x02, 0x01, 0xFD, 0x30, 0x52, 0x03, 0x40, 0x24,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48, 0x04, 0xC0, 0xC4,
  0x1C, 0x3E, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x41,
  0x3F, 0x14, 0x03, 0x80, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x01, 0xFE,
  0x30, 0x22, 0x01, 0x60, 0x12, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x06,
  0x00, 0x28, 0x02, 0x80, 0x64, 0x0C, 0x3F, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0xF0, 0x20, 0x16, 0x01,
  0x40, 0x14, 0x03, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x28, 0x06,
  0x80, 0x4C, 0x0C, 0x41, 0x43, 0xE4, 0xC0, 0x0A, 0x00, 0x90, 0x0C, 0xC0,
  0x42, 0x06, 0x10, 0x20, 0x82, 0x06, 0x10, 0x11, 0x00, 0x98, 0x04, 0x80,
  0x3C, 0x00, 0xC0, 0x04, 0x00, 0x83, 0x06, 0x0C, 0x28, 0x50, 0xA1, 0x42,
  0x85, 0x12, 0x24, 0x48, 0x93, 0x24, 0x48, 0x91, 0x22, 0x45, 0x0A, 0x14,
  0x28, 0x50, 0x41, 0x81, 0x02, 0x00, 0x30, 0x0C, 0x40, 0x40, 0x83, 0x03,
  0x18, 0x04, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x05, 0x80, 0x22, 0x01,
  0x04, 0x08, 0x10, 0x40, 0x22, 0x00, 0xC0, 0x30, 0x03, 0x10, 0x06, 0x10,
  0x04, 0x10, 0x08, 0x18, 0x08, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x80, 0x07, 0x80, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0x60,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x07, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x48, 0x88, 0x88, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x0C, 0x01, 0xC0, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x00, 0x7C, 0x07, 0x08, 0x18, 0x10, 0xA0, 0x3C,
};

const GFXglyph RobotoMono_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 6, 5, 16, 6, -20 },
  { 15, 16, 19, 16, 0, -19 },
  { 53, 13, 25, 16, 2, -22 },
  { 94, 13, 19, 16, 2, -19 },
  { 125, 14, 19, 16, 1, -19 },
  { 159, 2, 5, 16, 8, -20 },
  { 161, 8, 27, 16, 5, -21 },
  { 188, 9, 27, 16, 2, -21 },
  { 219, 11, 11, 16, 4, -19 },
  { 235, 13, 14, 16, 2, -16 },
  { 258, 3, 6, 16, 3, -2 },
  { 261, 10, 1, 16, 3, -9 },
  { 263, 2, 2, 16, 6, -2 },
  { 264, 13, 21, 16, 2, -19 },
  { 299, 12, 19, 16, 2, -19 },
  { 328, 7, 19, 16, 4, -19 },
  { 345, 12, 19, 16, 1, -19 },
  { 374, 13, 19, 16, 1, -19 },
  { 405, 13, 19, 16, 1, -19 },
  { 436, 14, 19, 16, 2, -19 },
  { 470, 11, 19, 16, 2, -19 },
  { 497, 13, 19, 16, 3, -19 },
  { 528, 13, 19, 16, 2, -19 },
  { 559, 11, 19, 16, 3, -19 },
  { 586, 4, 14, 16, 7, -14 },
  { 593, 6, 18, 16, 5, -14 },
  { 607, 12, 11, 16, 2, -14 },
  { 624, 12, 6, 16, 2, -12 },
  { 633, 12, 11, 16, 2, -14 },
  { 650, 10, 19, 16, 4, -19 },
  { 674, 15, 19, 16, 1, -19 },
  { 710, 13, 19, 16, 0, -19 },
  { 741, 14, 19, 16, 1, -19 },
  { 775, 13, 19, 16, 2, -19 },
  { 806, 14, 19, 16, 1, -19 },
  { 840, 14, 19, 16, 1, -19 },
  { 874, 15, 19, 16, 1, -19 },
  { 910, 13, 19, 16, 2, -19 },
  { 941, 15, 19, 16, 1, -19 },
  { 977, 14, 19, 16, 1, -19 },
  { 1011, 14, 19, 16, 1, -19 },
  { 1045, 16, 19, 16, 1, -19 },
  { 1083, 11, 19, 16, 2, -19 },
  { 1110, 15, 19, 16, 1, -19 },
  { 1146, 15, 19, 16, 1, -19 },
  { 1182, 13, 19, 16, 2, -19 },
  { 1213, 14, 19, 16, 2, -19 },
  { 1247, 14, 22, 16, 1, -19 },
  { 1286, 14, 19, 16, 1, -19 },
  { 1320, 14, 19, 16, 1, -19 },
  { 1354, 13, 19, 16, 3, -19 },
  { 1385, 14, 19, 16, 2, -19 },
  { 1419, 13, 19, 16, 3, -19 },
  { 1450, 14, 19, 16, 3, -19 },
  { 1484, 16, 19, 16, 0, -19 },
  { 1522, 13, 19, 16, 3, -19 },
  { 1553, 14, 19, 16, 1, -19 },
  { 1587, 8, 26, 16, 4, -22 },
  { 1613, 6, 21, 16, 5, -19 },
  { 1629, 8, 26, 16, 4, -22 },
  { 1655, 10, 10, 16, 3, -19 },
  { 1668, 11, 1, 16, 1, 0 },
  { 1670, 3, 4, 16, 8, -20 },
  { 1672, 13, 15, 16, 1, -15 },
  { 1697, 13, 20, 16, 1, -20 },
  { 1730, 12, 15, 16, 2, -15 },
  { 1753, 13, 20, 16, 2, -20 },
  { 1786, 12, 15, 16, 2, -15 },
  { 1809, 13, 21, 16, 3, -21 },
  { 1844, 13, 21, 16, 1, -15 },
  { 1879, 13, 20, 16, 1, -20 },
  { 1912, 11, 19, 16, 2, -19 },
  { 1939, 12, 25, 16, 0, -19 },
  { 1977, 13, 20, 16, 2, -20 },
  { 2010, 11, 20, 16, 2, -20 },
  { 2038, 15, 15, 16, 0, -15 },
  { 2067, 13, 15, 16, 1, -15 },
  { 2092, 13, 15, 16, 1, -15 },
  { 2117, 14, 20, 16, 0, -15 },
  { 2152, 12, 20, 16, 2, -15 },
  { 2182, 12, 15, 16, 3, -15 },
  { 2205, 12, 15, 16, 2, -15 },
  { 2228, 11, 18, 16, 3, -18 },
  { 2253, 12, 14, 16, 2, -14 },
  { 2274, 13, 14, 16, 2, -14 },
  { 2297, 14, 14, 16, 2, -14 },
  { 2322, 14, 14, 16, 1, -14 },
  { 2347, 16, 20, 16, 0, -14 },
  { 2387, 13, 14, 16, 1, -14 },
  { 2410, 11, 27, 16, 4, -21 },
  { 2448, 4, 23, 16, 6, -19 },
  { 2460, 11, 27, 16, 2, -21 },
  { 2498, 14, 4, 16, 1, -10 },
};

const GFXfont RobotoMono_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC27PT7B_H_
