#ifndef _ROBOTOMONO_EXTRALIGHTITALIC36PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41,
  0x0C, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x42, 0x8D, 0x1E,
  0x2C, 0x50, 0xA1, 0x46, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x04, 0x08,
  0x00, 0x60, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x20, 0x01, 0x83, 0x00, 0x08,
  0x10, 0x1F, 0xFF, 0xF8, 0x06, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00,
  0x18, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x04,
  0x00, 0x30, 0x60, 0x3F, 0xFF, 0xF0, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x10, 0x20, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0xF0, 0x01, 0xEF,
  0x01, 0xC0, 0xC0, 0x40, 0x18, 0x30, 0x02, 0x08, 0x00, 0x86, 0x00, 0x21,
  0x80, 0x08, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x02, 0x18, 0x01, 0x83,
  0x00, 0xC0, 0xE0, 0xE0, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0xC0, 0x02, 0x18, 0x01, 0x02,
  0x04, 0x40, 0x83, 0x30, 0x20, 0x8C, 0x18, 0x43, 0x06, 0x30, 0xC1, 0x18,
  0x10, 0xC4, 0x07, 0xE3, 0x00, 0x61, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x7C, 0x02, 0x31, 0x81, 0x88, 0x20, 0xC6, 0x08, 0x21,
  0x02, 0x10, 0x40, 0x8C, 0x10, 0x26, 0x04, 0x18, 0x01, 0x04, 0x00, 0x63,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xEC, 0x00, 0x83, 0x00, 0xC0, 0x80,
  0x40, 0x40, 0x60, 0x20, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x02, 0x30,
  0x01, 0xB0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x62, 0x00, 0x61,
  0x81, 0x60, 0x41, 0xA0, 0x30, 0xF0, 0x0C, 0x50, 0x02, 0x68, 0x01, 0xA4,
  0x00, 0x73, 0x00, 0x30, 0x80, 0x7C, 0x70, 0x63, 0x0F, 0xE1, 0x80, 0x2D,
  0xA4, 0x96, 0x00, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x18, 0x20, 0xFC, 0x4F, 0x8F, 0xF8, 0x03,
  0x80, 0x0F, 0x00, 0x32, 0x00, 0xC6, 0x03, 0x06, 0x0C, 0x0C, 0x10, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x84, 0x63, 0x31, 0x18, 0xFF, 0xF8, 0x5F,
  0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x07,
  0xBC, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x01, 0x20, 0x01, 0x60,
  0x03, 0x60, 0x07, 0x40, 0x09, 0x40, 0x31, 0xC0, 0x63, 0xC0, 0xC3, 0xC1,
  0x83, 0xC2, 0x02, 0x8C, 0x02, 0x98, 0x02, 0xB0, 0x06, 0xE0, 0x06, 0xC0,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x18, 0x40, 0x30, 0x70, 0xE0, 0x1F,
  0x80, 0x00, 0x81, 0xC3, 0xEF, 0x2C, 0x14, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x00, 0x00, 0xF8, 0x01, 0xEF, 0x01,
  0x80, 0xC1, 0x80, 0x61, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0x80, 0xC1, 0x80, 0x30,
  0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x26,
  0x00, 0x31, 0x00, 0x30, 0xC0, 0x38, 0x38, 0x30, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x04,
  0xC0, 0x02, 0x20, 0x01, 0x88, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x08, 0x18, 0x06, 0x04, 0x03, 0x01, 0x01, 0x80, 0x40, 0xC0, 0x30, 0x20,
  0x0C, 0x10, 0x03, 0x1F, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x7F, 0x00, 0xF8,
  0xE0, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x04,
  0x00, 0x81, 0x80, 0x60, 0x30, 0x70, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x7E, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x31, 0xF0, 0x27, 0xF8, 0x6C, 0x0C, 0x70, 0x06, 0x60,
  0x02, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x30, 0x18, 0x38, 0x70, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7B, 0xC0, 0x70, 0x18, 0x10, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x18, 0x00, 0x86, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x38,
  0x03, 0xF8, 0x01, 0xFE, 0x01, 0xC0, 0x60, 0xC0, 0x08, 0x60, 0x03, 0x10,
  0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xC4, 0x00,
  0x61, 0x80, 0x30, 0x38, 0x38, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xBC,
  0x0C, 0x04, 0x18, 0x06, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x06,
  0x20, 0x0A, 0x30, 0x36, 0x1F, 0xE6, 0x07, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x7C, 0x00,
  0x08, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xE6, 0x00,
  0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x30, 0x60, 0x83, 0x06, 0x18, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x04, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xF7, 0x0C, 0x0C, 0xC0, 0x3C,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0xC0, 0x60, 0x06, 0x04, 0x00,
  0x20, 0x80, 0x03, 0x18, 0x7E, 0x11, 0x0C, 0x21, 0x21, 0x82, 0x12, 0x10,
  0x41, 0x63, 0x04, 0x14, 0x20, 0x43, 0x46, 0x04, 0x2C, 0x40, 0x82, 0x84,
  0x08, 0x28, 0x40, 0x82, 0x84, 0x18, 0x48, 0x43, 0x84, 0x84, 0x38, 0x88,
  0x6C, 0x98, 0xC3, 0x8E, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x38, 0x38, 0x00, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x16, 0x00, 0x0D, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00,
  0x42, 0x00, 0x30, 0x80, 0x08, 0x20, 0x06, 0x0C, 0x01, 0x03, 0x00, 0xC0,
  0xC0, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x30, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x80, 0x70, 0x20,
  0x06, 0x18, 0x00, 0x86, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02, 0x10, 0x01,
  0x84, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x30, 0x3F, 0xF8, 0x0F, 0xFF, 0x02,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x44, 0x00, 0x11, 0x00,
  0x0C, 0x40, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x70, 0x80, 0xF8,
  0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFB, 0x80, 0x70, 0x30, 0x30, 0x06,
  0x08, 0x00, 0x86, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x13, 0x00, 0x0C,
  0xC0, 0x02, 0x10, 0x01, 0x86, 0x00, 0xC0, 0x80, 0x60, 0x38, 0x70, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0,
  0xC0, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00, 0x8C,
  0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x03, 0x02, 0x00, 0xC0, 0x41,
  0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x70, 0x30, 0x30, 0x06, 0x08, 0x00, 0x86, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x07, 0xFB, 0x01, 0xFE, 0xC0, 0x01, 0x30, 0x00,
  0x4C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x10, 0x00, 0xC6, 0x00, 0x20,
  0xC0, 0x18, 0x18, 0x3C, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00,
  0x0C, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20,
  0x01, 0x82, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x60, 0x80, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x38, 0x70, 0x03, 0xFC,
  0x00, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x10, 0x30, 0x01,
  0x06, 0x00, 0x10, 0xC0, 0x03, 0x38, 0x00, 0x37, 0x80, 0x02, 0xD8, 0x00,
  0x38, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x02, 0x00, 0x60, 0x30,
  0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x00, 0xC0, 0xC0, 0x04, 0x0C, 0x00,
  0x60, 0xC0, 0x02, 0x08, 0x00, 0x30, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x06, 0x00, 0x30, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0A, 0x00, 0xA0, 0xB0, 0x1A, 0x0B, 0x03,
  0x61, 0x90, 0x36, 0x19, 0x06, 0x61, 0x90, 0x44, 0x11, 0x0C, 0x41, 0x18,
  0x84, 0x11, 0x98, 0xC3, 0x09, 0x0C, 0x30, 0xB0, 0xC3, 0x0E, 0x08, 0x20,
  0xC0, 0x82, 0x0C, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x84,
  0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0E, 0x00, 0x20, 0xA0, 0x02, 0x0A, 0x00,
  0x60, 0xB0, 0x06, 0x19, 0x00, 0x61, 0x98, 0x04, 0x19, 0x80, 0x41, 0x08,
  0x04, 0x10, 0xC0, 0xC1, 0x04, 0x0C, 0x30, 0x40, 0xC3, 0x06, 0x08, 0x30,
  0x20, 0x82, 0x02, 0x08, 0x20, 0x31, 0x82, 0x01, 0x18, 0x60, 0x19, 0x86,
  0x01, 0x90, 0x60, 0x09, 0x04, 0x00, 0xD0, 0x40, 0x07, 0x04, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x20, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x70, 0x30,
  0x30, 0x04, 0x08, 0x01, 0x86, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x03, 0x20,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x30, 0x00, 0x4C, 0x00, 0x33,
  0x00, 0x08, 0xC0, 0x06, 0x10, 0x01, 0x06, 0x00, 0xC0, 0x80, 0x60, 0x38,
  0x70, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x30, 0x06, 0x04,
  0x00, 0x60, 0x80, 0x04, 0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x30, 0x60,
  0x1C, 0x0F, 0xFF, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x60,
  0x30, 0x30, 0x06, 0x18, 0x00, 0x84, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03,
  0x60, 0x00, 0x58, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00,
  0x13, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x60,
  0x38, 0x70, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x80, 0x30, 0x20,
  0x06, 0x08, 0x00, 0x86, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06, 0x08, 0x07, 0x03,
  0xFF, 0x00, 0x80, 0xC0, 0x20, 0x30, 0x18, 0x04, 0x06, 0x01, 0x81, 0x00,
  0x60, 0x40, 0x08, 0x10, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x06,
  0x20, 0x00, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x60, 0x38, 0x30, 0x06,
  0x18, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x12, 0x00, 0x04,
  0xC0, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x61, 0x80, 0x30, 0x38, 0x38, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x84, 0x00,
  0x10, 0x80, 0x02, 0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00,
  0x42, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x0C, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03, 0x01, 0x00, 0xC0, 0x38, 0x70,
  0x01, 0xF8, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C,
  0x40, 0x03, 0x10, 0x00, 0x86, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x18,
  0x02, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x0C, 0x08, 0x03, 0x06,
  0x00, 0xC1, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x18, 0x00, 0x46, 0x00,
  0x19, 0x00, 0x06, 0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0x40, 0xA0, 0x50, 0x68, 0x34, 0x1A, 0x09, 0x04, 0x82, 0x41, 0x21, 0x90,
  0xC8, 0x44, 0x22, 0x11, 0x08, 0x8C, 0x46, 0x22, 0x11, 0x08, 0x84, 0x42,
  0x61, 0x30, 0x90, 0x4C, 0x24, 0x12, 0x0B, 0x04, 0x82, 0x81, 0x60, 0xA0,
  0x50, 0x38, 0x14, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18,
  0x00, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x20, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x20, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x32, 0x00, 0x00, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x02, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x60, 0x60, 0x00, 0x83, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x64, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06,
  0x08, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x10, 0x30, 0x06, 0x08, 0x01,
  0x86, 0x00, 0x23, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x1F,
  0xFF, 0xC0, 0x03, 0xE0, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x1F,
  0x80, 0xC1, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x81,
  0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC1, 0x81, 0x02, 0x04, 0x0C,
  0x18, 0x10, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x1F,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x80, 0x36, 0x01, 0x30, 0x18,
  0x81, 0x84, 0x08, 0x30, 0xC1, 0x84, 0x04, 0x60, 0x22, 0x01, 0x70, 0x0C,
  0xFF, 0xFE, 0x8C, 0x46, 0x30, 0x03, 0xFC, 0x0E, 0x0E, 0x18, 0x02, 0x10,
  0x03, 0x30, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0xFE, 0x1F,
  0x82, 0x30, 0x02, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x04, 0xC0,
  0x0C, 0xC0, 0x34, 0x60, 0xE4, 0x3F, 0x84, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x11,
  0xF8, 0x17, 0x0C, 0x1C, 0x06, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40,
  0x02, 0x40, 0x06, 0x40, 0x04, 0xE0, 0x0C, 0xE0, 0x18, 0xD8, 0x70, 0x8F,
  0xE0, 0x03, 0xF8, 0x07, 0x0E, 0x0C, 0x02, 0x18, 0x03, 0x30, 0x01, 0x30,
  0x01, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x18, 0x38,
  0x30, 0x0F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x03, 0xF9, 0x81,
  0x83, 0x60, 0xC0, 0x70, 0x60, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x10, 0x01, 0x84, 0x00, 0x41, 0x80, 0x30, 0x20, 0x14, 0x0E,
  0x1B, 0x01, 0xFC, 0xC0, 0x03, 0xF8, 0x03, 0x87, 0x03, 0x00, 0x83, 0x00,
  0x63, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x7F, 0xFF, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x08, 0x30, 0x0C, 0x0C, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFC, 0xC0, 0xC1, 0xB0,
  0x60, 0x38, 0x30, 0x06, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03,
  0x08, 0x00, 0xC2, 0x00, 0x20, 0xC0, 0x18, 0x10, 0x0E, 0x07, 0x0D, 0x80,
  0xFE, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x04, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x70, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x11, 0xFC, 0x13, 0x06, 0x34, 0x03, 0x38, 0x03, 0x30, 0x01, 0x30, 0x01,
  0x20, 0x01, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x81, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x02, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x01,
  0xC6, 0x01, 0xC1, 0x80, 0xC0, 0x40, 0x60, 0x10, 0x30, 0x04, 0x38, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x37, 0x00, 0x0F, 0x40, 0x03, 0x18, 0x00, 0x83,
  0x00, 0x60, 0x40, 0x18, 0x18, 0x06, 0x03, 0x01, 0x00, 0x60, 0x40, 0x18,
  0x30, 0x03, 0x0C, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x03, 0xFF, 0xF8, 0x13, 0xE3, 0xE1, 0xC3,
  0xC3, 0x18, 0x38, 0x13, 0x03, 0x01, 0x30, 0x30, 0x12, 0x03, 0x01, 0x20,
  0x30, 0x32, 0x02, 0x03, 0x60, 0x20, 0x26, 0x02, 0x02, 0x60, 0x60, 0x24,
  0x06, 0x02, 0x40, 0x60, 0x64, 0x04, 0x06, 0xC0, 0x40, 0x4C, 0x04, 0x04,
  0xC0, 0xC0, 0x48, 0x0C, 0x04, 0x80, 0x80, 0xC0, 0x11, 0xFC, 0x13, 0x06,
  0x34, 0x03, 0x38, 0x03, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06,
  0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x03, 0xF8,
  0x03, 0x06, 0x07, 0x01, 0x82, 0x00, 0x63, 0x00, 0x13, 0x00, 0x09, 0x80,
  0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x13, 0x00, 0x18, 0x80, 0x18, 0x60, 0x18, 0x1C, 0x38,
  0x07, 0xF0, 0x00, 0x04, 0x7E, 0x01, 0x70, 0xC0, 0x70, 0x18, 0x38, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63, 0x00,
  0x10, 0xC0, 0x0C, 0x38, 0x06, 0x0F, 0x87, 0x02, 0x3F, 0x80, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xF9, 0x83, 0x06, 0xC3, 0x01, 0xC3, 0x00, 0x63, 0x00,
  0x31, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x01, 0x98, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x18,
  0x20, 0x1C, 0x1C, 0x36, 0x07, 0xF3, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x10, 0xFE,
  0x27, 0x00, 0xD8, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFC,
  0x07, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x21, 0x00, 0x18, 0x80, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x13, 0x00, 0x08, 0x80, 0x0C, 0x60, 0x0C, 0x1C, 0x1C,
  0x07, 0xFC, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x03,
  0xFF, 0xF0, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xFC, 0x20, 0x03, 0x20,
  0x03, 0x20, 0x03, 0x60, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x06, 0x40,
  0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0x80, 0x0C, 0x80,
  0x0C, 0x80, 0x0C, 0xC0, 0x18, 0xC0, 0x28, 0x60, 0xC8, 0x3F, 0x98, 0xC0,
  0x01, 0xA0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x61, 0x00, 0x20,
  0x80, 0x30, 0x60, 0x30, 0x30, 0x10, 0x08, 0x18, 0x04, 0x08, 0x03, 0x0C,
  0x01, 0x84, 0x00, 0x46, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x70, 0x18, 0x1A, 0x07, 0x03, 0x40,
  0xA0, 0x48, 0x14, 0x19, 0x06, 0x82, 0x20, 0x90, 0x44, 0x32, 0x18, 0x84,
  0x42, 0x11, 0x88, 0xC3, 0x21, 0x10, 0x64, 0x22, 0x0D, 0x86, 0xC1, 0xA0,
  0xD0, 0x3C, 0x1E, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x01, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x61, 0x80, 0x18, 0x10, 0x06, 0x03, 0x01, 0x80,
  0x30, 0x60, 0x06, 0x18, 0x00, 0x66, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x31, 0x00, 0x0C, 0x30, 0x03,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x43, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x40, 0x01, 0x81, 0x00, 0x0C, 0x06,
  0x00, 0x20, 0x18, 0x01, 0x80, 0x20, 0x0C, 0x00, 0xC0, 0x20, 0x03, 0x01,
  0x80, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00,
  0x02, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x30, 0x06, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x82, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x03, 0xC0, 0x18, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x05, 0x87, 0x01, 0xE0, 0x30, 0x28, 0x03,
  0x0D, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 26, 21, 7, -26 },
  { 21, 7, 8, 21, 9, -27 },
  { 28, 21, 26, 21, 0, -26 },
  { 97, 18, 33, 21, 2, -29 },
  { 172, 18, 26, 21, 2, -26 },
  { 231, 17, 26, 21, 2, -26 },
  { 287, 3, 8, 21, 10, -27 },
  { 290, 11, 37, 21, 6, -29 },
  { 341, 11, 37, 21, 3, -29 },
  { 392, 15, 15, 21, 5, -26 },
  { 421, 17, 18, 21, 2, -21 },
  { 460, 5, 8, 21, 4, -3 },
  { 465, 13, 1, 21, 4, -12 },
  { 467, 3, 3, 21, 8, -3 },
  { 469, 16, 28, 21, 3, -26 },
  { 525, 16, 26, 21, 3, -26 },
  { 577, 9, 26, 21, 6, -26 },
  { 607, 17, 26, 21, 1, -26 },
  { 663, 17, 26, 21, 1, -26 },
  { 719, 18, 26, 21, 1, -26 },
  { 778, 18, 26, 21, 3, -26 },
  { 837, 16, 26, 21, 2, -26 },
  { 889, 17, 26, 21, 4, -26 },
  { 945, 18, 26, 21, 2, -26 },
  { 1004, 16, 26, 21, 3, -26 },
  { 1056, 5, 18, 21, 9, -18 },
  { 1068, 7, 23, 21, 7, -18 },
  { 1089, 16, 15, 21, 3, -19 },
  { 1119, 17, 9, 21, 2, -16 },
  { 1139, 16, 15, 21, 2, -19 },
  { 1169, 13, 26, 21, 6, -26 },
  { 1212, 20, 26, 21, 1, -26 },
  { 1277, 18, 26, 21, 0, -26 },
  { 1336, 18, 26, 21, 2, -26 },
  { 1395, 18, 26, 21, 2, -26 },
  { 1454, 19, 26, 21, 1, -26 },
  { 1516, 19, 26, 21, 2, -26 },
  { 1578, 19, 26, 21, 2, -26 },
  { 1640, 18, 26, 21, 2, -26 },
  { 1699, 20, 26, 21, 1, -26 },
  { 1764, 18, 26, 21, 2, -26 },
  { 1823, 19, 26, 21, 1, -26 },
  { 1885, 20, 26, 21, 2, -26 },
  { 1950, 15, 26, 21, 2, -26 },
  { 1999, 20, 26, 21, 1, -26 },
  { 2064, 20, 26, 21, 1, -26 },
  { 2129, 18, 26, 21, 2, -26 },
  { 2188, 19, 26, 21, 2, -26 },
  { 2250, 18, 31, 21, 2, -26 },
  { 2320, 18, 26, 21, 2, -26 },
  { 2379, 18, 26, 21, 2, -26 },
  { 2438, 18, 26, 21, 4, -26 },
  { 2497, 19, 26, 21, 2, -26 },
  { 2559, 18, 26, 21, 4, -26 },
  { 2618, 18, 26, 21, 4, -26 },
  { 2677, 22, 26, 21, 0, -26 },
  { 2749, 18, 26, 21, 4, -26 },
  { 2808, 19, 26, 21, 1, -26 },
  { 2870, 11, 34, 21, 5, -29 },
  { 2917, 7, 28, 21, 7, -26 },
  { 2942, 11, 34, 21, 5, -29 },
  { 2989, 13, 14, 21, 4, -26 },
  { 3012, 15, 1, 21, 1, 0 },
  { 3014, 4, 5, 21, 11, -27 },
  { 3017, 16, 19, 21, 2, -19 },
  { 3055, 16, 27, 21, 2, -27 },
  { 3109, 16, 19, 21, 2, -19 },
  { 3147, 18, 27, 21, 2, -27 },
  { 3208, 17, 19, 21, 2, -19 },
  { 3249, 17, 27, 21, 5, -27 },
  { 3307, 18, 27, 21, 1, -19 },
  { 3368, 16, 27, 21, 2, -27 },
  { 3422, 15, 26, 21, 2, -26 },
  { 3471, 17, 34, 21, 0, -26 },
  { 3544, 18, 27, 21, 2, -27 },
  { 3605, 15, 27, 21, 2, -27 },
  { 3656, 20, 19, 21, 0, -19 },
  { 3704, 16, 19, 21, 2, -19 },
  { 3742, 17, 19, 21, 2, -19 },
  { 3783, 18, 26, 21, 0, -19 },
  { 3842, 17, 26, 21, 2, -19 },
  { 3898, 15, 19, 21, 5, -19 },
  { 3934, 17, 19, 21, 2, -19 },
  { 3975, 14, 24, 21, 4, -24 },
  { 4017, 16, 19, 21, 3, -19 },
  { 4055, 17, 19, 21, 3, -19 },
  { 4096, 19, 19, 21, 3, -19 },
  { 4142, 19, 19, 21, 1, -19 },
  { 4188, 22, 27, 21, -1, -19 },
  { 4263, 18, 19, 21, 1, -19 },
  { 4306, 13, 35, 21, 6, -28 },
  { 4363, 7, 31, 21, 7, -26 },
  { 4391, 14, 35, 21, 3, -28 },
  { 4453, 19, 6, 21, 1, -14 },
};

const GFXfont RobotoMono_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC36PT7B_H_
