#ifndef _ROBOTOMONO_EXTRALIGHTITALIC25PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x40, 0x00, 0x4C, 0x4A, 0x63,
  0x19, 0x48, 0x00, 0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x07,
  0xFF, 0xC0, 0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x00, 0x42,
  0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20, 0x08, 0x80, 0x21, 0x00, 0x42, 0x00,
  0x01, 0x00, 0x10, 0x07, 0x81, 0x86, 0x30, 0x22, 0x02, 0x20, 0x32, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x48, 0x04,
  0x80, 0x48, 0x0C, 0x41, 0x83, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x38,
  0x04, 0x80, 0x84, 0x28, 0x44, 0x88, 0x88, 0x88, 0x89, 0x0F, 0x20, 0x06,
  0x00, 0x40, 0x08, 0xC1, 0x32, 0x12, 0x12, 0x21, 0x44, 0x2C, 0x42, 0x02,
  0x20, 0x3C, 0x07, 0x80, 0xC4, 0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x09,
  0x00, 0xE0, 0x0C, 0x01, 0x40, 0x22, 0x14, 0x11, 0x41, 0x18, 0x0A, 0x80,
  0xEC, 0x04, 0x41, 0xA3, 0xE3, 0x55, 0xA0, 0x01, 0x02, 0x04, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x80, 0x02,
  0x00, 0x40, 0x10, 0x42, 0x1E, 0x4E, 0x3E, 0x03, 0x00, 0x90, 0x31, 0x0C,
  0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x7F, 0xF8,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x25, 0x28, 0xFF,
  0x80, 0xB0, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x07, 0x83, 0x08, 0xC0,
  0x90, 0x14, 0x02, 0x80, 0xD0, 0x2E, 0x09, 0x82, 0x30, 0x86, 0x60, 0xD8,
  0x3C, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x04, 0x76, 0x61,
  0x04, 0x30, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x80, 0x07,
  0x83, 0x08, 0xC0, 0x90, 0x14, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x1F, 0xF8,
  0x07, 0xC1, 0x86, 0x30, 0x22, 0x01, 0x60, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x0F, 0x80, 0x38, 0x00, 0x40, 0x04, 0x00, 0x68, 0x04, 0x80, 0x48, 0x0C,
  0x41, 0x83, 0xE0, 0x00, 0x20, 0x06, 0x00, 0xA0, 0x12, 0x03, 0x40, 0x24,
  0x04, 0x40, 0x84, 0x10, 0x43, 0x0C, 0x60, 0x84, 0x08, 0xFF, 0xF0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x0F, 0xF1, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x03, 0xF8, 0x20, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x48, 0x04, 0x80, 0x4C, 0x08, 0x41, 0x83, 0xE0, 0x00, 0xE0, 0x60,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0xC1, 0x66, 0x70, 0x68, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x20, 0x83, 0xE0, 0xFF, 0xE0,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x00, 0x03,
  0xE0, 0x61, 0x86, 0x04, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04,
  0x0F, 0xC0, 0xE6, 0x0C, 0x08, 0xC0, 0x44, 0x01, 0x20, 0x09, 0x00, 0x88,
  0x04, 0x60, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0x08, 0x81, 0xB0, 0x14, 0x02,
  0x80, 0x50, 0x0E, 0x01, 0x40, 0x28, 0x0D, 0x87, 0x1F, 0x20, 0x04, 0x01,
  0x00, 0x60, 0x18, 0x06, 0x0F, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x04,
  0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44, 0x21, 0x10, 0x00,
  0x20, 0x38, 0x18, 0x1C, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x0C,
  0x00, 0x1E, 0x30, 0x90, 0x30, 0x10, 0x08, 0x04, 0x04, 0x06, 0x06, 0x06,
  0x04, 0x02, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0xE0,
  0x10, 0x41, 0x80, 0x84, 0x02, 0x23, 0xC9, 0x11, 0x14, 0x84, 0x62, 0x12,
  0x90, 0x8A, 0x42, 0x29, 0x08, 0xA4, 0x44, 0x91, 0x12, 0x7A, 0x88, 0x04,
  0x20, 0x00, 0x40, 0x80, 0xFC, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x14,
  0x01, 0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x21, 0x02,
  0x1F, 0xF2, 0x01, 0x20, 0x14, 0x01, 0x40, 0x18, 0x01, 0x1F, 0x80, 0x83,
  0x04, 0x04, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80, 0x44, 0x0C, 0x3F, 0x81,
  0x06, 0x18, 0x08, 0x80, 0x64, 0x01, 0x20, 0x19, 0x00, 0x88, 0x0C, 0x80,
  0xC7, 0xF8, 0x00, 0x07, 0x81, 0x86, 0x30, 0x22, 0x03, 0x40, 0x14, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x08, 0x41, 0x03, 0xE0, 0x1F, 0x80, 0x83, 0x04, 0x0C, 0x60,
  0x22, 0x01, 0x10, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x11, 0x01, 0x90, 0x18, 0x81, 0x87, 0xF0, 0x00,
  0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x3F, 0xE1, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xE1, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x03, 0xC0, 0x61, 0x86, 0x04, 0x20, 0x32, 0x00, 0x90, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0xFD, 0x00, 0x2C, 0x01, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x20, 0x40, 0xFC, 0x00, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x7F, 0xF2, 0x00, 0x90, 0x04,
  0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x00,
  0x1F, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x40, 0x22, 0x01, 0x10, 0x10, 0x41, 0x81, 0xF0, 0x00,
  0x10, 0x04, 0x40, 0x21, 0x01, 0x04, 0x18, 0x10, 0xC0, 0x86, 0x02, 0x30,
  0x09, 0x80, 0x2C, 0x00, 0xE8, 0x03, 0x20, 0x10, 0x40, 0x41, 0x81, 0x02,
  0x04, 0x0C, 0x10, 0x10, 0x40, 0x22, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xFC, 0x10, 0x0C, 0x60,
  0x63, 0x81, 0x8A, 0x0A, 0x28, 0x28, 0xA1, 0x22, 0x85, 0x09, 0x24, 0x45,
  0x91, 0x14, 0x44, 0x61, 0x11, 0x84, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x22, 0x01, 0x80, 0x10, 0x08, 0x80, 0x4A, 0x02, 0x50, 0x12,
  0x80, 0x92, 0x08, 0x90, 0x44, 0x82, 0x42, 0x12, 0x10, 0x90, 0x44, 0x82,
  0x44, 0x12, 0x20, 0x52, 0x02, 0x90, 0x14, 0x80, 0x64, 0x02, 0x00, 0x03,
  0xC0, 0x61, 0x06, 0x04, 0x20, 0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x2C, 0x02, 0x20, 0x11, 0x01, 0x88,
  0x08, 0x20, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x81, 0x84, 0x02, 0x20, 0x11,
  0x00, 0x88, 0x04, 0x80, 0x24, 0x03, 0x20, 0x31, 0x07, 0x0F, 0xC0, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x00, 0x03,
  0xC0, 0x61, 0x04, 0x04, 0x60, 0x32, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x11, 0x00, 0x88,
  0x08, 0x20, 0x80, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x1F, 0x80,
  0x83, 0x04, 0x04, 0x20, 0x31, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20,
  0x21, 0x0E, 0x0F, 0xC0, 0x81, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08,
  0x40, 0x64, 0x01, 0x00, 0x07, 0xC0, 0x61, 0x84, 0x04, 0x60, 0x12, 0x00,
  0x90, 0x00, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x40, 0x0B, 0x00, 0x88, 0x04, 0x60, 0x40, 0xFC, 0x00, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0xC8,
  0x08, 0x41, 0x03, 0xE0, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0xC0, 0x44,
  0x0C, 0x40, 0x84, 0x18, 0x41, 0x04, 0x10, 0x42, 0x02, 0x20, 0x24, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x30, 0x01, 0x00, 0x82, 0x0C, 0x30, 0xA1, 0x85,
  0x0C, 0x28, 0xA2, 0x45, 0x12, 0x48, 0x92, 0x48, 0x92, 0x45, 0x12, 0x28,
  0xA1, 0x45, 0x0C, 0x28, 0x61, 0x43, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10,
  0x00, 0x18, 0x02, 0x10, 0x08, 0x20, 0x20, 0x20, 0xC0, 0x41, 0x00, 0x44,
  0x00, 0x90, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x26, 0x00,
  0xC4, 0x01, 0x08, 0x04, 0x08, 0x10, 0x10, 0x60, 0x11, 0x80, 0x20, 0x80,
  0x18, 0x02, 0x40, 0x64, 0x04, 0x40, 0x82, 0x10, 0x21, 0x02, 0x20, 0x14,
  0x01, 0x40, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x1E, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x78, 0x84, 0x20, 0x84, 0x21, 0x08,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x82, 0x10, 0x0F, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0xF0, 0x06, 0x03, 0x02, 0x81,
  0x41, 0x20, 0x88, 0x84, 0xC2, 0x41, 0x40, 0x40, 0xFF, 0xC0, 0xCC, 0x80,
  0x0F, 0xC1, 0x02, 0x20, 0x20, 0x03, 0x00, 0x20, 0x1E, 0x1C, 0x26, 0x02,
  0x40, 0x28, 0x06, 0xC0, 0xC4, 0x1C, 0x3E, 0x40, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x27, 0xC3, 0x82, 0x20, 0x22, 0x03, 0x20,
  0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40, 0x46, 0x08, 0x9F,
  0x00, 0x1F, 0x86, 0x09, 0x81, 0xA0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x0A, 0x02, 0x20, 0x83, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x1F, 0xA2, 0x0A, 0x40, 0x64, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x18, 0x7E, 0x80,
  0x1F, 0x86, 0x09, 0x81, 0xA0, 0x18, 0x03, 0xFF, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x02, 0x20, 0xC3, 0xF0, 0x01, 0xF0, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xFF, 0xC0, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x0F,
  0xD1, 0x05, 0x20, 0x32, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x04, 0x40, 0x42, 0x0C, 0x1F, 0x40, 0x04, 0x00, 0x88, 0x08, 0xC1,
  0x07, 0xE0, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x27,
  0xE2, 0x82, 0x30, 0x32, 0x01, 0x20, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x40, 0x00, 0x80, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x1F, 0xFC, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x3E, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x01, 0x20, 0x62, 0x08, 0x41, 0x04, 0x60, 0x4C, 0x05, 0x80, 0x68, 0x0C,
  0x40, 0x86, 0x08, 0x20, 0x81, 0x08, 0x18, 0x80, 0xC0, 0x0F, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x83, 0xFF, 0x80,
  0x3F, 0x7C, 0x86, 0x12, 0x10, 0x50, 0x41, 0x41, 0x05, 0x04, 0x14, 0x10,
  0x90, 0x82, 0x42, 0x0A, 0x08, 0x28, 0x20, 0xA0, 0x82, 0x82, 0x10, 0x27,
  0xE2, 0x82, 0x30, 0x32, 0x01, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x40, 0x0F, 0xC1, 0x02, 0x20, 0x26,
  0x01, 0x40, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x24, 0x02, 0x40, 0x46,
  0x08, 0x1F, 0x00, 0x17, 0xE0, 0xE0, 0x86, 0x04, 0x20, 0x21, 0x01, 0x98,
  0x0C, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0xE0, 0x84, 0xF8,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x00, 0x1F, 0xA4, 0x15,
  0x01, 0xA0, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02,
  0x20, 0xC7, 0xE8, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x27, 0xE5,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x00, 0x1F, 0xC4, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x70,
  0x01, 0xC0, 0x04, 0x00, 0x50, 0x0A, 0x01, 0x60, 0x47, 0xF0, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0xFF, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x1A, 0x02, 0x61,
  0xC7, 0xC8, 0xC0, 0x14, 0x02, 0x40, 0x64, 0x04, 0x60, 0x82, 0x08, 0x21,
  0x02, 0x10, 0x32, 0x01, 0x60, 0x14, 0x01, 0x80, 0x08, 0x00, 0x82, 0x0C,
  0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x45, 0x12, 0x49, 0x12, 0x48, 0xA2,
  0x45, 0x0C, 0x30, 0x61, 0x82, 0x0C, 0x10, 0x00, 0x10, 0x0C, 0x20, 0x40,
  0xC2, 0x01, 0x18, 0x02, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x04, 0x80,
  0x21, 0x01, 0x06, 0x08, 0x08, 0xC0, 0x10, 0x20, 0x06, 0x60, 0x18, 0x40,
  0x20, 0x80, 0x81, 0x01, 0x01, 0x04, 0x02, 0x18, 0x04, 0x20, 0x0C, 0x80,
  0x09, 0x00, 0x14, 0x00, 0x38, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF,
  0xE0, 0x00, 0x40, 0x60, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0xC0, 0xC0, 0x38, 0x02, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x0C, 0x00, 0x11, 0x11, 0x11,
  0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x0C, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x07, 0x01,
  0x80, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02,
  0x03, 0x00, 0x10, 0x03, 0x60, 0x61, 0x87, 0x06, 0x60, 0x0E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 18, 15, 5, -18 },
  { 10, 5, 6, 15, 6, -19 },
  { 14, 15, 18, 15, 0, -18 },
  { 48, 12, 23, 15, 2, -20 },
  { 83, 12, 18, 15, 2, -18 },
  { 110, 12, 18, 15, 1, -18 },
  { 137, 2, 6, 15, 7, -19 },
  { 139, 8, 26, 15, 4, -20 },
  { 165, 8, 26, 15, 2, -20 },
  { 191, 11, 10, 15, 3, -18 },
  { 205, 12, 13, 15, 1, -15 },
  { 225, 3, 5, 15, 3, -2 },
  { 227, 9, 1, 15, 3, -9 },
  { 229, 2, 2, 15, 6, -2 },
  { 230, 12, 20, 15, 2, -18 },
  { 260, 11, 18, 15, 2, -18 },
  { 285, 6, 18, 15, 4, -18 },
  { 299, 11, 18, 15, 1, -18 },
  { 324, 12, 18, 15, 1, -18 },
  { 351, 12, 18, 15, 1, -18 },
  { 378, 12, 18, 15, 2, -18 },
  { 405, 11, 18, 15, 1, -18 },
  { 430, 11, 18, 15, 3, -18 },
  { 455, 13, 18, 15, 1, -18 },
  { 485, 11, 18, 15, 2, -18 },
  { 510, 4, 13, 15, 6, -13 },
  { 517, 5, 16, 15, 5, -13 },
  { 527, 11, 10, 15, 2, -13 },
  { 541, 11, 6, 15, 2, -11 },
  { 550, 12, 10, 15, 1, -13 },
  { 565, 9, 18, 15, 4, -18 },
  { 586, 14, 18, 15, 1, -18 },
  { 618, 12, 18, 15, 0, -18 },
  { 645, 13, 18, 15, 1, -18 },
  { 675, 12, 18, 15, 2, -18 },
  { 702, 13, 18, 15, 1, -18 },
  { 732, 13, 18, 15, 1, -18 },
  { 762, 13, 18, 15, 1, -18 },
  { 792, 13, 18, 15, 1, -18 },
  { 822, 13, 18, 15, 1, -18 },
  { 852, 13, 18, 15, 1, -18 },
  { 882, 13, 18, 15, 1, -18 },
  { 912, 14, 18, 15, 1, -18 },
  { 944, 11, 18, 15, 1, -18 },
  { 969, 14, 18, 15, 1, -18 },
  { 1001, 13, 18, 15, 1, -18 },
  { 1031, 13, 18, 15, 1, -18 },
  { 1061, 13, 18, 15, 1, -18 },
  { 1091, 13, 21, 15, 1, -18 },
  { 1126, 13, 18, 15, 1, -18 },
  { 1156, 13, 18, 15, 1, -18 },
  { 1186, 12, 18, 15, 3, -18 },
  { 1213, 12, 18, 15, 2, -18 },
  { 1240, 12, 18, 15, 3, -18 },
  { 1267, 13, 18, 15, 3, -18 },
  { 1297, 15, 18, 15, 0, -18 },
  { 1331, 12, 18, 15, 3, -18 },
  { 1358, 14, 18, 15, 0, -18 },
  { 1390, 7, 24, 15, 4, -20 },
  { 1411, 5, 20, 15, 5, -18 },
  { 1424, 8, 24, 15, 3, -20 },
  { 1448, 9, 10, 15, 3, -18 },
  { 1460, 10, 1, 15, 1, 0 },
  { 1462, 3, 3, 15, 7, -18 },
  { 1464, 12, 13, 15, 1, -13 },
  { 1484, 12, 19, 15, 1, -19 },
  { 1513, 11, 13, 15, 2, -13 },
  { 1531, 12, 19, 15, 2, -19 },
  { 1560, 11, 13, 15, 2, -13 },
  { 1578, 12, 19, 15, 3, -19 },
  { 1607, 12, 18, 15, 1, -13 },
  { 1634, 12, 19, 15, 1, -19 },
  { 1663, 11, 18, 15, 1, -18 },
  { 1688, 11, 23, 15, 0, -18 },
  { 1720, 12, 19, 15, 2, -19 },
  { 1749, 11, 19, 15, 1, -19 },
  { 1776, 14, 13, 15, 0, -13 },
  { 1799, 12, 13, 15, 1, -13 },
  { 1819, 12, 13, 15, 1, -13 },
  { 1839, 13, 18, 15, 0, -13 },
  { 1869, 11, 18, 15, 2, -13 },
  { 1894, 11, 13, 15, 3, -13 },
  { 1912, 11, 13, 15, 2, -13 },
  { 1930, 10, 17, 15, 3, -17 },
  { 1952, 11, 13, 15, 2, -13 },
  { 1970, 12, 13, 15, 2, -13 },
  { 1990, 13, 13, 15, 2, -13 },
  { 2012, 14, 13, 15, 0, -13 },
  { 2035, 15, 18, 15, 0, -13 },
  { 2069, 12, 13, 15, 1, -13 },
  { 2089, 10, 25, 15, 4, -20 },
  { 2121, 4, 22, 15, 5, -18 },
  { 2132, 10, 24, 15, 2, -19 },
  { 2162, 13, 5, 15, 1, -10 },
};

const GFXfont RobotoMono_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC25PT7B_H_
