#ifndef _ROBOTOMONO_EXTRALIGHTITALIC31PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82,
  0x08, 0x00, 0x00, 0x00, 0x43, 0x00, 0x66, 0x8D, 0x12, 0x24, 0x59, 0x80,
  0x00, 0x20, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01, 0x04, 0x00, 0x83, 0x00,
  0x20, 0x81, 0xFF, 0xFC, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x06, 0x08, 0x01, 0x04, 0x00, 0x41, 0x03, 0xFF, 0xFC,
  0x08, 0x20, 0x02, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x1F, 0xC0, 0x60, 0xC1,
  0x00, 0x86, 0x01, 0x08, 0x03, 0x10, 0x06, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x26, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x10, 0x0C, 0x18, 0x30, 0x1F,
  0xC0, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x3C, 0x00, 0xC4, 0x01, 0x08,
  0x24, 0x10, 0x68, 0x21, 0x90, 0x42, 0x20, 0x88, 0x42, 0x20, 0x4C, 0xC0,
  0x61, 0x00, 0x04, 0x00, 0x18, 0x00, 0x23, 0x80, 0x8D, 0x83, 0x21, 0x84,
  0x41, 0x11, 0x82, 0x42, 0x0D, 0x84, 0x12, 0x08, 0x20, 0x08, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x02, 0x18, 0x06, 0x08, 0x04, 0x08, 0x0C, 0x08, 0x0C,
  0x10, 0x0C, 0x30, 0x04, 0x60, 0x04, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0D,
  0x00, 0x11, 0x83, 0x30, 0xC2, 0x60, 0x42, 0x40, 0x66, 0x40, 0x24, 0x40,
  0x1C, 0x40, 0x18, 0x60, 0x38, 0x30, 0x6C, 0x1F, 0x86, 0x57, 0xA0, 0x00,
  0x40, 0x30, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x0C, 0x21, 0xBD,
  0x78, 0x3E, 0x00, 0xC0, 0x0D, 0x00, 0xCC, 0x0C, 0x30, 0xC0, 0x84, 0x04,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x24, 0xB5, 0xA0, 0x7F, 0xFF,
  0xFC, 0xF0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x03,
  0xF0, 0x0C, 0x30, 0x20, 0x30, 0x80, 0x23, 0x00, 0x44, 0x00, 0xC8, 0x03,
  0xB0, 0x0B, 0x40, 0x24, 0x81, 0x89, 0x06, 0x12, 0x18, 0x2C, 0x60, 0xD9,
  0x01, 0xB4, 0x02, 0x70, 0x04, 0xC0, 0x19, 0x80, 0x21, 0x00, 0xC2, 0x03,
  0x02, 0x0C, 0x03, 0xF0, 0x00, 0x03, 0x0F, 0x72, 0xC2, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xC4, 0x01, 0x20, 0x04,
  0x80, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x1C, 0x18, 0x20, 0x10,
  0x80, 0x33, 0x00, 0x64, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x1F, 0x80, 0x07, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x80, 0x09, 0x00, 0x13, 0x00, 0x42, 0x01, 0x86, 0x06, 0x03, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x62, 0x01, 0x8C, 0x02, 0x18, 0x08, 0x20, 0x20, 0x40, 0xC0, 0x83, 0x01,
  0x0C, 0x06, 0x10, 0x0C, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x27, 0xC0, 0x70,
  0xC1, 0x80, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x80, 0x11, 0x00, 0x62, 0x00, 0x86, 0x03, 0x06, 0x0C, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x6F, 0xE2, 0xC1, 0x98, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xB0, 0x0C, 0x80, 0xC3, 0x0C, 0x0F, 0xC0,
  0xFF, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x03, 0xF8, 0x0C, 0x18, 0x20, 0x10, 0xC0, 0x31, 0x00,
  0x26, 0x00, 0x4C, 0x01, 0x88, 0x02, 0x10, 0x0C, 0x18, 0x70, 0x1F, 0x80,
  0xE3, 0x83, 0x01, 0x8C, 0x01, 0x10, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x00,
  0x13, 0x00, 0x62, 0x01, 0x86, 0x06, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0xC1,
  0x8C, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x06, 0x80, 0x76, 0x07, 0x18, 0xC8, 0x3C, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x07, 0x00, 0xE0, 0x3C, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x82, 0x08, 0x61, 0x08, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x04, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x30, 0x00, 0x1F, 0x86, 0x09, 0x81, 0xE0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x01, 0x81, 0x01, 0x00, 0x41, 0x00, 0x31, 0x06, 0x09, 0x8E, 0xC4,
  0x8C, 0x22, 0xC4, 0x21, 0x44, 0x10, 0xA2, 0x08, 0x61, 0x04, 0x31, 0x04,
  0x28, 0x82, 0x14, 0x41, 0x0A, 0x21, 0x89, 0x11, 0x44, 0x8F, 0x3C, 0x41,
  0x08, 0x30, 0x00, 0x08, 0x00, 0x03, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x02, 0xC0, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x84, 0x01, 0x08, 0x06, 0x10, 0x08, 0x30, 0x30, 0x20, 0x40, 0x41, 0x80,
  0x83, 0xFF, 0x0F, 0xFE, 0x10, 0x04, 0x60, 0x0C, 0x80, 0x1B, 0x00, 0x14,
  0x00, 0x38, 0x00, 0x40, 0x0F, 0xF8, 0x08, 0x0C, 0x08, 0x06, 0x08, 0x02,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x18,
  0x3F, 0xE0, 0x30, 0x38, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x06, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x18, 0x40, 0x70, 0xFF, 0xC0,
  0x03, 0xF0, 0x0C, 0x18, 0x20, 0x10, 0x80, 0x33, 0x00, 0x24, 0x00, 0x58,
  0x00, 0xA0, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x06, 0x80, 0x09, 0x00, 0x33, 0x00, 0x42,
  0x01, 0x02, 0x0C, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x08, 0x18, 0x08, 0x04,
  0x18, 0x02, 0x18, 0x02, 0x10, 0x03, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x30, 0x01, 0x20, 0x01, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02,
  0x60, 0x06, 0x40, 0x04, 0x40, 0x08, 0x40, 0x18, 0x40, 0x30, 0xC1, 0xC0,
  0xFF, 0x00, 0x1F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x0C, 0x18, 0x20, 0x10,
  0x80, 0x33, 0x00, 0x24, 0x00, 0x58, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xD0, 0x00, 0xA0, 0x03, 0x40, 0x06,
  0x80, 0x09, 0x00, 0x11, 0x00, 0x23, 0x00, 0xC3, 0x07, 0x03, 0xF8, 0x00,
  0x08, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x0C, 0x60, 0x06, 0x20, 0x02, 0x10, 0x01, 0x0F, 0xFF, 0x84,
  0x00, 0x42, 0x00, 0x63, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x03, 0x18, 0x01, 0x08, 0x00, 0x84, 0x00, 0x40, 0x0F,
  0xFF, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x30,
  0xE0, 0x1F, 0x80, 0x18, 0x01, 0x88, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01,
  0x03, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x43, 0x00, 0x23, 0x00, 0x13, 0x00,
  0x0B, 0x80, 0x0F, 0x60, 0x07, 0x10, 0x03, 0x0C, 0x01, 0x02, 0x00, 0x81,
  0x80, 0x40, 0x60, 0x60, 0x10, 0x20, 0x0C, 0x10, 0x02, 0x08, 0x01, 0x84,
  0x00, 0x60, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0F, 0xFF, 0x0C,
  0x01, 0x86, 0x01, 0xC7, 0x00, 0xE2, 0x80, 0xE1, 0x40, 0x50, 0xB0, 0x68,
  0x48, 0x24, 0x24, 0x22, 0x32, 0x33, 0x11, 0x11, 0x08, 0xD8, 0x84, 0x68,
  0x42, 0x1C, 0x23, 0x0C, 0x31, 0x84, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x40, 0x08, 0x01,
  0x8E, 0x00, 0xC7, 0x00, 0x42, 0x80, 0x21, 0x60, 0x10, 0x90, 0x08, 0x48,
  0x0C, 0x66, 0x06, 0x31, 0x02, 0x10, 0x81, 0x08, 0x20, 0x84, 0x10, 0x42,
  0x0C, 0x63, 0x02, 0x21, 0x81, 0x10, 0x80, 0xC8, 0x40, 0x24, 0x20, 0x16,
  0x10, 0x0F, 0x18, 0x03, 0x08, 0x01, 0x84, 0x00, 0x40, 0x03, 0xF0, 0x0C,
  0x30, 0x20, 0x30, 0x80, 0x23, 0x00, 0x64, 0x00, 0xD8, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0,
  0x03, 0x40, 0x04, 0x80, 0x09, 0x00, 0x23, 0x00, 0xC2, 0x03, 0x02, 0x0C,
  0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x18, 0x0C, 0x10, 0x06, 0x10, 0x02, 0x10,
  0x03, 0x10, 0x01, 0x30, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20,
  0x0C, 0x20, 0x70, 0x7F, 0xC0, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x1C, 0x30, 0x60, 0x10, 0x80, 0x32, 0x00, 0x2C, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x33, 0x00, 0x42, 0x01,
  0x06, 0x0C, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x1F, 0xF0, 0x20, 0x30, 0x40, 0x10, 0x80, 0x31, 0x00, 0x26, 0x00, 0x4C,
  0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x18, 0x80, 0x63, 0xFF, 0x07, 0xFC,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x30, 0x40, 0x21, 0x80, 0x42, 0x00, 0xC4,
  0x00, 0x88, 0x01, 0x10, 0x03, 0x00, 0x03, 0xF0, 0x18, 0x18, 0x60, 0x11,
  0x80, 0x33, 0x00, 0x24, 0x00, 0x48, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x80, 0x0D, 0x00, 0x12, 0x00, 0x26, 0x00, 0x87, 0x06, 0x03, 0xF8, 0x00,
  0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x10, 0x01, 0x30, 0x03, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x06, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0xC0, 0x30, 0x40, 0x20, 0x60, 0xC0,
  0x1F, 0x80, 0xC0, 0x03, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x60, 0x08, 0x60, 0x18, 0x20, 0x10, 0x20, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x30, 0x40, 0x30, 0xC0, 0x10, 0x80, 0x11, 0x80, 0x11, 0x00, 0x13, 0x00,
  0x12, 0x00, 0x1A, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xC0, 0x81,
  0xC1, 0x81, 0xC1, 0x83, 0xC1, 0x82, 0xC2, 0x82, 0xC2, 0x86, 0x86, 0x84,
  0x84, 0x84, 0x84, 0x84, 0x8C, 0x88, 0x88, 0x88, 0x88, 0x88, 0x98, 0x98,
  0x90, 0x90, 0x90, 0x90, 0xB0, 0xB0, 0xA0, 0xA0, 0xA0, 0xA0, 0xE0, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0x80, 0x10, 0x18,
  0x06, 0x01, 0x01, 0x80, 0x20, 0x20, 0x06, 0x08, 0x00, 0x43, 0x00, 0x0C,
  0xC0, 0x00, 0x90, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0A,
  0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x30, 0x80, 0x0C, 0x08, 0x01, 0x01,
  0x00, 0x40, 0x30, 0x18, 0x02, 0x06, 0x00, 0x61, 0x80, 0x04, 0x00, 0xC0,
  0x03, 0x40, 0x06, 0x60, 0x0C, 0x20, 0x08, 0x20, 0x18, 0x30, 0x30, 0x10,
  0x20, 0x10, 0x60, 0x18, 0xC0, 0x08, 0x80, 0x09, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xFF, 0xF8, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x87,
  0x80, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41,
  0x06, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x07, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x3E, 0x00, 0x03, 0x00, 0x60,
  0x1C, 0x02, 0xC0, 0x88, 0x11, 0x04, 0x21, 0x86, 0x20, 0xCC, 0x09, 0x01,
  0x40, 0x30, 0xFF, 0xF8, 0xC4, 0x63, 0x01, 0x80, 0x3F, 0xC1, 0x81, 0x8C,
  0x02, 0x20, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x1F, 0xF8, 0xC0, 0x24,
  0x01, 0xB0, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x07, 0x30, 0x74, 0x7F, 0x10,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x1C,
  0x09, 0xFC, 0x28, 0x18, 0xC0, 0x22, 0x00, 0x88, 0x03, 0x60, 0x0D, 0x00,
  0x34, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0,
  0x62, 0x83, 0x09, 0xF8, 0x00, 0x01, 0x80, 0x1F, 0xC1, 0x81, 0x8C, 0x02,
  0x20, 0x0D, 0x80, 0x34, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x19, 0x00, 0x44, 0x03, 0x0C, 0x38, 0x1F, 0x80, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0xE1,
  0x07, 0xF2, 0x18, 0x14, 0x60, 0x18, 0x80, 0x33, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x30, 0x02, 0x60, 0x0C, 0x80, 0x19, 0x00, 0x23, 0x00, 0x46, 0x01,
  0x84, 0x07, 0x0C, 0x1E, 0x0F, 0xC8, 0x00, 0x01, 0xC0, 0x1F, 0xC1, 0x81,
  0x8C, 0x02, 0x20, 0x0D, 0x80, 0x14, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x01, 0x0C, 0x18, 0x1F,
  0xC0, 0x00, 0x1C, 0x01, 0xFC, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x01, 0xC0,
  0x0F, 0xE4, 0x30, 0x28, 0xC0, 0x31, 0x00, 0x66, 0x00, 0x88, 0x01, 0x10,
  0x02, 0x60, 0x04, 0xC0, 0x19, 0x00, 0x32, 0x00, 0x46, 0x00, 0x84, 0x03,
  0x08, 0x0E, 0x18, 0x3C, 0x1F, 0x98, 0x00, 0x20, 0x00, 0x40, 0x01, 0x88,
  0x06, 0x08, 0x18, 0x0F, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x1C, 0x09, 0xFC, 0x16, 0x0C,
  0x30, 0x08, 0x40, 0x19, 0x80, 0x33, 0x00, 0x64, 0x00, 0x88, 0x01, 0x10,
  0x02, 0x20, 0x04, 0xC0, 0x19, 0x80, 0x32, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x3F, 0x80, 0x78, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x88, 0x06, 0x30, 0x18, 0x60,
  0xC0, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x05, 0x80, 0x1F, 0x80, 0x39, 0x00,
  0x41, 0x00, 0x83, 0x01, 0x02, 0x02, 0x02, 0x0C, 0x06, 0x10, 0x06, 0x20,
  0x06, 0x00, 0x0F, 0xE0, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x07, 0xFF, 0xC0, 0x03, 0x87, 0x1F, 0xEF, 0xCE, 0x1C, 0x26, 0x0C,
  0x12, 0x04, 0x09, 0x02, 0x04, 0x81, 0x02, 0xC1, 0x81, 0x40, 0xC1, 0xA0,
  0x40, 0xD0, 0x20, 0x48, 0x10, 0x2C, 0x08, 0x16, 0x0C, 0x0A, 0x04, 0x0D,
  0x02, 0x04, 0x81, 0x02, 0x00, 0x00, 0x70, 0x27, 0xF0, 0x58, 0x30, 0xC0,
  0x21, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x13, 0x00, 0x64, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0xC0,
  0x18, 0x03, 0x80, 0x3F, 0xC1, 0x81, 0x8C, 0x02, 0x60, 0x0D, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x1B,
  0x00, 0x44, 0x02, 0x18, 0x30, 0x1F, 0x80, 0x04, 0x60, 0x09, 0xFC, 0x0A,
  0x06, 0x0C, 0x02, 0x08, 0x02, 0x18, 0x02, 0x18, 0x03, 0x10, 0x03, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x30,
  0x18, 0x28, 0x30, 0x27, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x3F, 0x91, 0x81, 0x4C, 0x03,
  0x20, 0x0D, 0x80, 0x24, 0x00, 0x90, 0x02, 0xC0, 0x0B, 0x00, 0x68, 0x01,
  0xA0, 0x04, 0xC0, 0x11, 0x00, 0xC4, 0x07, 0x18, 0x3C, 0x3F, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x00, 0x78,
  0x9F, 0xCD, 0x80, 0x70, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0x80, 0x8C, 0x03, 0x20, 0x04, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0B, 0x00, 0x6C, 0x01, 0x18, 0x18, 0x3F, 0xC0, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x0F, 0xFF, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xC0, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x60,
  0x0D, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x6C, 0x01, 0xB0,
  0x04, 0x40, 0x31, 0x01, 0xC6, 0x0D, 0x0F, 0xCC, 0x80, 0x07, 0x80, 0x11,
  0x00, 0x62, 0x00, 0x84, 0x03, 0x0C, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20,
  0x80, 0x61, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x03, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0xC0, 0x81, 0xE0, 0xC0, 0xB0, 0x60, 0x98, 0x50, 0x44, 0x28,
  0x62, 0x34, 0x21, 0x12, 0x10, 0x89, 0x10, 0x48, 0xC8, 0x24, 0x6C, 0x14,
  0x14, 0x0A, 0x0A, 0x05, 0x07, 0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0x80,
  0x38, 0x03, 0x08, 0x06, 0x0C, 0x0C, 0x04, 0x18, 0x06, 0x30, 0x03, 0x60,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x04, 0x60, 0x08, 0x20,
  0x18, 0x30, 0x30, 0x10, 0x60, 0x08, 0xC0, 0x0C, 0x30, 0x00, 0xC4, 0x00,
  0x61, 0x80, 0x10, 0x20, 0x0C, 0x08, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x10, 0x20, 0x04, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00, 0x09, 0x80, 0x02,
  0x40, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFE, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x04,
  0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xF0, 0x07,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x1C, 0x00, 0x77,
  0x01, 0x41, 0x81, 0x80, 0xC2, 0x80, 0x7C,
};

const GFXglyph RobotoMono_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 7, 6, 18, 7, -23 },
  { 24, 18, 22, 18, 0, -22 },
  { 74, 15, 28, 18, 2, -25 },
  { 127, 15, 22, 18, 2, -22 },
  { 169, 16, 22, 18, 1, -22 },
  { 213, 2, 6, 18, 9, -23 },
  { 215, 10, 32, 18, 5, -25 },
  { 255, 9, 32, 18, 3, -25 },
  { 291, 13, 13, 18, 4, -22 },
  { 313, 15, 16, 18, 2, -18 },
  { 343, 3, 7, 18, 4, -3 },
  { 346, 11, 2, 18, 3, -11 },
  { 349, 2, 2, 18, 7, -2 },
  { 350, 15, 24, 18, 2, -22 },
  { 395, 15, 22, 18, 2, -22 },
  { 437, 8, 22, 18, 5, -22 },
  { 459, 14, 22, 18, 1, -22 },
  { 498, 15, 22, 18, 1, -22 },
  { 540, 15, 22, 18, 1, -22 },
  { 582, 15, 22, 18, 3, -22 },
  { 624, 13, 22, 18, 2, -22 },
  { 660, 14, 22, 18, 4, -22 },
  { 699, 15, 22, 18, 2, -22 },
  { 741, 13, 22, 18, 3, -22 },
  { 777, 4, 15, 18, 8, -15 },
  { 785, 6, 19, 18, 6, -15 },
  { 800, 14, 12, 18, 2, -16 },
  { 821, 14, 8, 18, 2, -14 },
  { 835, 14, 12, 18, 2, -16 },
  { 856, 11, 22, 18, 5, -22 },
  { 887, 17, 22, 18, 1, -22 },
  { 934, 15, 22, 18, 0, -22 },
  { 976, 16, 22, 18, 1, -22 },
  { 1020, 15, 22, 18, 2, -22 },
  { 1062, 16, 22, 18, 1, -22 },
  { 1106, 16, 22, 18, 2, -22 },
  { 1150, 16, 22, 18, 2, -22 },
  { 1194, 15, 22, 18, 2, -22 },
  { 1236, 17, 22, 18, 1, -22 },
  { 1283, 16, 22, 18, 1, -22 },
  { 1327, 16, 22, 18, 1, -22 },
  { 1371, 17, 22, 18, 2, -22 },
  { 1418, 12, 22, 18, 2, -22 },
  { 1451, 17, 22, 18, 1, -22 },
  { 1498, 17, 22, 18, 1, -22 },
  { 1545, 15, 22, 18, 2, -22 },
  { 1587, 16, 22, 18, 2, -22 },
  { 1631, 15, 26, 18, 2, -22 },
  { 1680, 15, 22, 18, 2, -22 },
  { 1722, 15, 22, 18, 2, -22 },
  { 1764, 15, 22, 18, 4, -22 },
  { 1806, 16, 22, 18, 2, -22 },
  { 1850, 16, 22, 18, 3, -22 },
  { 1894, 16, 22, 18, 3, -22 },
  { 1938, 19, 22, 18, 0, -22 },
  { 1991, 16, 22, 18, 3, -22 },
  { 2035, 16, 22, 18, 1, -22 },
  { 2079, 9, 30, 18, 5, -25 },
  { 2113, 6, 24, 18, 6, -22 },
  { 2131, 10, 30, 18, 4, -25 },
  { 2169, 11, 12, 18, 4, -22 },
  { 2186, 13, 1, 18, 1, 0 },
  { 2188, 4, 4, 18, 9, -23 },
  { 2190, 14, 17, 18, 2, -17 },
  { 2220, 14, 23, 18, 2, -23 },
  { 2261, 14, 17, 18, 2, -17 },
  { 2291, 15, 23, 18, 2, -23 },
  { 2335, 14, 17, 18, 2, -17 },
  { 2365, 15, 24, 18, 4, -24 },
  { 2410, 15, 24, 18, 1, -17 },
  { 2455, 15, 23, 18, 1, -23 },
  { 2499, 13, 22, 18, 2, -22 },
  { 2535, 14, 29, 18, 0, -22 },
  { 2586, 15, 23, 18, 2, -23 },
  { 2630, 13, 23, 18, 2, -23 },
  { 2668, 17, 17, 18, 0, -17 },
  { 2705, 15, 17, 18, 1, -17 },
  { 2737, 14, 17, 18, 2, -17 },
  { 2767, 16, 23, 18, 0, -17 },
  { 2813, 14, 23, 18, 2, -17 },
  { 2854, 13, 17, 18, 4, -17 },
  { 2882, 14, 17, 18, 2, -17 },
  { 2912, 12, 21, 18, 4, -21 },
  { 2944, 14, 16, 18, 2, -16 },
  { 2972, 15, 16, 18, 3, -16 },
  { 3002, 17, 16, 18, 2, -16 },
  { 3036, 16, 16, 18, 1, -16 },
  { 3068, 18, 23, 18, 0, -16 },
  { 3120, 15, 16, 18, 1, -16 },
  { 3150, 12, 30, 18, 5, -24 },
  { 3195, 6, 27, 18, 6, -22 },
  { 3216, 12, 30, 18, 3, -24 },
  { 3261, 16, 5, 18, 1, -12 },
};

const GFXfont RobotoMono_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC31PT7B_H_
