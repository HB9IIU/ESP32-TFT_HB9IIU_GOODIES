#ifndef _ROBOTOMONO_EXTRALIGHTITALIC61PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x78, 0x1F, 0x01, 0xC0,
  0x00, 0x30, 0x33, 0x03, 0x70, 0x77, 0x07, 0x70, 0x66, 0x06, 0x60, 0x66,
  0x06, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xC0, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x21, 0x80, 0x38, 0x03, 0x9C, 0x01, 0xC0, 0x18, 0xE0, 0x0E,
  0x01, 0x86, 0x00, 0x60, 0x1C, 0x30, 0x03, 0x01, 0xC1, 0x80, 0x18, 0x0C,
  0x0C, 0x00, 0xC0, 0xE0, 0x60, 0x0E, 0x0E, 0x03, 0x00, 0x60, 0x60, 0x1C,
  0x07, 0x06, 0x00, 0x60, 0x70, 0x70, 0x03, 0x8F, 0x03, 0x00, 0x0F, 0xF0,
  0x30, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x7E, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x60, 0xE0, 0xE0, 0x06,
  0x0E, 0x03, 0x00, 0x70, 0x60, 0x1C, 0x07, 0x07, 0x00, 0x60, 0x30, 0x30,
  0x03, 0x03, 0x81, 0x80, 0x18, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0xE0, 0x06,
  0x18, 0x06, 0x00, 0x71, 0xC0, 0x30, 0x03, 0x1C, 0x01, 0x80, 0x18, 0xC0,
  0x0C, 0x01, 0xC2, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x61, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C,
  0x0E, 0x00, 0x71, 0xE0, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x06, 0x38, 0x00,
  0xC0, 0x39, 0xC0, 0x03, 0x80, 0xE7, 0x00, 0x07, 0x03, 0x18, 0x00, 0x0C,
  0x1C, 0xE0, 0x00, 0x38, 0x63, 0x80, 0x00, 0x73, 0x8E, 0x00, 0x01, 0xDC,
  0x38, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xF8, 0x1C, 0x00, 0x07, 0x60, 0x38, 0x00, 0x79, 0xC0, 0x78,
  0x07, 0xC3, 0x80, 0xFF, 0xFC, 0x0E, 0x01, 0xFF, 0xC0, 0x1C, 0x00, 0x20,
  0x00, 0x00, 0x33, 0x77, 0x76, 0x66, 0xEC, 0xCC, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x38, 0x01, 0x70,
  0x0C, 0x03, 0xFF, 0x03, 0x07, 0xF3, 0xF8, 0xC7, 0xF0, 0x1F, 0xBF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x10, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18,
  0x38, 0x70, 0xE0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x7C, 0x70, 0x00, 0x0F, 0xE3, 0x00, 0x00, 0xE7, 0x38, 0x00,
  0x0E, 0x31, 0xC0, 0x00, 0xE1, 0x8E, 0x00, 0x0E, 0x0C, 0x60, 0x01, 0xE0,
  0x63, 0x00, 0x1C, 0x07, 0x18, 0x01, 0xC0, 0x39, 0xC0, 0x1C, 0x01, 0xCE,
  0x01, 0xC0, 0x0C, 0x70, 0x1C, 0x00, 0x63, 0x03, 0xC0, 0x07, 0x18, 0x38,
  0x00, 0x38, 0xC3, 0x80, 0x01, 0xCE, 0x38, 0x00, 0x0C, 0x73, 0x80, 0x00,
  0x63, 0xF8, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0x7F, 0x03, 0xF7, 0x0F, 0xC7, 0x3E, 0x06, 0x78, 0x06, 0x60, 0x06,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x06, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFE, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x04, 0x00, 0x18, 0x3F, 0xF0, 0x0E, 0x3F, 0xFF, 0x03,
  0x9E, 0x03, 0xE0, 0xCE, 0x00, 0x3C, 0x36, 0x00, 0x07, 0x1F, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x03, 0xC0, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x1B, 0x8F, 0x00, 0x1C,
  0xC1, 0xE0, 0x0E, 0x30, 0x3F, 0x3F, 0x1C, 0x07, 0xFF, 0x06, 0x00, 0x7F,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xC7, 0xC0, 0x7C, 0x03,
  0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x98, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x01, 0xC0, 0x18, 0x0E, 0x01, 0xFE, 0x03, 0x01, 0x80, 0x7D, 0xE0,
  0x60, 0x70, 0x1C, 0x0C, 0x0C, 0x0C, 0x06, 0x01, 0x81, 0x83, 0x01, 0x80,
  0x30, 0x30, 0x60, 0x70, 0x0C, 0x06, 0x1C, 0x0C, 0x01, 0x80, 0xC3, 0x03,
  0x80, 0x30, 0x18, 0xE0, 0x60, 0x06, 0x03, 0x18, 0x0C, 0x01, 0x80, 0x63,
  0x03, 0x00, 0x30, 0x0C, 0x60, 0x60, 0x06, 0x01, 0x98, 0x0C, 0x00, 0xC0,
  0x63, 0x03, 0x00, 0x30, 0x0C, 0x60, 0x60, 0x06, 0x01, 0x8C, 0x0C, 0x00,
  0xC0, 0x31, 0x81, 0x80, 0x38, 0x0C, 0x30, 0x30, 0x06, 0x01, 0x86, 0x06,
  0x01, 0xC0, 0x31, 0xC0, 0xC0, 0x78, 0x0C, 0x38, 0x18, 0x0F, 0x01, 0x83,
  0x03, 0x03, 0x60, 0x60, 0x60, 0x71, 0xCC, 0x18, 0x0C, 0x07, 0xF0, 0xFE,
  0x01, 0x80, 0xFC, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x7E, 0x00, 0x60, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0xF8, 0x03, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xC0, 0x00, 0xF8, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x1E, 0x06, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x07, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0xF8, 0x00, 0x60, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0xC0,
  0x03, 0xFF, 0xF1, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x06, 0x07, 0x80, 0x00, 0x01, 0x83,
  0xC0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x0E,
  0x7E, 0x00, 0x00, 0x03, 0x3D, 0xC0, 0x00, 0x00, 0xDE, 0x70, 0x00, 0x00,
  0x7E, 0x0E, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xEC, 0x00, 0x06, 0xE0,
  0x3B, 0x00, 0x03, 0xB0, 0x0E, 0xC0, 0x00, 0xCC, 0x03, 0x38, 0x00, 0x73,
  0x00, 0xCE, 0x00, 0x39, 0xC0, 0x31, 0x80, 0x0E, 0x70, 0x1C, 0x60, 0x07,
  0x18, 0x07, 0x18, 0x01, 0xC6, 0x01, 0xC6, 0x00, 0xE1, 0x80, 0x61, 0xC0,
  0x30, 0x60, 0x18, 0x70, 0x1C, 0x38, 0x06, 0x0C, 0x06, 0x0E, 0x03, 0x83,
  0x03, 0x83, 0x00, 0xE0, 0xC1, 0xC0, 0xC0, 0x38, 0x38, 0x70, 0x30, 0x0C,
  0x0E, 0x38, 0x1C, 0x03, 0x01, 0x8C, 0x07, 0x00, 0xC0, 0x67, 0x01, 0xC0,
  0x70, 0x19, 0x80, 0x60, 0x1C, 0x06, 0xE0, 0x18, 0x07, 0x01, 0xF0, 0x06,
  0x01, 0x80, 0x3C, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x30, 0x1F, 0x80,
  0x00, 0x18, 0x0E, 0xC0, 0x00, 0x1C, 0x06, 0x70, 0x00, 0x0E, 0x03, 0x18,
  0x00, 0x07, 0x01, 0x8C, 0x00, 0x03, 0x01, 0xC7, 0x00, 0x01, 0x80, 0xE1,
  0x80, 0x01, 0xC0, 0x70, 0xC0, 0x00, 0xE0, 0x30, 0x70, 0x00, 0x70, 0x18,
  0x18, 0x00, 0x38, 0x0C, 0x0E, 0x00, 0x18, 0x0E, 0x07, 0x00, 0x0C, 0x07,
  0x01, 0x80, 0x0E, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x30, 0x03, 0x80,
  0xC0, 0x18, 0x01, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x70, 0x03, 0x00, 0x60,
  0x38, 0x01, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0x30, 0x1C,
  0x06, 0x00, 0x1C, 0x0C, 0x03, 0x00, 0x0E, 0x06, 0x03, 0x80, 0x03, 0x03,
  0x01, 0xC0, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0x61, 0xC0, 0x60, 0x00, 0x30,
  0xE0, 0x30, 0x00, 0x1C, 0x60, 0x38, 0x00, 0x06, 0x30, 0x1C, 0x00, 0x03,
  0xB8, 0x0E, 0x00, 0x01, 0xDC, 0x06, 0x00, 0x00, 0x6E, 0x03, 0x00, 0x00,
  0x3F, 0x01, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x06, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x07, 0x80, 0x18, 0x00, 0x07, 0x80,
  0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3C, 0x01, 0x80, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x60, 0x03, 0x80, 0x06, 0x60, 0x03, 0xC0,
  0x06, 0x60, 0x03, 0xC0, 0x0E, 0x60, 0x07, 0xC0, 0x0E, 0x60, 0x07, 0xC0,
  0x0C, 0x60, 0x07, 0xC0, 0x0C, 0x60, 0x0F, 0xC0, 0x1C, 0x60, 0x0D, 0xC0,
  0x18, 0x60, 0x0C, 0xC0, 0x18, 0x60, 0x1C, 0xC0, 0x38, 0xE0, 0x18, 0xC0,
  0x30, 0xE0, 0x18, 0xC0, 0x30, 0xE0, 0x38, 0xC0, 0x70, 0xE0, 0x30, 0xC0,
  0x70, 0xE0, 0x30, 0xC0, 0x60, 0xE0, 0x70, 0xC0, 0x60, 0xE0, 0x60, 0xC0,
  0xE0, 0xE0, 0x60, 0xC0, 0xC0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0xC0, 0xC1,
  0xC0, 0xE0, 0xC0, 0xC1, 0x80, 0xE1, 0xC0, 0xC1, 0x80, 0xE1, 0x80, 0xC3,
  0x80, 0xE1, 0x80, 0xC3, 0x80, 0xE3, 0x80, 0xC3, 0x00, 0xE3, 0x00, 0xC3,
  0x00, 0xE3, 0x00, 0xC7, 0x00, 0xE7, 0x00, 0xC6, 0x00, 0xE6, 0x00, 0xC6,
  0x00, 0xEE, 0x00, 0xCE, 0x00, 0xEE, 0x00, 0xCC, 0x00, 0xEC, 0x00, 0xCC,
  0x00, 0xFC, 0x00, 0xDC, 0x00, 0xFC, 0x00, 0xDC, 0x00, 0xF8, 0x00, 0xD8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x60, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x19, 0xC0,
  0x01, 0xCE, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x0E, 0x0C, 0x00, 0x60,
  0x70, 0x07, 0x03, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x81,
  0xC0, 0x1C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00,
  0xE7, 0x00, 0x07, 0x30, 0x00, 0x1B, 0x80, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0x00,
  0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7E,
  0x00, 0x0C, 0x0F, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x86, 0x00, 0x00,
  0xF8, 0x70, 0x00, 0x3B, 0x87, 0x80, 0x07, 0x30, 0x3C, 0x03, 0xE3, 0x81,
  0xFF, 0xF8, 0x38, 0x07, 0xFE, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x00, 0x07,
  0x0F, 0xFE, 0x00, 0x71, 0xFF, 0xF0, 0x07, 0x78, 0x07, 0x80, 0x6E, 0x00,
  0x3C, 0x07, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x07, 0xC0, 0x01,
  0xE0, 0x6E, 0x00, 0x3C, 0x0E, 0x78, 0x0F, 0x80, 0xE3, 0xFF, 0xE0, 0x0E,
  0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x03, 0x80, 0x3C, 0x00, 0x38,
  0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x03, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0x01, 0xC0, 0x03, 0xFF, 0x87, 0x00, 0x3F,
  0xFF, 0x1C, 0x01, 0xE0, 0x0E, 0x60, 0x0F, 0x00, 0x1D, 0x80, 0x78, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x60, 0x07, 0x80, 0x7B, 0x80, 0x0F,
  0xFF, 0x8E, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x03, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x70, 0x03, 0xFF, 0xF1, 0xC0, 0x1E, 0x00, 0xE6,
  0x00, 0xF0, 0x01, 0xD8, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x76, 0x00, 0x78, 0x07, 0xB8, 0x00, 0xFF, 0xF8, 0xE0, 0x00, 0xFF, 0xC3,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x10,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x0F, 0xC0, 0x07, 0x07, 0xFF, 0x00, 0x60, 0xFF, 0xF8, 0x06, 0x3C,
  0x03, 0xC0, 0x67, 0x00, 0x1E, 0x06, 0xE0, 0x00, 0xE0, 0xFC, 0x00, 0x06,
  0x0F, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x40, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07,
  0x80, 0x07, 0x00, 0x78, 0x00, 0x30, 0x0F, 0x00, 0x01, 0x80, 0xF0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x01, 0x9F, 0x80, 0x00, 0x0D, 0xFC, 0x00, 0x00, 0xFC, 0x70,
  0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x38, 0x03, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x63, 0xFC, 0x1F, 0xF0, 0x0D, 0xFF, 0xC7, 0xFF, 0x01, 0xF0, 0x1D,
  0xC0, 0x70, 0x7C, 0x03, 0xF0, 0x0E, 0x0F, 0x00, 0x3C, 0x00, 0xC1, 0xC0,
  0x07, 0x00, 0x18, 0x38, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x61,
  0xC0, 0x07, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00,
  0x70, 0xC0, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x00, 0x30, 0xE0, 0x03, 0x80, 0x06, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x00, 0x38, 0x60, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x00, 0x18, 0x70, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x00,
  0xE1, 0x80, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x00, 0x70, 0xC0, 0x03, 0x00, 0x0E, 0x18, 0x00, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x70, 0x7F, 0xF0, 0x06, 0x0F, 0xFF, 0x80, 0x63, 0xC0, 0x3C, 0x06,
  0x70, 0x01, 0xE0, 0xEE, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x60, 0xF8, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0x0F, 0xFE, 0x00, 0x1C, 0xFF, 0xFC, 0x00, 0x67, 0x80, 0x78,
  0x01, 0xB8, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x07, 0x00, 0x6E, 0x00,
  0x3C, 0x03, 0x9C, 0x03, 0xE0, 0x0E, 0x3F, 0xFE, 0x00, 0x38, 0x7F, 0xE0,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0x87, 0x00, 0xFF, 0xFC, 0x70, 0x1E, 0x00, 0xE6,
  0x03, 0xC0, 0x07, 0x60, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0x60, 0x1E, 0x01, 0xEE, 0x00, 0xFF,
  0xF8, 0xE0, 0x03, 0xFF, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0x41, 0xC0, 0xFF, 0xE0, 0x60, 0xFF, 0xF8, 0x18, 0x7C,
  0x00, 0x06, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF8,
  0x38, 0x00, 0x3E, 0x07, 0x00, 0x1E, 0xC0, 0x78, 0x0F, 0x18, 0x07, 0xFF,
  0xC7, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0xA0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x60, 0x01, 0xC0,
  0x07, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x07, 0xC0,
  0x0E, 0x60, 0x06, 0xC0, 0x0C, 0x60, 0x06, 0xC0, 0x1C, 0x60, 0x0C, 0xC0,
  0x18, 0x60, 0x0C, 0xC0, 0x18, 0x60, 0x1C, 0xC0, 0x38, 0x60, 0x18, 0xC0,
  0x30, 0x60, 0x18, 0xC0, 0x70, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x30, 0xC0,
  0x60, 0x60, 0x70, 0xC0, 0xE0, 0x70, 0x60, 0xE0, 0xC0, 0x70, 0xE0, 0xE0,
  0xC0, 0x70, 0xC0, 0x61, 0xC0, 0x70, 0xC0, 0x61, 0x80, 0x71, 0x80, 0x63,
  0x80, 0x71, 0x80, 0x63, 0x00, 0x33, 0x80, 0x63, 0x00, 0x33, 0x00, 0x67,
  0x00, 0x33, 0x00, 0x66, 0x00, 0x36, 0x00, 0x66, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0x3C, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x23, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xC7, 0x87, 0xC0, 0x00, 0xE3, 0x80, 0xF0, 0x00, 0x63, 0x80, 0x1C, 0x00,
  0x33, 0x80, 0x07, 0x00, 0x39, 0x80, 0x01, 0xC0, 0x38, 0xC0, 0x00, 0x7C,
  0x78, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 11, 43, 36, 12, -43 },
  { 61, 12, 13, 36, 15, -46 },
  { 81, 35, 43, 36, 1, -43 },
  { 270, 29, 56, 36, 4, -50 },
  { 473, 29, 45, 36, 4, -44 },
  { 637, 30, 45, 36, 3, -44 },
  { 806, 4, 13, 36, 18, -46 },
  { 813, 19, 62, 36, 10, -48 },
  { 961, 18, 62, 36, 6, -48 },
  { 1101, 26, 25, 36, 8, -43 },
  { 1183, 29, 32, 36, 4, -36 },
  { 1299, 8, 13, 36, 7, -5 },
  { 1312, 21, 3, 36, 7, -21 },
  { 1320, 4, 5, 36, 14, -5 },
  { 1323, 28, 47, 36, 5, -43 },
  { 1488, 29, 45, 36, 4, -44 },
  { 1652, 16, 43, 36, 9, -43 },
  { 1738, 29, 44, 36, 1, -44 },
  { 1898, 29, 45, 36, 2, -44 },
  { 2062, 30, 43, 36, 1, -43 },
  { 2224, 30, 44, 36, 5, -43 },
  { 2389, 26, 45, 36, 4, -44 },
  { 2536, 28, 43, 36, 7, -43 },
  { 2687, 30, 45, 36, 4, -44 },
  { 2856, 26, 44, 36, 6, -44 },
  { 2999, 10, 31, 36, 15, -31 },
  { 3038, 13, 39, 36, 12, -31 },
  { 3102, 27, 25, 36, 5, -32 },
  { 3187, 28, 15, 36, 4, -27 },
  { 3240, 27, 25, 36, 4, -32 },
  { 3325, 23, 44, 36, 9, -44 },
  { 3452, 35, 44, 36, 1, -44 },
  { 3645, 30, 43, 36, 0, -43 },
  { 3807, 30, 43, 36, 3, -43 },
  { 3969, 30, 45, 36, 4, -44 },
  { 4138, 32, 43, 36, 2, -43 },
  { 4310, 32, 43, 36, 3, -43 },
  { 4482, 32, 43, 36, 3, -43 },
  { 4654, 31, 45, 36, 3, -44 },
  { 4829, 33, 43, 36, 2, -43 },
  { 5007, 31, 43, 36, 3, -43 },
  { 5174, 32, 44, 36, 2, -43 },
  { 5350, 34, 43, 36, 3, -43 },
  { 5533, 24, 43, 36, 4, -43 },
  { 5662, 34, 43, 36, 2, -43 },
  { 5845, 33, 43, 36, 2, -43 },
  { 6023, 29, 45, 36, 4, -44 },
  { 6187, 31, 43, 36, 4, -43 },
  { 6354, 31, 52, 36, 3, -44 },
  { 6556, 31, 43, 36, 3, -43 },
  { 6723, 31, 45, 36, 3, -44 },
  { 6898, 30, 43, 36, 7, -43 },
  { 7060, 31, 44, 36, 4, -43 },
  { 7231, 30, 43, 36, 7, -43 },
  { 7393, 32, 43, 36, 6, -43 },
  { 7565, 36, 43, 36, 1, -43 },
  { 7759, 30, 43, 36, 7, -43 },
  { 7921, 33, 43, 36, 1, -43 },
  { 8099, 19, 59, 36, 9, -50 },
  { 8240, 12, 47, 36, 12, -43 },
  { 8311, 18, 59, 36, 9, -50 },
  { 8444, 21, 23, 36, 8, -43 },
  { 8505, 25, 2, 36, 2, 0 },
  { 8512, 7, 8, 36, 18, -45 },
  { 8519, 28, 34, 36, 3, -33 },
  { 8638, 28, 47, 36, 3, -46 },
  { 8803, 27, 34, 36, 4, -33 },
  { 8918, 30, 47, 36, 4, -46 },
  { 9095, 27, 34, 36, 4, -33 },
  { 9210, 29, 47, 36, 8, -47 },
  { 9381, 30, 46, 36, 2, -33 },
  { 9554, 28, 46, 36, 3, -46 },
  { 9715, 25, 44, 36, 4, -44 },
  { 9853, 28, 57, 36, 0, -44 },
  { 10053, 29, 46, 36, 4, -46 },
  { 10220, 25, 46, 36, 4, -46 },
  { 10364, 35, 33, 36, -1, -33 },
  { 10509, 28, 33, 36, 3, -33 },
  { 10625, 29, 34, 36, 3, -33 },
  { 10749, 30, 45, 36, 1, -33 },
  { 10918, 28, 45, 36, 4, -33 },
  { 11076, 26, 33, 36, 8, -33 },
  { 11184, 28, 34, 36, 4, -33 },
  { 11303, 24, 42, 36, 7, -41 },
  { 11429, 27, 33, 36, 5, -32 },
  { 11541, 29, 32, 36, 5, -32 },
  { 11657, 32, 32, 36, 4, -32 },
  { 11785, 33, 32, 36, 1, -32 },
  { 11917, 37, 45, 36, -1, -32 },
  { 12126, 31, 32, 36, 1, -32 },
  { 12250, 24, 61, 36, 9, -48 },
  { 12433, 11, 52, 36, 12, -43 },
  { 12505, 24, 61, 36, 5, -48 },
  { 12688, 33, 10, 36, 1, -23 },
};

const GFXfont RobotoMono_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC61PT7B_H_
