#ifndef _ROBOTOMONO_EXTRALIGHTITALIC24PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x64, 0x44, 0x00, 0x08, 0xC0, 0xCC, 0xA5,
  0x29, 0x00, 0x01, 0x88, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10, 0xFF,
  0xF0, 0x42, 0x01, 0x08, 0x04, 0x40, 0x21, 0x00, 0x84, 0x3F, 0xFC, 0x10,
  0x80, 0x42, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x01, 0x00, 0x20, 0x04,
  0x07, 0xC1, 0x04, 0x40, 0x48, 0x09, 0x01, 0x20, 0x04, 0x00, 0x60, 0x07,
  0x00, 0x18, 0x01, 0x00, 0x14, 0x02, 0x80, 0x50, 0x11, 0x06, 0x1F, 0x00,
  0x80, 0x10, 0x00, 0x3C, 0x04, 0x40, 0x44, 0x24, 0x44, 0x84, 0x44, 0x48,
  0x49, 0x03, 0x20, 0x02, 0x00, 0x44, 0x09, 0xB0, 0x91, 0x12, 0x12, 0x21,
  0x42, 0x10, 0x22, 0x01, 0xC0, 0x07, 0x80, 0x84, 0x10, 0x41, 0x04, 0x10,
  0x81, 0x10, 0x0A, 0x00, 0xC0, 0x1C, 0x02, 0x61, 0x42, 0x14, 0x12, 0x81,
  0x28, 0x0C, 0x80, 0xC4, 0x1C, 0x3E, 0x20, 0x5A, 0x80, 0x02, 0x08, 0x20,
  0x41, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x04, 0x01, 0x00, 0x43,
  0x11, 0x37, 0x83, 0x01, 0x40, 0xC8, 0x61, 0x10, 0x40, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x29, 0x28, 0xFF, 0x70, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00, 0x0F, 0x82, 0x08, 0x81,
  0x30, 0x14, 0x06, 0x81, 0xE0, 0x4C, 0x11, 0x84, 0x53, 0x0A, 0xC1, 0x60,
  0x28, 0x0D, 0x01, 0x20, 0x62, 0x18, 0x7E, 0x00, 0x0C, 0xDC, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x07, 0xC0, 0x82,
  0x10, 0x12, 0x01, 0x20, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xE0, 0x0F,
  0xC2, 0x0C, 0x80, 0x90, 0x14, 0x02, 0x00, 0x40, 0x10, 0x0C, 0x0F, 0x00,
  0x10, 0x01, 0x00, 0x28, 0x05, 0x00, 0xA0, 0x22, 0x0C, 0x3E, 0x00, 0x00,
  0x60, 0x18, 0x07, 0x00, 0xA0, 0x24, 0x08, 0x82, 0x10, 0x84, 0x30, 0x84,
  0x11, 0x02, 0x40, 0x4F, 0xFE, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x1F,
  0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x2E, 0x07, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x08, 0x80, 0x84, 0x10, 0x3E,
  0x00, 0x01, 0xC0, 0xC0, 0x20, 0x08, 0x03, 0x00, 0x40, 0x0B, 0xE2, 0x82,
  0x60, 0x48, 0x05, 0x00, 0xE0, 0x14, 0x04, 0x80, 0x90, 0x31, 0x0C, 0x1F,
  0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x83, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x10, 0x20,
  0x8C, 0x0F, 0x83, 0x04, 0x60, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x46,
  0x0C, 0x3F, 0x00, 0x0F, 0x86, 0x18, 0x81, 0x20, 0x34, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0x40, 0x48, 0x18, 0xFD, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x78, 0x00, 0x23, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x10, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x84, 0x42, 0x00, 0x00, 0x20, 0x18, 0x0C, 0x0E,
  0x06, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x00, 0x3E, 0x20, 0xA0, 0x50,
  0x10, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x08, 0x0C, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x42, 0x14, 0x64,
  0xA4, 0x26, 0x22, 0x32, 0x11, 0x90, 0x8C, 0x84, 0xA4, 0x45, 0x26, 0x29,
  0x72, 0x44, 0x42, 0x00, 0x08, 0x10, 0x3F, 0x00, 0x00, 0x80, 0x0C, 0x01,
  0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0x20, 0x82, 0x10,
  0x21, 0xFE, 0x20, 0x22, 0x02, 0x40, 0x24, 0x01, 0x80, 0x10, 0x1F, 0xC1,
  0x02, 0x10, 0x12, 0x01, 0x20, 0x12, 0x03, 0x20, 0x22, 0x0C, 0x3F, 0x84,
  0x04, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x48, 0x08, 0xFF, 0x00,
  0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x40, 0x24, 0x04, 0x40, 0x42, 0x08,
  0x3F, 0x00, 0x1F, 0x81, 0x06, 0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x80,
  0x88, 0x30, 0xFC, 0x00, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xC1, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x00,
  0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x3F, 0x80, 0x28, 0x02, 0x80, 0x24, 0x02, 0x40, 0x22, 0x04,
  0x1F, 0x80, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09,
  0x00, 0x48, 0x02, 0x7F, 0xE2, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x40, 0x1F, 0xF0, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x10, 0x0C,
  0x40, 0x41, 0x02, 0x04, 0x10, 0x20, 0x80, 0x84, 0x02, 0x20, 0x0B, 0x00,
  0x3C, 0x00, 0xC8, 0x06, 0x20, 0x10, 0x40, 0x41, 0x81, 0x02, 0x04, 0x04,
  0x20, 0x10, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xFF, 0xC0, 0x10, 0x19, 0x80, 0xCA, 0x0A, 0x50, 0x62, 0x85, 0x14, 0x68,
  0xA2, 0x48, 0xA2, 0x45, 0x12, 0x31, 0x11, 0x88, 0x88, 0x44, 0x02, 0x40,
  0x12, 0x01, 0x10, 0x08, 0x80, 0x40, 0x10, 0x09, 0x80, 0x4A, 0x04, 0x50,
  0x22, 0x81, 0x12, 0x08, 0x90, 0x48, 0x86, 0x42, 0x22, 0x11, 0x10, 0x48,
  0x82, 0x44, 0x12, 0x40, 0x62, 0x03, 0x10, 0x18, 0x80, 0x40, 0x07, 0xC0,
  0x82, 0x10, 0x32, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x40, 0xC2, 0x18, 0x3F, 0x00,
  0x1F, 0xE0, 0x81, 0x84, 0x04, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44,
  0x06, 0x20, 0x61, 0xFC, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x2C,
  0x04, 0x40, 0x46, 0x18, 0x3F, 0x00, 0x10, 0x00, 0x80, 0x04, 0x1F, 0xC1,
  0x02, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x32, 0x02, 0x20, 0xC3,
  0xF0, 0x41, 0x04, 0x08, 0x40, 0x84, 0x08, 0x40, 0x48, 0x04, 0x80, 0x60,
  0x07, 0xC1, 0x82, 0x10, 0x12, 0x01, 0x20, 0x12, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x28, 0x02, 0x40, 0x66, 0x0C,
  0x3F, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x00, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x20, 0x21, 0x03, 0x0C, 0x30, 0x3F, 0x00, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x28, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x10, 0x22,
  0x02, 0x80, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x42, 0x0A, 0x10, 0x51,
  0x84, 0x8C, 0x24, 0x61, 0x25, 0x11, 0x28, 0x91, 0x24, 0x91, 0x44, 0x8A,
  0x24, 0x51, 0x43, 0x0A, 0x18, 0x50, 0xC3, 0x06, 0x18, 0x20, 0xC1, 0x00,
  0x10, 0x04, 0x20, 0x20, 0x81, 0x81, 0x04, 0x04, 0x20, 0x09, 0x00, 0x28,
  0x00, 0x60, 0x01, 0x00, 0x0E, 0x00, 0x48, 0x03, 0x20, 0x08, 0x40, 0x41,
  0x02, 0x02, 0x18, 0x08, 0xC0, 0x10, 0x80, 0x30, 0x09, 0x01, 0x20, 0x44,
  0x10, 0x42, 0x08, 0x81, 0x20, 0x14, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE0, 0x1E, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x70, 0x88, 0x88, 0x44, 0x44, 0x42,
  0x22, 0x22, 0x11, 0x11, 0x0F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0xF0, 0x04, 0x0A, 0x0A, 0x12, 0x12, 0x22, 0x21, 0x41,
  0x81, 0xFF, 0xC0, 0x89, 0x80, 0x07, 0x83, 0x08, 0x80, 0x90, 0x10, 0x02,
  0x00, 0x47, 0xFB, 0x02, 0x40, 0x50, 0x0A, 0x03, 0x20, 0xA7, 0xE4, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x4F, 0x0A, 0x11, 0x81, 0x20, 0x24,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xD0, 0x12, 0x06, 0xA1, 0x93, 0xE0,
  0x0F, 0x0C, 0x26, 0x05, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x28, 0x09, 0x04, 0x3E, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x1C, 0x8C, 0x73, 0x06, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x24, 0x0C, 0xC2, 0x8F, 0xA0, 0x07, 0x83, 0x08, 0xC0, 0x90, 0x14,
  0x02, 0x80, 0x5F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x61, 0xF0,
  0x03, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFC, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x07, 0x11, 0x8E, 0x30, 0x62, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC6, 0x1C, 0x3E, 0x80, 0x08,
  0x00, 0x88, 0x10, 0xC3, 0x03, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x47, 0x0B, 0x19, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x02,
  0x80, 0x90, 0x12, 0x02, 0x80, 0x50, 0x08, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x1F, 0x08, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x41, 0xF0, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x03, 0x20, 0x62, 0x08,
  0x21, 0x02, 0x60, 0x2C, 0x03, 0x40, 0x66, 0x04, 0x20, 0x41, 0x04, 0x18,
  0x40, 0x8C, 0x04, 0x1F, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x3F, 0xF0, 0x2E, 0x78, 0xC6, 0x22, 0x10, 0x90, 0x42, 0x41, 0x09, 0x04,
  0x24, 0x20, 0x90, 0x82, 0x42, 0x0A, 0x08, 0x48, 0x21, 0x20, 0x84, 0x84,
  0x10, 0x23, 0x85, 0x88, 0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01,
  0x40, 0x48, 0x09, 0x01, 0x40, 0x28, 0x04, 0x07, 0x83, 0x08, 0x80, 0xB0,
  0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x09, 0x01, 0x30, 0xC3,
  0xF0, 0x13, 0xC1, 0x42, 0x18, 0x31, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x22, 0x02, 0x20, 0x65, 0x0C, 0x4F, 0x84, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x0F, 0x26, 0x19, 0x83, 0x20, 0x28, 0x05, 0x00,
  0xA0, 0x24, 0x04, 0x80, 0x90, 0x12, 0x06, 0x61, 0xC7, 0xD0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x23, 0xCB, 0x03, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x0C,
  0x34, 0x05, 0x01, 0x40, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x80, 0x18, 0x0B,
  0x06, 0x7F, 0x00, 0x08, 0x04, 0x02, 0x1F, 0xF1, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x3C, 0x40, 0x28, 0x09,
  0x01, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x12, 0x06,
  0x61, 0x47, 0xC8, 0x80, 0x3C, 0x02, 0x40, 0x44, 0x04, 0x40, 0x86, 0x08,
  0x21, 0x02, 0x20, 0x22, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x00, 0x84,
  0x18, 0x61, 0x86, 0x18, 0xA2, 0x8A, 0x29, 0x24, 0x92, 0x49, 0x24, 0xA2,
  0x8A, 0x28, 0xC3, 0x0C, 0x30, 0x83, 0x00, 0x10, 0x08, 0xC0, 0x82, 0x08,
  0x08, 0x80, 0x4C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x44, 0x04,
  0x10, 0x40, 0xCC, 0x03, 0x00, 0x20, 0x04, 0x80, 0x23, 0x00, 0x84, 0x04,
  0x10, 0x20, 0x40, 0x80, 0x84, 0x02, 0x10, 0x08, 0x80, 0x34, 0x00, 0x50,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x03, 0x80,
  0x00, 0x3F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xE0, 0x00, 0x81, 0x81,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x0C, 0x0C, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x18,
  0x11, 0x12, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x80, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x30, 0x18, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x81, 0x80, 0x3C, 0x0A, 0x10, 0x50, 0x47, 0x01, 0xC0,
};

const GFXglyph RobotoMono_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 5, 5, 14, 6, -18 },
  { 14, 14, 17, 14, 0, -17 },
  { 44, 11, 22, 14, 2, -20 },
  { 75, 12, 17, 14, 1, -17 },
  { 101, 12, 17, 14, 1, -17 },
  { 127, 2, 5, 14, 7, -18 },
  { 129, 7, 25, 14, 4, -19 },
  { 151, 8, 25, 14, 2, -19 },
  { 176, 10, 10, 14, 3, -17 },
  { 189, 12, 12, 14, 1, -14 },
  { 207, 3, 5, 14, 3, -2 },
  { 209, 8, 1, 14, 3, -8 },
  { 210, 2, 2, 14, 5, -2 },
  { 211, 11, 18, 14, 2, -17 },
  { 236, 11, 17, 14, 2, -17 },
  { 260, 6, 17, 14, 4, -17 },
  { 273, 12, 17, 14, 0, -17 },
  { 299, 11, 17, 14, 1, -17 },
  { 323, 11, 17, 14, 1, -17 },
  { 347, 12, 17, 14, 2, -17 },
  { 373, 11, 17, 14, 1, -17 },
  { 397, 11, 17, 14, 3, -17 },
  { 421, 12, 17, 14, 1, -17 },
  { 447, 11, 17, 14, 2, -17 },
  { 471, 4, 12, 14, 6, -12 },
  { 477, 5, 15, 14, 5, -12 },
  { 487, 11, 10, 14, 2, -13 },
  { 501, 11, 6, 14, 2, -11 },
  { 510, 11, 10, 14, 1, -13 },
  { 524, 9, 17, 14, 4, -17 },
  { 544, 13, 17, 14, 1, -17 },
  { 572, 12, 17, 14, 0, -17 },
  { 598, 12, 17, 14, 1, -17 },
  { 624, 12, 17, 14, 1, -17 },
  { 650, 12, 17, 14, 1, -17 },
  { 676, 13, 17, 14, 1, -17 },
  { 704, 13, 17, 14, 1, -17 },
  { 732, 12, 17, 14, 1, -17 },
  { 758, 13, 17, 14, 1, -17 },
  { 786, 12, 17, 14, 1, -17 },
  { 812, 12, 17, 14, 1, -17 },
  { 838, 14, 17, 14, 1, -17 },
  { 868, 10, 17, 14, 1, -17 },
  { 890, 13, 17, 14, 1, -17 },
  { 918, 13, 17, 14, 1, -17 },
  { 946, 12, 17, 14, 1, -17 },
  { 972, 13, 17, 14, 1, -17 },
  { 1000, 12, 20, 14, 1, -17 },
  { 1030, 12, 17, 14, 1, -17 },
  { 1056, 12, 17, 14, 1, -17 },
  { 1082, 12, 17, 14, 3, -17 },
  { 1108, 13, 17, 14, 1, -17 },
  { 1136, 11, 17, 14, 3, -17 },
  { 1160, 13, 17, 14, 2, -17 },
  { 1188, 14, 17, 14, 0, -17 },
  { 1218, 11, 17, 14, 3, -17 },
  { 1242, 13, 17, 14, 0, -17 },
  { 1270, 7, 24, 14, 4, -20 },
  { 1291, 4, 18, 14, 5, -17 },
  { 1300, 8, 24, 14, 3, -20 },
  { 1324, 8, 9, 14, 3, -17 },
  { 1333, 10, 1, 14, 1, 0 },
  { 1335, 3, 3, 14, 7, -18 },
  { 1337, 11, 13, 14, 1, -13 },
  { 1355, 11, 18, 14, 1, -18 },
  { 1380, 10, 13, 14, 2, -13 },
  { 1397, 11, 18, 14, 2, -18 },
  { 1422, 11, 13, 14, 1, -13 },
  { 1440, 12, 18, 14, 3, -18 },
  { 1467, 12, 18, 14, 1, -13 },
  { 1494, 11, 18, 14, 1, -18 },
  { 1519, 10, 17, 14, 1, -17 },
  { 1541, 11, 22, 14, 0, -17 },
  { 1572, 12, 18, 14, 1, -18 },
  { 1599, 10, 18, 14, 1, -18 },
  { 1622, 14, 13, 14, 0, -13 },
  { 1645, 11, 13, 14, 1, -13 },
  { 1663, 11, 13, 14, 1, -13 },
  { 1681, 12, 18, 14, 0, -13 },
  { 1708, 11, 18, 14, 2, -13 },
  { 1733, 10, 13, 14, 3, -13 },
  { 1750, 10, 13, 14, 2, -13 },
  { 1767, 9, 16, 14, 3, -16 },
  { 1785, 11, 13, 14, 2, -13 },
  { 1803, 12, 13, 14, 2, -13 },
  { 1823, 12, 13, 14, 2, -13 },
  { 1843, 13, 13, 14, 0, -13 },
  { 1865, 14, 18, 14, 0, -13 },
  { 1897, 12, 13, 14, 1, -13 },
  { 1917, 9, 24, 14, 4, -19 },
  { 1944, 4, 21, 14, 5, -17 },
  { 1955, 9, 24, 14, 2, -19 },
  { 1982, 13, 4, 14, 0, -9 },
};

const GFXfont RobotoMono_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC24PT7B_H_
