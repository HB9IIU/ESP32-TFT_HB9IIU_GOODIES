#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoMono_ExtraLightItalic
// Headers: 67

#include "RobotoMono_ExtraLightItalic6pt7b.h"
#include "RobotoMono_ExtraLightItalic7pt7b.h"
#include "RobotoMono_ExtraLightItalic8pt7b.h"
#include "RobotoMono_ExtraLightItalic9pt7b.h"
#include "RobotoMono_ExtraLightItalic10pt7b.h"
#include "RobotoMono_ExtraLightItalic11pt7b.h"
#include "RobotoMono_ExtraLightItalic12pt7b.h"
#include "RobotoMono_ExtraLightItalic13pt7b.h"
#include "RobotoMono_ExtraLightItalic14pt7b.h"
#include "RobotoMono_ExtraLightItalic15pt7b.h"
#include "RobotoMono_ExtraLightItalic16pt7b.h"
#include "RobotoMono_ExtraLightItalic17pt7b.h"
#include "RobotoMono_ExtraLightItalic18pt7b.h"
#include "RobotoMono_ExtraLightItalic19pt7b.h"
#include "RobotoMono_ExtraLightItalic20pt7b.h"
#include "RobotoMono_ExtraLightItalic21pt7b.h"
#include "RobotoMono_ExtraLightItalic22pt7b.h"
#include "RobotoMono_ExtraLightItalic23pt7b.h"
#include "RobotoMono_ExtraLightItalic24pt7b.h"
#include "RobotoMono_ExtraLightItalic25pt7b.h"
#include "RobotoMono_ExtraLightItalic26pt7b.h"
#include "RobotoMono_ExtraLightItalic27pt7b.h"
#include "RobotoMono_ExtraLightItalic28pt7b.h"
#include "RobotoMono_ExtraLightItalic29pt7b.h"
#include "RobotoMono_ExtraLightItalic30pt7b.h"
#include "RobotoMono_ExtraLightItalic31pt7b.h"
#include "RobotoMono_ExtraLightItalic32pt7b.h"
#include "RobotoMono_ExtraLightItalic33pt7b.h"
#include "RobotoMono_ExtraLightItalic34pt7b.h"
#include "RobotoMono_ExtraLightItalic35pt7b.h"
#include "RobotoMono_ExtraLightItalic36pt7b.h"
#include "RobotoMono_ExtraLightItalic37pt7b.h"
#include "RobotoMono_ExtraLightItalic38pt7b.h"
#include "RobotoMono_ExtraLightItalic39pt7b.h"
#include "RobotoMono_ExtraLightItalic40pt7b.h"
#include "RobotoMono_ExtraLightItalic41pt7b.h"
#include "RobotoMono_ExtraLightItalic42pt7b.h"
#include "RobotoMono_ExtraLightItalic43pt7b.h"
#include "RobotoMono_ExtraLightItalic44pt7b.h"
#include "RobotoMono_ExtraLightItalic45pt7b.h"
#include "RobotoMono_ExtraLightItalic46pt7b.h"
#include "RobotoMono_ExtraLightItalic47pt7b.h"
#include "RobotoMono_ExtraLightItalic48pt7b.h"
#include "RobotoMono_ExtraLightItalic49pt7b.h"
#include "RobotoMono_ExtraLightItalic50pt7b.h"
#include "RobotoMono_ExtraLightItalic51pt7b.h"
#include "RobotoMono_ExtraLightItalic52pt7b.h"
#include "RobotoMono_ExtraLightItalic53pt7b.h"
#include "RobotoMono_ExtraLightItalic54pt7b.h"
#include "RobotoMono_ExtraLightItalic55pt7b.h"
#include "RobotoMono_ExtraLightItalic56pt7b.h"
#include "RobotoMono_ExtraLightItalic57pt7b.h"
#include "RobotoMono_ExtraLightItalic58pt7b.h"
#include "RobotoMono_ExtraLightItalic59pt7b.h"
#include "RobotoMono_ExtraLightItalic60pt7b.h"
#include "RobotoMono_ExtraLightItalic61pt7b.h"
#include "RobotoMono_ExtraLightItalic62pt7b.h"
#include "RobotoMono_ExtraLightItalic63pt7b.h"
#include "RobotoMono_ExtraLightItalic64pt7b.h"
#include "RobotoMono_ExtraLightItalic65pt7b.h"
#include "RobotoMono_ExtraLightItalic66pt7b.h"
#include "RobotoMono_ExtraLightItalic67pt7b.h"
#include "RobotoMono_ExtraLightItalic68pt7b.h"
#include "RobotoMono_ExtraLightItalic69pt7b.h"
#include "RobotoMono_ExtraLightItalic70pt7b.h"
#include "RobotoMono_ExtraLightItalic71pt7b.h"
#include "RobotoMono_ExtraLightItalic72pt7b.h"
