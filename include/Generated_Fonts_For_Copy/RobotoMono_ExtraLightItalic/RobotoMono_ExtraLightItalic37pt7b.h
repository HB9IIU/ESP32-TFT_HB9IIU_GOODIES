#ifndef _ROBOTOMONO_EXTRALIGHTITALIC37PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x82,
  0x08, 0x61, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x63, 0x42, 0x42,
  0x42, 0xC6, 0xC6, 0x84, 0x84, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01,
  0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00, 0x06, 0x04,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00,
  0x20, 0x40, 0x01, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x80, 0x02, 0x06, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x01, 0x02, 0x00,
  0x0C, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10,
  0x30, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x60, 0x18, 0x30, 0x03, 0x0C,
  0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x60, 0xC0, 0x38, 0x18, 0x38, 0x03, 0xFC,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x03, 0x18, 0x01, 0x82, 0x00, 0x40, 0x81, 0x90, 0x20, 0xCC,
  0x08, 0x23, 0x02, 0x10, 0xC1, 0x8C, 0x30, 0x46, 0x06, 0x31, 0x00, 0xF8,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x0C, 0x01, 0x1F,
  0x80, 0x8C, 0x30, 0x62, 0x04, 0x30, 0x81, 0x08, 0x60, 0x46, 0x10, 0x33,
  0x04, 0x0C, 0x81, 0x02, 0x00, 0x61, 0x80, 0x08, 0xC0, 0x03, 0xE0, 0x00,
  0x20, 0x00, 0x7F, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x06, 0x06, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x30, 0x30, 0x04, 0x18, 0x01, 0x0C, 0x00, 0x66, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xD8, 0x00, 0x63, 0x03, 0x30,
  0x40, 0xD8, 0x18, 0x24, 0x03, 0x0B, 0x00, 0xC6, 0xC0, 0x1B, 0x20, 0x02,
  0xCC, 0x00, 0xE3, 0x00, 0x38, 0x60, 0x1A, 0x1C, 0x1C, 0xC1, 0xFC, 0x18,
  0x57, 0xEA, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x81, 0x81, 0xE1, 0x8F, 0x3D, 0x7C, 0x07, 0xE0, 0x03, 0x80,
  0x06, 0x80, 0x0C, 0xC0, 0x18, 0x60, 0x30, 0x60, 0x60, 0x30, 0x40, 0x10,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x18, 0xC4, 0x63, 0x11, 0x98,
  0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x01, 0x81,
  0x81, 0x80, 0x61, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x06, 0x40, 0x03, 0x60,
  0x03, 0xB0, 0x03, 0xD0, 0x06, 0x68, 0x06, 0x34, 0x06, 0x16, 0x06, 0x0B,
  0x06, 0x05, 0x8C, 0x06, 0x8C, 0x03, 0x4C, 0x01, 0xAC, 0x00, 0x9C, 0x00,
  0xC8, 0x00, 0x64, 0x00, 0x23, 0x00, 0x31, 0x80, 0x30, 0x60, 0x30, 0x18,
  0x70, 0x07, 0xF0, 0x00, 0x01, 0x83, 0xCF, 0x7C, 0x38, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0x01, 0xC0, 0xC1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x04, 0x40,
  0x02, 0x60, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xBF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x7F,
  0x80, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x31, 0x80, 0x0C,
  0x40, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0x23, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x61,
  0x00, 0x18, 0x60, 0x0C, 0x0E, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x19, 0x00, 0x0C, 0xC0, 0x02,
  0x30, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x20, 0x18, 0x18,
  0x04, 0x06, 0x03, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x10, 0x60, 0x0C, 0x10,
  0x03, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xC1, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x38, 0x01, 0x7F, 0x80, 0xF0, 0x30, 0x10,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x04, 0x00, 0xC1,
  0x80, 0x60, 0x38, 0x70, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x3F, 0x00,
  0xF0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x33, 0xF8, 0x26, 0x1C, 0x78, 0x06, 0x70, 0x02, 0x60,
  0x03, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x18, 0x18, 0x30, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xC0, 0x38, 0x38, 0x18, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x11, 0x80,
  0x04, 0x60, 0x01, 0x18, 0x00, 0xC6, 0x00, 0x30, 0x80, 0x18, 0x30, 0x0C,
  0x07, 0x0E, 0x00, 0x7E, 0x00, 0xF1, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x18,
  0x00, 0x44, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00,
  0x31, 0x80, 0x18, 0x60, 0x0E, 0x0E, 0x0E, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x07, 0xF8, 0x1C, 0x1C, 0x38, 0x04, 0x30, 0x06, 0x60, 0x02, 0x40, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x16, 0x30, 0x64, 0x1F, 0xCC, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x43, 0x8E, 0x00, 0x02, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0x80, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x04, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x18, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x83, 0x83, 0x18, 0x06, 0x40, 0x0B,
  0x00, 0x28, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x70, 0x38, 0x06,
  0x00, 0x40, 0x60, 0x03, 0x06, 0x00, 0x08, 0x20, 0xF0, 0x42, 0x0C, 0xE2,
  0x30, 0xC2, 0x11, 0x0C, 0x10, 0x98, 0x40, 0x84, 0x86, 0x0C, 0x24, 0x20,
  0x41, 0x21, 0x02, 0x0B, 0x18, 0x10, 0x50, 0x81, 0x84, 0x84, 0x08, 0x24,
  0x20, 0xC1, 0x21, 0x06, 0x11, 0x08, 0x51, 0x88, 0x7C, 0xD8, 0x61, 0xC3,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00,
  0x12, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30,
  0xC0, 0x08, 0x10, 0x06, 0x04, 0x01, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x18,
  0x18, 0x06, 0x04, 0x01, 0x83, 0xFF, 0xE0, 0x80, 0x08, 0x60, 0x02, 0x10,
  0x00, 0x8C, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00,
  0x10, 0x0F, 0xFE, 0x03, 0x01, 0xC0, 0x80, 0x18, 0x20, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x01, 0x84, 0x00, 0x63,
  0x00, 0x70, 0xC0, 0x70, 0x3F, 0xF8, 0x08, 0x03, 0x82, 0x00, 0x30, 0x80,
  0x04, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x00, 0x06, 0x40, 0x01,
  0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x30, 0xC0, 0xF8, 0x3F, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x04, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x03, 0x10,
  0x00, 0xC4, 0x00, 0x61, 0x80, 0x10, 0x30, 0x1C, 0x06, 0x0E, 0x00, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x80, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0,
  0x04, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x23, 0x00,
  0x04, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x03, 0x82, 0x00, 0xE0, 0x41, 0xF0,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE1, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE1, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80,
  0x30, 0x38, 0x18, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x04, 0xC0,
  0x01, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xFE, 0xC0, 0x00, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x10, 0x00, 0x46, 0x00, 0x31, 0x80,
  0x0C, 0x30, 0x06, 0x06, 0x07, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x10, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x18,
  0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x41,
  0x00, 0x04, 0x3F, 0xFF, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C,
  0x20, 0x00, 0x82, 0x00, 0x08, 0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01,
  0x84, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00,
  0x30, 0x0F, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x60, 0x01, 0x8C, 0x00, 0x30, 0x80, 0x0C, 0x18, 0x03, 0x01, 0x00, 0xE0,
  0x38, 0x70, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x03, 0x02, 0x00,
  0x30, 0x10, 0x03, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x70, 0x03,
  0x07, 0x00, 0x10, 0x70, 0x00, 0x87, 0x00, 0x04, 0x70, 0x00, 0x66, 0x00,
  0x03, 0x78, 0x00, 0x1E, 0x60, 0x00, 0xE3, 0x00, 0x06, 0x0C, 0x00, 0x20,
  0x20, 0x03, 0x01, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x30, 0x04, 0x00, 0xC0,
  0x20, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0xFF, 0xFC, 0x06, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x14, 0x1E,
  0x01, 0xE0, 0xB0, 0x0B, 0x05, 0x80, 0xD8, 0x24, 0x04, 0x83, 0x20, 0x64,
  0x19, 0x06, 0x20, 0xCC, 0x33, 0x04, 0x63, 0x18, 0x21, 0x10, 0xC1, 0x09,
  0x84, 0x18, 0x48, 0x20, 0xC3, 0xC3, 0x06, 0x1C, 0x18, 0x20, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x00, 0x06, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x10, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xF0, 0x03, 0x0B, 0x00,
  0x20, 0x90, 0x02, 0x19, 0x80, 0x21, 0x98, 0x06, 0x18, 0x80, 0x61, 0x0C,
  0x06, 0x10, 0x40, 0x41, 0x04, 0x04, 0x30, 0x60, 0x43, 0x02, 0x0C, 0x30,
  0x30, 0xC2, 0x03, 0x0C, 0x20, 0x10, 0x82, 0x01, 0x88, 0x60, 0x09, 0x86,
  0x00, 0x98, 0x60, 0x0D, 0x84, 0x00, 0x58, 0x40, 0x05, 0x04, 0x00, 0x70,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x30, 0x30,
  0x18, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x04, 0xC0, 0x03, 0x10, 0x00, 0x84, 0x00, 0x61, 0x80, 0x30, 0x30,
  0x18, 0x06, 0x1C, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0x80, 0x70, 0x30,
  0x03, 0x06, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0,
  0x01, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x03, 0x08, 0x00, 0xC3, 0x00,
  0x38, 0x60, 0x3C, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xC0, 0x0C, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01, 0x84, 0x00,
  0x11, 0x80, 0x02, 0x20, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00,
  0x24, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x36, 0x00, 0x06, 0x80, 0x00,
  0xD0, 0x00, 0x12, 0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06,
  0x10, 0x01, 0x83, 0x00, 0x20, 0x30, 0x18, 0x07, 0x0E, 0x00, 0x3F, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x0F, 0xFE, 0x03, 0x01, 0xC0, 0x80, 0x18, 0x20, 0x03, 0x08, 0x00, 0xC6,
  0x00, 0x11, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00,
  0x18, 0xC0, 0x0C, 0x30, 0x06, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x80, 0xC0,
  0x20, 0x10, 0x18, 0x06, 0x06, 0x00, 0x81, 0x80, 0x30, 0x40, 0x0C, 0x10,
  0x01, 0x04, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x02, 0x30, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x3F, 0xE0, 0x1C, 0x0E, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30,
  0x00, 0x84, 0x00, 0x10, 0x80, 0x03, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x07, 0x07,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x23, 0x00, 0x0C, 0x60,
  0x01, 0x88, 0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x80,
  0x06, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x46, 0x00,
  0x08, 0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x08, 0x00,
  0x23, 0x00, 0x0C, 0x60, 0x01, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x03,
  0x01, 0x80, 0xC0, 0x38, 0x70, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x24, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x18, 0x00, 0x86, 0x00, 0x61,
  0x80, 0x18, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x30,
  0x01, 0x88, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x80, 0x40, 0x70, 0x18, 0x0E,
  0x03, 0x01, 0x40, 0x60, 0x68, 0x1C, 0x0D, 0x02, 0x81, 0x20, 0xD0, 0x24,
  0x1A, 0x0C, 0x82, 0x41, 0x10, 0xCC, 0x22, 0x19, 0x8C, 0x42, 0x31, 0x88,
  0xC6, 0x21, 0x18, 0xCC, 0x22, 0x19, 0x84, 0xC3, 0x20, 0x98, 0x64, 0x12,
  0x0D, 0x82, 0xC1, 0xA0, 0x58, 0x34, 0x0A, 0x07, 0x81, 0xC0, 0xE0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x10, 0x04, 0x00, 0x06, 0x00, 0x0C,
  0x08, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x98,
  0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x80, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x60, 0x01, 0x80, 0x80, 0x04, 0x03, 0x00, 0x30, 0x04, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x20, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xD0,
  0x00, 0x66, 0x00, 0x11, 0x80, 0x0C, 0x20, 0x06, 0x0C, 0x01, 0x03, 0x00,
  0xC0, 0x40, 0x60, 0x18, 0x10, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x31, 0x00,
  0x0C, 0xC0, 0x01, 0x60, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x03, 0xE0, 0x7C, 0x00,
  0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x10, 0x10,
  0x10, 0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x06,
  0x06, 0x02, 0x02, 0x03, 0x03, 0xE0, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x83, 0xF0, 0x7E, 0x00, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x2C,
  0x06, 0x40, 0xC4, 0x08, 0x61, 0x86, 0x10, 0x23, 0x02, 0x20, 0x36, 0x03,
  0xC0, 0x3C, 0x01, 0xFF, 0xFE, 0xC6, 0x63, 0x10, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x03, 0xFF, 0x87, 0x80, 0xC6, 0x00, 0x66, 0x00, 0x26,
  0x00, 0x13, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x0E, 0x60, 0x0F, 0x1C, 0x39,
  0x87, 0xF8, 0xC0, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0xF8, 0x09, 0xFE,
  0x05, 0x81, 0x83, 0x80, 0x61, 0x80, 0x11, 0x80, 0x08, 0xC0, 0x06, 0x60,
  0x03, 0x20, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x32,
  0x00, 0x19, 0x00, 0x08, 0x80, 0x0C, 0xE0, 0x0C, 0x78, 0x0C, 0x36, 0x1C,
  0x11, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x0E, 0x18, 0x06, 0x30,
  0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0xC0, 0x0C, 0xC0,
  0x08, 0x60, 0x18, 0x30, 0x70, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x03, 0xE1, 0x03, 0xFE, 0x41, 0xC0, 0xF0, 0xC0, 0x1C, 0x30, 0x03,
  0x18, 0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x20, 0x01, 0x88,
  0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00,
  0x30, 0xC0, 0x1C, 0x18, 0x0E, 0x07, 0x0E, 0x80, 0x7E, 0x60, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0x81, 0xC1, 0x80, 0x61, 0x80, 0x19, 0x80, 0x0C, 0x80,
  0x06, 0xC0, 0x03, 0x40, 0x01, 0xBF, 0xFF, 0xD0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x18, 0x07,
  0x06, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3C, 0x20, 0x1C, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x40, 0xFF,
  0x90, 0x70, 0x3C, 0x30, 0x07, 0x0C, 0x01, 0xC6, 0x00, 0x31, 0x00, 0x08,
  0xC0, 0x02, 0x30, 0x01, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x30, 0x07, 0x06, 0x03,
  0x81, 0xC3, 0xA0, 0x1F, 0x88, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x78, 0x08, 0xFF, 0x04, 0xC0, 0xC2, 0x80,
  0x23, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x20, 0x01, 0x30,
  0x00, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x32, 0x00, 0x19, 0x00, 0x09,
  0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x90, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x7F, 0x80, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0xC6, 0x00, 0x61, 0x80, 0x70, 0x60, 0x30, 0x18, 0x18, 0x04, 0x0C,
  0x01, 0x0E, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0xD8, 0x00,
  0xC3, 0x00, 0x20, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x18, 0x10, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x18, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x07, 0xFF,
  0xF0, 0x11, 0xE1, 0xE0, 0xBF, 0xBF, 0x87, 0x0F, 0x06, 0x70, 0x30, 0x33,
  0x01, 0x01, 0x98, 0x08, 0x0C, 0x80, 0xC0, 0x64, 0x06, 0x02, 0x20, 0x30,
  0x13, 0x01, 0x00, 0x98, 0x08, 0x0C, 0xC0, 0x40, 0x64, 0x06, 0x02, 0x20,
  0x30, 0x11, 0x01, 0x80, 0x98, 0x08, 0x0C, 0xC0, 0x40, 0x66, 0x02, 0x03,
  0x20, 0x30, 0x11, 0x01, 0x80, 0x80, 0x18, 0x7C, 0x08, 0xFF, 0x04, 0x80,
  0xC2, 0x80, 0x23, 0x80, 0x11, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x02, 0x20,
  0x01, 0x30, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x32, 0x00, 0x11,
  0x00, 0x09, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x90, 0x00,
  0x80, 0x00, 0xF8, 0x03, 0xFE, 0x03, 0x81, 0x83, 0x00, 0x63, 0x00, 0x11,
  0x80, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0C, 0x80, 0x0C, 0x60,
  0x0C, 0x30, 0x0E, 0x0E, 0x0C, 0x01, 0xFC, 0x00, 0x06, 0x3E, 0x00, 0x9F,
  0xE0, 0x16, 0x06, 0x03, 0x80, 0x60, 0xE0, 0x0C, 0x18, 0x00, 0x83, 0x00,
  0x18, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00,
  0x21, 0x80, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x0C, 0x38, 0x03,
  0x07, 0x00, 0xC0, 0xD8, 0x70, 0x11, 0xFC, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xE1, 0x0F, 0xF9, 0x1C, 0x0F, 0x30, 0x07, 0x30,
  0x03, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0xC0,
  0x1C, 0x60, 0x38, 0x70, 0xE8, 0x1F, 0x88, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x18,
  0x3E, 0x23, 0xFC, 0x4C, 0x00, 0xA0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x20,
  0x01, 0x20, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x80, 0x06, 0x80, 0x04, 0xC0,
  0x0C, 0x70, 0x38, 0x1F, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0xF0, 0x30, 0x01, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x1C, 0x20, 0x1E, 0x1C, 0x3A, 0x07, 0xF1, 0x00, 0xC0,
  0x00, 0xD0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x08, 0x01,
  0x82, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00,
  0x60, 0xC0, 0x18, 0x60, 0x02, 0x10, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0D,
  0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x0E, 0x03, 0x01, 0x40, 0x60, 0x68, 0x14, 0x0D, 0x02, 0x81, 0x20, 0xD0,
  0x64, 0x12, 0x08, 0xC6, 0x61, 0x18, 0x8C, 0x63, 0x11, 0x88, 0x66, 0x33,
  0x0C, 0x82, 0x41, 0xB0, 0x48, 0x34, 0x0B, 0x06, 0x81, 0x40, 0xE0, 0x38,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x00, 0x18, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x03, 0x00, 0x30, 0x60, 0x01,
  0x8C, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xB0, 0x00, 0x31, 0x80, 0x06, 0x08, 0x00, 0xC0, 0xC0,
  0x18, 0x06, 0x03, 0x00, 0x20, 0x60, 0x03, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x80, 0x18, 0x01, 0x80, 0x20, 0x03, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x80,
  0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC3, 0x08,
  0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xF0, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x33, 0xB8, 0x03, 0x60, 0xC0,
  0x2C, 0x06, 0x06, 0x80, 0x39, 0xC8, 0x00, 0xF8,
};

const GFXglyph RobotoMono_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 8, 8, 22, 9, -28 },
  { 29, 22, 26, 22, 0, -26 },
  { 101, 18, 34, 22, 2, -30 },
  { 178, 18, 27, 22, 2, -27 },
  { 239, 18, 27, 22, 2, -27 },
  { 300, 2, 8, 22, 11, -28 },
  { 302, 12, 37, 22, 6, -29 },
  { 358, 12, 37, 22, 3, -29 },
  { 414, 16, 15, 22, 5, -26 },
  { 444, 18, 19, 22, 2, -22 },
  { 487, 5, 8, 22, 4, -3 },
  { 492, 13, 2, 22, 4, -13 },
  { 496, 3, 3, 22, 8, -3 },
  { 498, 17, 28, 22, 3, -26 },
  { 558, 17, 27, 22, 3, -27 },
  { 616, 9, 26, 22, 6, -26 },
  { 646, 17, 27, 22, 1, -27 },
  { 704, 18, 27, 22, 1, -27 },
  { 765, 18, 26, 22, 1, -26 },
  { 824, 18, 26, 22, 3, -26 },
  { 883, 16, 27, 22, 2, -27 },
  { 937, 17, 26, 22, 4, -26 },
  { 993, 18, 27, 22, 2, -27 },
  { 1054, 16, 27, 22, 4, -27 },
  { 1108, 6, 19, 22, 9, -19 },
  { 1123, 8, 24, 22, 7, -19 },
  { 1147, 16, 15, 22, 3, -19 },
  { 1177, 18, 8, 22, 2, -16 },
  { 1195, 17, 15, 22, 2, -19 },
  { 1227, 14, 27, 22, 6, -27 },
  { 1275, 21, 27, 22, 1, -27 },
  { 1346, 18, 26, 22, 0, -26 },
  { 1405, 18, 26, 22, 2, -26 },
  { 1464, 18, 27, 22, 2, -27 },
  { 1525, 19, 26, 22, 1, -26 },
  { 1587, 19, 26, 22, 2, -26 },
  { 1649, 19, 26, 22, 2, -26 },
  { 1711, 18, 27, 22, 2, -27 },
  { 1772, 20, 26, 22, 1, -26 },
  { 1837, 19, 26, 22, 2, -26 },
  { 1899, 19, 26, 22, 1, -26 },
  { 1961, 21, 26, 22, 2, -26 },
  { 2030, 15, 26, 22, 2, -26 },
  { 2079, 21, 26, 22, 1, -26 },
  { 2148, 20, 26, 22, 1, -26 },
  { 2213, 18, 27, 22, 2, -27 },
  { 2274, 19, 26, 22, 2, -26 },
  { 2336, 19, 32, 22, 2, -27 },
  { 2412, 18, 26, 22, 2, -26 },
  { 2471, 19, 27, 22, 2, -27 },
  { 2536, 19, 26, 22, 4, -26 },
  { 2598, 19, 26, 22, 2, -26 },
  { 2660, 18, 26, 22, 4, -26 },
  { 2719, 19, 26, 22, 4, -26 },
  { 2781, 22, 26, 22, 0, -26 },
  { 2853, 18, 26, 22, 4, -26 },
  { 2912, 19, 26, 22, 1, -26 },
  { 2974, 11, 36, 22, 6, -30 },
  { 3024, 8, 28, 22, 7, -26 },
  { 3052, 11, 36, 22, 5, -30 },
  { 3102, 12, 14, 22, 5, -26 },
  { 3123, 15, 1, 22, 1, 0 },
  { 3125, 4, 5, 22, 11, -27 },
  { 3128, 17, 20, 22, 2, -20 },
  { 3171, 17, 28, 22, 2, -28 },
  { 3231, 16, 20, 22, 3, -20 },
  { 3271, 18, 28, 22, 3, -28 },
  { 3334, 17, 20, 22, 2, -20 },
  { 3377, 18, 28, 22, 5, -28 },
  { 3440, 18, 28, 22, 1, -20 },
  { 3503, 17, 28, 22, 2, -28 },
  { 3563, 15, 27, 22, 2, -27 },
  { 3614, 17, 35, 22, 0, -27 },
  { 3689, 18, 28, 22, 2, -28 },
  { 3752, 15, 28, 22, 2, -28 },
  { 3805, 21, 20, 22, 0, -20 },
  { 3858, 17, 20, 22, 2, -20 },
  { 3901, 17, 20, 22, 2, -20 },
  { 3944, 19, 28, 22, 0, -20 },
  { 4011, 16, 28, 22, 3, -20 },
  { 4067, 15, 20, 22, 5, -20 },
  { 4105, 16, 20, 22, 3, -20 },
  { 4145, 15, 25, 22, 4, -25 },
  { 4192, 17, 20, 22, 3, -20 },
  { 4235, 18, 20, 22, 3, -20 },
  { 4280, 19, 20, 22, 3, -20 },
  { 4328, 20, 20, 22, 1, -20 },
  { 4378, 23, 28, 22, -1, -20 },
  { 4459, 19, 20, 22, 1, -20 },
  { 4507, 14, 37, 22, 6, -29 },
  { 4572, 6, 31, 22, 8, -26 },
  { 4596, 14, 37, 22, 3, -29 },
  { 4661, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC37PT7B_H_
