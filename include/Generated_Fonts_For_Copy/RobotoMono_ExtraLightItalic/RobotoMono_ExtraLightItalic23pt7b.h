#ifndef _ROBOTOMONO_EXTRALIGHTITALIC23PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0x08, 0x99, 0x99, 0xA0,
  0x01, 0x18, 0x04, 0x40, 0x21, 0x00, 0x88, 0x3F, 0xFC, 0x10, 0x80, 0x44,
  0x02, 0x10, 0x08, 0x40, 0x22, 0x0F, 0xFF, 0x04, 0x20, 0x11, 0x00, 0x84,
  0x02, 0x10, 0x08, 0x80, 0x02, 0x00, 0x40, 0x1C, 0x0C, 0x43, 0x04, 0x40,
  0x90, 0x12, 0x00, 0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x20,
  0x24, 0x04, 0x80, 0x98, 0x21, 0xF8, 0x04, 0x01, 0x00, 0x18, 0x04, 0x81,
  0x11, 0xA2, 0x28, 0x49, 0x09, 0x12, 0x43, 0x90, 0x02, 0x00, 0x80, 0x27,
  0x85, 0x11, 0x22, 0x44, 0x50, 0x88, 0x11, 0x03, 0xC0, 0x03, 0x01, 0x90,
  0x22, 0x08, 0x41, 0x08, 0x22, 0x04, 0x80, 0x60, 0x18, 0x06, 0x81, 0x08,
  0xA1, 0x18, 0x13, 0x03, 0xA0, 0x22, 0x0A, 0x3E, 0x60, 0xF8, 0x02, 0x08,
  0x20, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x00, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x82, 0x0C, 0x20, 0x00, 0x04, 0x01, 0x00, 0x43, 0xA7, 0x1E, 0x07, 0x03,
  0x40, 0x88, 0x41, 0x00, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x55, 0x80, 0xFF,
  0x70, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x06,
  0x06, 0x62, 0x04, 0x81, 0x40, 0x50, 0x38, 0x16, 0x09, 0x84, 0x62, 0x1B,
  0x07, 0x02, 0x80, 0xA0, 0x28, 0x13, 0x08, 0x7C, 0x00, 0x1D, 0xA8, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x03, 0x01, 0x98,
  0x40, 0x88, 0x12, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x03, 0x03, 0x98,
  0xC1, 0x10, 0x14, 0x02, 0x00, 0x80, 0x10, 0x04, 0x0F, 0x00, 0x30, 0x02,
  0x00, 0x28, 0x05, 0x01, 0x20, 0x26, 0x08, 0x7E, 0x00, 0x00, 0xC0, 0x18,
  0x05, 0x01, 0x20, 0x48, 0x11, 0x06, 0x20, 0x84, 0x20, 0x88, 0x22, 0x04,
  0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x1F, 0xE2, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x1F, 0xC2, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x48,
  0x09, 0x03, 0x10, 0x41, 0xF0, 0x00, 0x40, 0xE0, 0xC0, 0x60, 0x10, 0x08,
  0x02, 0x71, 0x62, 0x60, 0x50, 0x14, 0x06, 0x01, 0x80, 0x50, 0x14, 0x09,
  0x84, 0x3E, 0x00, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x03,
  0x80, 0xC4, 0x18, 0x21, 0x01, 0x20, 0x12, 0x02, 0x20, 0x21, 0x04, 0x0F,
  0x81, 0x08, 0x60, 0x44, 0x02, 0x40, 0x28, 0x04, 0x40, 0x44, 0x08, 0x3F,
  0x00, 0x06, 0x06, 0x62, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xD0, 0x56, 0x28, 0x72, 0x00, 0x80, 0x40, 0x20, 0x30, 0x70, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0x60, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x42,
  0x23, 0x00, 0x00, 0x40, 0xE0, 0xC1, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x18, 0x66,
  0xC1, 0x81, 0x01, 0x01, 0x02, 0x06, 0x0C, 0x10, 0x20, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x07, 0xE1, 0x81, 0x20, 0x12, 0x39, 0x44, 0x94, 0x89,
  0x90, 0x99, 0x11, 0x91, 0x19, 0x11, 0x93, 0x29, 0x52, 0x98, 0xC8, 0x00,
  0x41, 0x03, 0xE0, 0x00, 0x80, 0x30, 0x06, 0x01, 0x20, 0x24, 0x08, 0x81,
  0x10, 0x42, 0x08, 0x42, 0x08, 0x7F, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0C,
  0x01, 0x1F, 0xC2, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x31, 0xF8,
  0x40, 0xC8, 0x09, 0x00, 0xA0, 0x14, 0x05, 0x00, 0xA0, 0x67, 0xF0, 0x03,
  0x00, 0xCC, 0x10, 0x23, 0x02, 0x20, 0x14, 0x01, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x64, 0x04, 0x40, 0x86, 0x18, 0x3E,
  0x00, 0x1F, 0x82, 0x04, 0x20, 0x22, 0x02, 0x20, 0x12, 0x01, 0x20, 0x14,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x80, 0x48, 0x08, 0x83, 0x0F,
  0xC0, 0x1F, 0xF1, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03,
  0xFC, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0F,
  0xF8, 0x1F, 0xF1, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03,
  0xFC, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x03, 0x00, 0xCC, 0x10, 0x22, 0x03, 0x20, 0x14, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x3E, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x40, 0x46,
  0x0C, 0x3F, 0x00, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x24, 0x02,
  0x40, 0x27, 0xFE, 0x40, 0x24, 0x02, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x0C, 0x1F, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x0F, 0xF8, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x04, 0x80, 0x88, 0x08,
  0x41, 0x03, 0xE0, 0x10, 0x18, 0x81, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11,
  0x00, 0x90, 0x05, 0x80, 0x54, 0x03, 0x10, 0x10, 0xC0, 0x82, 0x04, 0x08,
  0x20, 0x42, 0x01, 0x10, 0x0C, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0xFF, 0x30, 0x13, 0x03, 0x30, 0x52, 0x85, 0x28, 0x92, 0x8A, 0x49, 0x24,
  0x92, 0x46, 0x24, 0x62, 0x44, 0x24, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x04, 0x30, 0x13, 0x01, 0x28, 0x12, 0x81, 0x28, 0x24, 0x42, 0x44, 0x24,
  0x42, 0x42, 0x24, 0x22, 0x42, 0x48, 0x14, 0x81, 0x48, 0x0C, 0x80, 0xC8,
  0x08, 0x03, 0x00, 0xCC, 0x10, 0x23, 0x02, 0x20, 0x24, 0x01, 0x40, 0x14,
  0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x04, 0x40, 0x86,
  0x10, 0x3E, 0x00, 0x1F, 0xE1, 0x03, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x22, 0x06, 0x3F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x03, 0x00, 0xCC, 0x10, 0x22, 0x02, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x40, 0x84, 0x18, 0x3E, 0x00, 0x10, 0x00, 0x80, 0x08, 0x1F, 0xC1, 0x02,
  0x20, 0x22, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x0C, 0x7F, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x84, 0x08, 0x80, 0x48, 0x04, 0x03, 0x00, 0xCC,
  0x10, 0x22, 0x01, 0x20, 0x12, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x06, 0x00, 0x28, 0x02, 0x40, 0x44, 0x08, 0x3F, 0x00, 0xFF,
  0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x48, 0x04, 0x40, 0x44, 0x08, 0x61, 0x03, 0xE0, 0x80, 0x70, 0x0A,
  0x02, 0x40, 0x48, 0x11, 0x02, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10,
  0x24, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x82, 0x18, 0x61, 0x86, 0x18,
  0x62, 0x8A, 0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0x49, 0x28, 0xA2, 0x8A,
  0x28, 0xA2, 0x8C, 0x30, 0xC3, 0x08, 0x30, 0x10, 0x0C, 0x20, 0x40, 0x81,
  0x01, 0x08, 0x04, 0x40, 0x0A, 0x00, 0x38, 0x00, 0x40, 0x03, 0x00, 0x14,
  0x00, 0xC8, 0x02, 0x20, 0x10, 0x40, 0x81, 0x06, 0x02, 0x30, 0x08, 0x80,
  0x70, 0x19, 0x02, 0x20, 0x84, 0x30, 0x44, 0x09, 0x01, 0x60, 0x28, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x1F, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFC, 0x0E,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x3C, 0x00, 0x88, 0x88, 0x44, 0x44,
  0x42, 0x22, 0x22, 0x11, 0x10, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x3C, 0x00, 0x0C, 0x0C, 0x14, 0x12, 0x22, 0x22, 0x42, 0x81, 0x81, 0xFF,
  0x80, 0x94, 0x0F, 0x86, 0x08, 0x80, 0x80, 0x10, 0x04, 0x3F, 0x88, 0x12,
  0x02, 0x80, 0x50, 0x11, 0x06, 0x3F, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x5F, 0x0C, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x24,
  0x04, 0x80, 0x90, 0x25, 0x08, 0xBE, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xA0, 0x4C, 0x31, 0xF0, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x3E, 0x88, 0x32, 0x06, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x44, 0x18, 0x7D, 0x00, 0x0F, 0x82,
  0x08, 0x80, 0xA0, 0x14, 0x02, 0xFF, 0xE0, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x83, 0x0F, 0x80, 0x00, 0xC0, 0xE4, 0x30, 0x04, 0x01, 0x00, 0x20, 0x3F,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x00, 0x0F, 0xA2, 0x0C, 0x81, 0xA0, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x86, 0x1F, 0x40, 0x08, 0x02, 0x20,
  0x46, 0x10, 0x3C, 0x00, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x5F,
  0x8C, 0x11, 0x01, 0x20, 0x28, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0xA0,
  0x14, 0x04, 0x80, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x43, 0xFF,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x18, 0x06, 0x0F, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x12, 0x06, 0x20, 0x82, 0x10, 0x22, 0x02, 0xC0, 0x38, 0x06, 0x40, 0x42,
  0x04, 0x20, 0x41, 0x04, 0x08, 0x80, 0xC0, 0x1F, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC0, 0x3E, 0xF1, 0x08, 0x50, 0x42, 0x84, 0x14,
  0x20, 0xA1, 0x09, 0x08, 0x48, 0x42, 0x82, 0x14, 0x20, 0xA1, 0x05, 0x08,
  0x40, 0x2F, 0xC6, 0x08, 0x80, 0x90, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x50, 0x0A, 0x02, 0x40, 0x40, 0x0F, 0x86, 0x08, 0x80, 0xA0, 0x14,
  0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x48, 0x11, 0x06, 0x1F, 0x00, 0x17,
  0xC1, 0x82, 0x10, 0x21, 0x02, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20,
  0x22, 0x04, 0x60, 0x85, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x00, 0x1F, 0x48, 0x34, 0x0E, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80,
  0xA0, 0x48, 0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x27,
  0xCE, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x3F, 0x98, 0x34, 0x05, 0x00, 0x60, 0x07, 0x00, 0x30, 0x02,
  0x00, 0xA0, 0x28, 0x11, 0xF8, 0x08, 0x04, 0x04, 0x1F, 0xF1, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x78, 0x40, 0x50,
  0x14, 0x05, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x31,
  0xF4, 0x80, 0x30, 0x09, 0x02, 0x20, 0x44, 0x10, 0x42, 0x08, 0x81, 0x10,
  0x24, 0x03, 0x00, 0x60, 0x08, 0x00, 0x84, 0x18, 0x42, 0x8C, 0x28, 0xC4,
  0x94, 0x49, 0x24, 0xA2, 0x8A, 0x28, 0xA3, 0x0C, 0x30, 0xC3, 0x08, 0x20,
  0x10, 0x18, 0x41, 0x02, 0x10, 0x09, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00,
  0xA0, 0x08, 0x80, 0x86, 0x08, 0x11, 0x80, 0x40, 0x20, 0x09, 0x00, 0x84,
  0x04, 0x20, 0x41, 0x06, 0x08, 0x20, 0x22, 0x01, 0x10, 0x09, 0x00, 0x38,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00,
  0x1F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0F, 0xFE, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x60, 0x80, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x10, 0x08, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x44,
  0x88, 0x88, 0x80, 0x18, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x30, 0x60, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x03, 0x03, 0x02, 0x00, 0x18, 0x03, 0x30, 0x50, 0xC5, 0x01, 0xC0,
};

const GFXglyph RobotoMono_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 4, 5, 14, 6, -17 },
  { 12, 14, 16, 14, 0, -16 },
  { 40, 11, 21, 14, 2, -19 },
  { 69, 11, 17, 14, 1, -17 },
  { 93, 11, 17, 14, 1, -17 },
  { 117, 1, 5, 14, 7, -17 },
  { 118, 7, 23, 14, 4, -18 },
  { 139, 7, 23, 14, 2, -18 },
  { 160, 10, 9, 14, 3, -16 },
  { 172, 11, 12, 14, 1, -14 },
  { 189, 2, 5, 14, 3, -2 },
  { 191, 8, 1, 14, 3, -8 },
  { 192, 2, 2, 14, 5, -2 },
  { 193, 10, 17, 14, 2, -16 },
  { 215, 10, 17, 14, 2, -17 },
  { 237, 6, 16, 14, 4, -16 },
  { 249, 11, 17, 14, 0, -17 },
  { 273, 11, 17, 14, 1, -17 },
  { 297, 11, 16, 14, 1, -16 },
  { 319, 11, 16, 14, 2, -16 },
  { 341, 10, 17, 14, 1, -17 },
  { 363, 10, 16, 14, 3, -16 },
  { 383, 12, 17, 14, 1, -17 },
  { 409, 10, 17, 14, 2, -17 },
  { 431, 3, 12, 14, 6, -12 },
  { 436, 5, 15, 14, 4, -12 },
  { 446, 10, 9, 14, 2, -12 },
  { 458, 10, 5, 14, 2, -10 },
  { 465, 11, 9, 14, 1, -12 },
  { 478, 8, 17, 14, 4, -17 },
  { 495, 12, 16, 14, 1, -16 },
  { 519, 11, 16, 14, 0, -16 },
  { 541, 11, 16, 14, 1, -16 },
  { 563, 12, 17, 14, 1, -17 },
  { 589, 12, 16, 14, 1, -16 },
  { 613, 12, 16, 14, 1, -16 },
  { 637, 12, 16, 14, 1, -16 },
  { 661, 12, 17, 14, 1, -17 },
  { 687, 12, 16, 14, 1, -16 },
  { 711, 12, 16, 14, 1, -16 },
  { 735, 12, 16, 14, 1, -16 },
  { 759, 13, 16, 14, 1, -16 },
  { 785, 10, 16, 14, 1, -16 },
  { 805, 12, 16, 14, 1, -16 },
  { 829, 12, 16, 14, 1, -16 },
  { 853, 12, 17, 14, 1, -17 },
  { 879, 12, 16, 14, 1, -16 },
  { 903, 12, 20, 14, 1, -17 },
  { 933, 12, 16, 14, 1, -16 },
  { 957, 12, 17, 14, 1, -17 },
  { 983, 11, 16, 14, 3, -16 },
  { 1005, 12, 16, 14, 1, -16 },
  { 1029, 11, 16, 14, 3, -16 },
  { 1051, 12, 16, 14, 2, -16 },
  { 1075, 14, 16, 14, 0, -16 },
  { 1103, 11, 16, 14, 3, -16 },
  { 1125, 13, 16, 14, 0, -16 },
  { 1151, 7, 23, 14, 3, -19 },
  { 1172, 4, 17, 14, 5, -16 },
  { 1181, 7, 23, 14, 3, -19 },
  { 1202, 8, 9, 14, 3, -16 },
  { 1211, 9, 1, 14, 1, 0 },
  { 1213, 2, 3, 14, 7, -17 },
  { 1214, 11, 12, 14, 1, -12 },
  { 1231, 11, 17, 14, 1, -17 },
  { 1255, 10, 12, 14, 2, -12 },
  { 1270, 11, 17, 14, 2, -17 },
  { 1294, 11, 12, 14, 1, -12 },
  { 1311, 11, 18, 14, 3, -18 },
  { 1336, 11, 17, 14, 1, -12 },
  { 1360, 11, 17, 14, 1, -17 },
  { 1384, 10, 16, 14, 1, -16 },
  { 1404, 11, 21, 14, 0, -16 },
  { 1433, 12, 17, 14, 1, -17 },
  { 1459, 10, 17, 14, 1, -17 },
  { 1481, 13, 12, 14, 0, -12 },
  { 1501, 11, 12, 14, 1, -12 },
  { 1518, 11, 12, 14, 1, -12 },
  { 1535, 12, 17, 14, 0, -12 },
  { 1561, 10, 17, 14, 2, -12 },
  { 1583, 10, 12, 14, 3, -12 },
  { 1598, 10, 12, 14, 2, -12 },
  { 1613, 9, 15, 14, 3, -15 },
  { 1630, 10, 12, 14, 2, -12 },
  { 1645, 11, 12, 14, 2, -12 },
  { 1662, 12, 12, 14, 2, -12 },
  { 1680, 13, 12, 14, 0, -12 },
  { 1700, 13, 17, 14, 0, -12 },
  { 1728, 12, 12, 14, 0, -12 },
  { 1746, 8, 23, 14, 4, -18 },
  { 1769, 4, 19, 14, 5, -16 },
  { 1779, 9, 23, 14, 2, -18 },
  { 1805, 13, 4, 14, 0, -9 },
};

const GFXfont RobotoMono_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC23PT7B_H_
