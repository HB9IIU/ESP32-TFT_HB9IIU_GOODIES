#ifndef _ROBOTOMONO_EXTRALIGHTITALIC67PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x31, 0x80,
  0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x04, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x18, 0x70, 0x03,
  0x00, 0x1C, 0x60, 0x03, 0x00, 0x38, 0x60, 0x03, 0x00, 0x70, 0xE0, 0x03,
  0x00, 0xE0, 0xE0, 0x03, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0xE0, 0x06, 0x03, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x60, 0x0C,
  0x0E, 0x00, 0x70, 0x1C, 0x0C, 0x00, 0x78, 0x78, 0x1C, 0x00, 0x3F, 0xF0,
  0x38, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x0E,
  0x07, 0xFC, 0x00, 0x1C, 0x0F, 0x1E, 0x00, 0x38, 0x1C, 0x06, 0x00, 0x30,
  0x38, 0x07, 0x00, 0x70, 0x30, 0x03, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0xC0, 0x60, 0x03, 0x03, 0x80, 0xE0, 0x03, 0x07, 0x00,
  0xE0, 0x03, 0x07, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0xC0, 0x07, 0x1C, 0x00,
  0xC0, 0x06, 0x38, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x70, 0xF0, 0x0E, 0x00, 0x38, 0xF0, 0x03,
  0x80, 0x1C, 0x70, 0x01, 0xC0, 0x1C, 0x70, 0x00, 0x70, 0x0E, 0x38, 0x00,
  0x3C, 0x07, 0x38, 0x00, 0x0E, 0x07, 0x1C, 0x00, 0x03, 0x83, 0x8C, 0x00,
  0x01, 0xC3, 0x8E, 0x00, 0x00, 0x71, 0xC7, 0x00, 0x00, 0x1D, 0xC3, 0x80,
  0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xFC, 0x07, 0x00, 0x01, 0xEF, 0x01,
  0xE0, 0x03, 0xE3, 0x80, 0xF8, 0x07, 0xC0, 0xE0, 0x1F, 0xFF, 0xC0, 0x70,
  0x07, 0xFF, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x19, 0xCE, 0x73,
  0x98, 0xCE, 0x73, 0x98, 0xC6, 0x70, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x04, 0x00, 0x70, 0x03, 0xF8, 0x07, 0x01, 0xFF, 0xF0, 0x60,
  0xFF, 0x3F, 0xC6, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x03, 0xC0,
  0x03, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0x00, 0x01, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x1F, 0x8C, 0x00, 0x00, 0x7F, 0x38, 0x00, 0x01, 0xCE, 0x70, 0x00, 0x07,
  0x1C, 0xE0, 0x00, 0x1C, 0x39, 0xC0, 0x00, 0xF0, 0x73, 0x00, 0x03, 0xC0,
  0xCE, 0x00, 0x0F, 0x03, 0x9C, 0x00, 0x38, 0x07, 0x38, 0x00, 0xE0, 0x0E,
  0x70, 0x07, 0x80, 0x1C, 0xE0, 0x1E, 0x00, 0x31, 0x80, 0x78, 0x00, 0x67,
  0x01, 0xC0, 0x01, 0xCE, 0x07, 0x00, 0x03, 0x9C, 0x3C, 0x00, 0x07, 0x38,
  0xF0, 0x00, 0x0E, 0x73, 0xC0, 0x00, 0x18, 0xEE, 0x00, 0x00, 0x71, 0xF8,
  0x00, 0x00, 0xE3, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x3E,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x01, 0xFF,
  0x81, 0xF8, 0xE3, 0xF8, 0x39, 0xF0, 0x0E, 0x70, 0x03, 0x30, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07,
  0x98, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x87, 0xFE, 0x00, 0x01,
  0xCF, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x3F, 0xE0, 0x07, 0x0F, 0xFF,
  0xC0, 0x38, 0xFC, 0x3F, 0x01, 0x9E, 0x00, 0x3C, 0x1D, 0xC0, 0x00, 0xF0,
  0xFC, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x0E, 0xE3,
  0x80, 0x01, 0xCC, 0x1E, 0x00, 0x79, 0xC0, 0xF0, 0x1F, 0x1C, 0x07, 0xFF,
  0xE1, 0xC0, 0x3F, 0xF0, 0x38, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x38, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x1F, 0x00,
  0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x07, 0xE0, 0x0E, 0x07,
  0x00, 0xFF, 0xC0, 0x70, 0x70, 0x0F, 0x8F, 0x03, 0x83, 0x00, 0xE0, 0x38,
  0x1C, 0x38, 0x0E, 0x01, 0xC0, 0x61, 0x80, 0xE0, 0x0C, 0x03, 0x1C, 0x06,
  0x00, 0x60, 0x18, 0xC0, 0x70, 0x03, 0x00, 0xCE, 0x03, 0x00, 0x38, 0x0E,
  0x60, 0x38, 0x01, 0x80, 0x73, 0x01, 0x80, 0x0C, 0x03, 0x38, 0x1C, 0x00,
  0x60, 0x19, 0x80, 0xE0, 0x06, 0x00, 0xCC, 0x06, 0x00, 0x30, 0x06, 0x60,
  0x30, 0x01, 0x80, 0x37, 0x03, 0x80, 0x1C, 0x03, 0xB0, 0x18, 0x00, 0xC0,
  0x19, 0x80, 0xC0, 0x06, 0x00, 0xCC, 0x06, 0x00, 0x70, 0x0E, 0x60, 0x30,
  0x03, 0x80, 0x63, 0x01, 0x80, 0x38, 0x03, 0x18, 0x0C, 0x01, 0xC0, 0x38,
  0xC0, 0x60, 0x1E, 0x01, 0x86, 0x03, 0x01, 0xB0, 0x1C, 0x30, 0x18, 0x1D,
  0x81, 0xC1, 0x80, 0xE1, 0xCE, 0x1C, 0x0C, 0x03, 0xFC, 0x3F, 0xC0, 0x70,
  0x1F, 0xC0, 0xFC, 0x03, 0x80, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x1F,
  0x80, 0x0C, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0xFF, 0x9C, 0x00, 0x1F, 0xFF, 0xCE, 0x00, 0x0F, 0xFF,
  0xE7, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x01, 0x8F, 0xE0, 0x00, 0x00, 0x0E,
  0x7B, 0xC0, 0x00, 0x00, 0x3B, 0xC7, 0x00, 0x00, 0x00, 0xFE, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xD8, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x3B, 0x00, 0x00, 0xEE,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x0E, 0xE0, 0x00, 0x73, 0x00, 0x67, 0x00,
  0x07, 0x18, 0x03, 0x18, 0x00, 0x39, 0xC0, 0x38, 0xC0, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x0E,
  0x18, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x30, 0x07, 0x0E, 0x01, 0xC1,
  0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x07, 0x03, 0x80, 0x70, 0x70, 0x38, 0x1C,
  0x03, 0x83, 0x83, 0x80, 0xC0, 0x18, 0x0C, 0x1C, 0x0E, 0x01, 0xC0, 0x61,
  0xC0, 0x70, 0x0E, 0x03, 0x8E, 0x03, 0x80, 0x70, 0x1C, 0xE0, 0x1C, 0x03,
  0x80, 0xE6, 0x00, 0xE0, 0x1C, 0x03, 0x70, 0x06, 0x00, 0xC0, 0x1F, 0x00,
  0x70, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x70, 0x07, 0x80, 0x1C, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x00,
  0x01, 0x80, 0x3B, 0x80, 0x00, 0x1C, 0x01, 0xDC, 0x00, 0x00, 0xE0, 0x0C,
  0x60, 0x00, 0x07, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x07, 0x1C, 0x00, 0x01,
  0xC0, 0x38, 0x60, 0x00, 0x0C, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0x0E, 0x1C,
  0x00, 0x07, 0x00, 0x60, 0x60, 0x00, 0x38, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x0E, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x18, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x00,
  0x70, 0x00, 0x70, 0x38, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x18, 0x00, 0x0E,
  0x0E, 0x00, 0xC0, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x70,
  0x00, 0x0E, 0x18, 0x03, 0x80, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0x01, 0x8E,
  0x00, 0xC0, 0x00, 0x0E, 0x70, 0x0E, 0x00, 0x00, 0x33, 0x80, 0x70, 0x00,
  0x01, 0xDC, 0x03, 0x80, 0x00, 0x0E, 0xC0, 0x1C, 0x00, 0x00, 0x3E, 0x00,
  0xE0, 0x00, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xE0,
  0x0E, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03,
  0xC0, 0x06, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E, 0x06, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1B, 0x80, 0x07, 0x80, 0x07,
  0x70, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0x1D, 0xC0, 0x07, 0xC0,
  0x03, 0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1B, 0x00, 0x1C, 0xE0, 0x07,
  0x60, 0x03, 0x1C, 0x00, 0xEC, 0x00, 0xE3, 0x80, 0x19, 0x80, 0x1C, 0x70,
  0x07, 0x30, 0x03, 0x0E, 0x00, 0xE6, 0x00, 0xE1, 0xC0, 0x18, 0xC0, 0x1C,
  0x38, 0x07, 0x18, 0x03, 0x87, 0x00, 0xE3, 0x00, 0x60, 0xE0, 0x18, 0x60,
  0x1C, 0x1C, 0x07, 0x0C, 0x03, 0x83, 0x80, 0xE1, 0x80, 0x60, 0x70, 0x18,
  0x30, 0x1C, 0x0E, 0x07, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0xC0, 0x60, 0x38,
  0x18, 0x18, 0x1C, 0x07, 0x07, 0x03, 0x03, 0x80, 0xE0, 0xE0, 0x70, 0x60,
  0x1C, 0x18, 0x0E, 0x0C, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38,
  0x70, 0x0E, 0x18, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x1C, 0x70, 0x06, 0x38, 0x03, 0x8C, 0x00, 0xC7, 0x00, 0x73, 0x80, 0x18,
  0xC0, 0x0E, 0x70, 0x03, 0x38, 0x01, 0xCC, 0x00, 0x67, 0x00, 0x39, 0x80,
  0x0C, 0xC0, 0x07, 0x70, 0x01, 0xB8, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0xF0, 0x00, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x60, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x60,
  0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x00,
  0x1C, 0x06, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0x30, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80,
  0x01, 0x86, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xE0, 0x3F, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x7C, 0x1C, 0x00, 0x01, 0xD8, 0x3C, 0x00, 0x07, 0x70, 0x3C,
  0x00, 0x3C, 0xE0, 0x3E, 0x03, 0xF1, 0xC0, 0x3F, 0xFF, 0x83, 0x80, 0x3F,
  0xFC, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x3F, 0x80, 0x01, 0xC1, 0xFF, 0xC0, 0x03, 0x8F, 0xFF,
  0xE0, 0x07, 0x3C, 0x03, 0xE0, 0x0D, 0xE0, 0x01, 0xC0, 0x1B, 0x00, 0x01,
  0xC0, 0x7C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0xF0, 0x1D, 0xC0, 0x07, 0xC0, 0x39, 0xE0, 0x3F,
  0x00, 0x61, 0xFF, 0xF8, 0x01, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0x7F, 0xF8, 0x38, 0x00, 0xFF,
  0xFF, 0x1C, 0x00, 0xF8, 0x03, 0x8E, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x3E, 0x03, 0xE6, 0x00, 0x0F, 0xFF,
  0xC3, 0x00, 0x01, 0xFF, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x10, 0x07, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x20, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x07, 0x00, 0x3F, 0xFF, 0xC7, 0x00, 0x7C, 0x01, 0xE7, 0x00, 0xF0,
  0x00, 0xE6, 0x01, 0xE0, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x3E, 0x03, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x1E, 0xE0, 0x07, 0xC0, 0x7C, 0xC0, 0x03, 0xFF,
  0xF1, 0xC0, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x40, 0x00, 0x0F, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xE0,
  0x01, 0xC0, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xF0, 0x06, 0x1E, 0x00, 0xF0,
  0x1C, 0x70, 0x00, 0xE0, 0x39, 0x80, 0x00, 0xE0, 0x76, 0x00, 0x01, 0xC0,
  0xF8, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x02, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x03,
  0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x03,
  0x00, 0x01, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x06,
  0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x1C,
  0xFC, 0x00, 0x00, 0x1D, 0xFE, 0x00, 0x00, 0x1F, 0xCE, 0x00, 0x00, 0x1F,
  0x87, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0x1F, 0xF0, 0x3F, 0xE0, 0x0E, 0xFF, 0xF1, 0xFF, 0xE0, 0x1B,
  0x80, 0xF7, 0x81, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xC0, 0x78, 0x01, 0xF0,
  0x01, 0x81, 0xE0, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x01, 0xC1,
  0xC0, 0x01, 0x80, 0x03, 0x83, 0x80, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x01, 0xC1, 0xC0, 0x03,
  0x80, 0x03, 0x83, 0x80, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x30, 0x00, 0x70, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0xC0, 0x01, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x80, 0x03, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x03, 0xFF, 0xC0,
  0x0C, 0x1F, 0xFF, 0xC0, 0x18, 0x78, 0x03, 0xC0, 0x71, 0xC0, 0x03, 0x80,
  0xE6, 0x00, 0x03, 0x81, 0xD8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x70, 0xFF, 0xF0, 0x00, 0x38, 0xFF, 0xFE,
  0x00, 0x19, 0xF0, 0x0F, 0x80, 0x0D, 0xE0, 0x01, 0xC0, 0x0F, 0xC0, 0x00,
  0x70, 0x07, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x03, 0xC0,
  0x1D, 0xC0, 0x07, 0xC0, 0x0E, 0x78, 0x0F, 0xC0, 0x0E, 0x1F, 0xFF, 0x80,
  0x07, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x70, 0x0F,
  0xFF, 0xF1, 0xC0, 0x7C, 0x01, 0xE7, 0x03, 0xC0, 0x03, 0x98, 0x1E, 0x00,
  0x07, 0xE0, 0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF8, 0x0E,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x7B, 0x80, 0x7C, 0x07, 0xCC, 0x00, 0xFF,
  0xFC, 0x30, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x1C, 0x07, 0xFF, 0xC0, 0xE0, 0xFF, 0xFC, 0x07, 0x0F,
  0x80, 0x00, 0x39, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x36, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0x00, 0x1E, 0xE0, 0x1E,
  0x03, 0xE3, 0x80, 0x3F, 0xFF, 0x0E, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0x1A,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1B, 0x80, 0x07, 0x80, 0x07, 0x70,
  0x00, 0xF0, 0x00, 0xEE, 0x00, 0x3E, 0x00, 0x39, 0xC0, 0x06, 0xC0, 0x07,
  0x38, 0x01, 0xD8, 0x00, 0xC7, 0x00, 0x3B, 0x00, 0x38, 0xE0, 0x06, 0x60,
  0x07, 0x1C, 0x01, 0xCC, 0x00, 0xC3, 0x80, 0x31, 0x80, 0x38, 0x70, 0x0E,
  0x30, 0x06, 0x06, 0x01, 0x86, 0x01, 0xC0, 0xC0, 0x30, 0xE0, 0x38, 0x18,
  0x0E, 0x1C, 0x06, 0x03, 0x01, 0x83, 0x81, 0xC0, 0x60, 0x70, 0x70, 0x30,
  0x0C, 0x0C, 0x0E, 0x0E, 0x01, 0x83, 0x81, 0xC1, 0xC0, 0x30, 0x70, 0x18,
  0x30, 0x06, 0x0C, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x18, 0x60,
  0x0C, 0x70, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0x73, 0x00, 0x31, 0x80, 0x0E,
  0x60, 0x06, 0x70, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0x3B, 0x00, 0x19, 0x80,
  0x07, 0xE0, 0x03, 0x70, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0x0C, 0x1E, 0x0F, 0x80,
  0x00, 0x61, 0xC0, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x78, 0x00, 0x30, 0xE0,
  0x01, 0xE0, 0x03, 0x8E, 0x00, 0x07, 0x80, 0x38, 0x70, 0x00, 0x1F, 0x03,
  0xC3, 0x00, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 11, 48, 39, 14, -48 },
  { 67, 14, 14, 39, 16, -50 },
  { 92, 39, 48, 39, 1, -48 },
  { 326, 33, 62, 39, 4, -55 },
  { 582, 32, 49, 39, 4, -48 },
  { 778, 33, 49, 39, 3, -48 },
  { 981, 5, 14, 39, 19, -50 },
  { 990, 20, 68, 39, 12, -53 },
  { 1160, 21, 68, 39, 6, -53 },
  { 1339, 28, 28, 39, 9, -48 },
  { 1437, 32, 34, 39, 4, -39 },
  { 1573, 8, 15, 39, 8, -6 },
  { 1588, 23, 3, 39, 8, -23 },
  { 1597, 5, 5, 39, 15, -5 },
  { 1601, 31, 52, 39, 5, -48 },
  { 1803, 31, 49, 39, 5, -48 },
  { 1993, 18, 48, 39, 10, -48 },
  { 2101, 32, 48, 39, 1, -48 },
  { 2293, 32, 49, 39, 2, -48 },
  { 2489, 32, 48, 39, 2, -48 },
  { 2681, 33, 49, 39, 6, -48 },
  { 2884, 29, 49, 39, 4, -48 },
  { 3062, 30, 48, 39, 8, -48 },
  { 3242, 33, 49, 39, 4, -48 },
  { 3445, 28, 48, 39, 7, -48 },
  { 3613, 10, 34, 39, 17, -34 },
  { 3656, 14, 43, 39, 13, -34 },
  { 3732, 30, 27, 39, 5, -35 },
  { 3834, 31, 16, 39, 5, -30 },
  { 3896, 30, 27, 39, 4, -35 },
  { 3998, 25, 48, 39, 10, -48 },
  { 4148, 37, 48, 39, 2, -48 },
  { 4370, 33, 48, 39, 0, -48 },
  { 4568, 33, 48, 39, 3, -48 },
  { 4766, 33, 49, 39, 4, -48 },
  { 4969, 34, 48, 39, 3, -48 },
  { 5173, 35, 48, 39, 3, -48 },
  { 5383, 35, 48, 39, 4, -48 },
  { 5593, 33, 49, 39, 4, -48 },
  { 5796, 37, 48, 39, 2, -48 },
  { 6018, 34, 48, 39, 3, -48 },
  { 6222, 35, 49, 39, 2, -48 },
  { 6437, 38, 48, 39, 3, -48 },
  { 6665, 27, 48, 39, 4, -48 },
  { 6827, 37, 48, 39, 2, -48 },
  { 7049, 37, 48, 39, 2, -48 },
  { 7271, 32, 49, 39, 4, -48 },
  { 7467, 35, 48, 39, 4, -48 },
  { 7677, 34, 56, 39, 3, -48 },
  { 7915, 34, 48, 39, 3, -48 },
  { 8119, 34, 49, 39, 3, -48 },
  { 8328, 33, 48, 39, 8, -48 },
  { 8526, 35, 49, 39, 4, -48 },
  { 8741, 33, 48, 39, 7, -48 },
  { 8939, 35, 48, 39, 7, -48 },
  { 9149, 39, 48, 39, 1, -48 },
  { 9383, 33, 48, 39, 7, -48 },
  { 9581, 36, 48, 39, 1, -48 },
  { 9797, 20, 64, 39, 10, -54 },
  { 9957, 13, 52, 39, 13, -48 },
  { 10042, 21, 64, 39, 9, -54 },
  { 10210, 23, 26, 39, 8, -48 },
  { 10285, 28, 3, 39, 2, 0 },
  { 10296, 7, 8, 39, 20, -49 },
  { 10303, 31, 37, 39, 3, -36 },
  { 10447, 31, 51, 39, 3, -50 },
  { 10645, 29, 37, 39, 5, -36 },
  { 10780, 33, 51, 39, 5, -50 },
  { 10991, 31, 37, 39, 4, -36 },
  { 11135, 33, 51, 39, 8, -51 },
  { 11346, 32, 50, 39, 3, -36 },
  { 11546, 31, 50, 39, 3, -50 },
  { 11740, 27, 48, 39, 4, -48 },
  { 11902, 31, 62, 39, 0, -48 },
  { 12143, 32, 50, 39, 4, -50 },
  { 12343, 27, 50, 39, 4, -50 },
  { 12512, 39, 36, 39, -1, -36 },
  { 12688, 31, 36, 39, 3, -36 },
  { 12828, 31, 37, 39, 4, -36 },
  { 12972, 33, 50, 39, 1, -36 },
  { 13179, 30, 50, 39, 5, -36 },
  { 13367, 29, 36, 39, 8, -36 },
  { 13498, 30, 37, 39, 5, -36 },
  { 13637, 26, 46, 39, 8, -45 },
  { 13787, 30, 36, 39, 5, -35 },
  { 13922, 32, 35, 39, 6, -35 },
  { 14062, 35, 35, 39, 5, -35 },
  { 14216, 36, 35, 39, 1, -35 },
  { 14374, 40, 49, 39, -1, -35 },
  { 14619, 35, 35, 39, 1, -35 },
  { 14773, 26, 66, 39, 10, -52 },
  { 14988, 11, 58, 39, 14, -48 },
  { 15068, 26, 66, 39, 6, -52 },
  { 15283, 37, 12, 39, 1, -26 },
};

const GFXfont RobotoMono_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC67PT7B_H_
