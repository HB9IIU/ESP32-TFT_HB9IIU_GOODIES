#ifndef _ROBOTOMONO_EXTRALIGHTITALIC48PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x61,
  0xB0, 0xD8, 0x6C, 0x3C, 0x1E, 0x0B, 0x0D, 0x86, 0xC3, 0x41, 0x80, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC1, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0xC1, 0x0F, 0xFF, 0xFF, 0xE0, 0x02,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xFC, 0x00, 0x3E, 0x1E, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0x38, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x80, 0x3C, 0x03, 0xE7, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x63,
  0x80, 0x01, 0x83, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x06, 0x03, 0x30, 0x0C,
  0x06, 0x60, 0x18, 0x18, 0xC0, 0x20, 0x61, 0x80, 0xC1, 0x83, 0x01, 0x83,
  0x06, 0x03, 0x0C, 0x0C, 0x0C, 0x30, 0x0C, 0x30, 0x60, 0x1F, 0xE1, 0x80,
  0x1F, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x0F, 0x80, 0x18, 0x7F, 0x80, 0x61, 0xC3, 0x00,
  0xC3, 0x03, 0x03, 0x0C, 0x06, 0x0C, 0x18, 0x0C, 0x30, 0x20, 0x18, 0x60,
  0xC0, 0x31, 0x81, 0x80, 0x66, 0x03, 0x00, 0x8C, 0x06, 0x03, 0x10, 0x0C,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x81,
  0x80, 0x01, 0x87, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x18, 0x03, 0x18, 0x0C, 0x03, 0x30, 0x0E, 0x06, 0x30, 0x06,
  0x06, 0x60, 0x03, 0x0E, 0x60, 0x03, 0x8C, 0x60, 0x01, 0x9C, 0xC0, 0x00,
  0xD8, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x70, 0x01,
  0xF0, 0x38, 0x07, 0x98, 0x1E, 0x3E, 0x1C, 0x07, 0xF8, 0x0E, 0x6D, 0xB6,
  0xB6, 0xD8, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x00, 0xC0,
  0x5F, 0x06, 0x1F, 0x3E, 0x27, 0xE0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1B, 0x00, 0x01, 0x8C, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80,
  0x1C, 0x06, 0x01, 0xC0, 0x38, 0x0C, 0x00, 0xC0, 0x20, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0xC6, 0x33, 0x98, 0xCC, 0xE6, 0x00, 0xFF, 0xFF, 0x80, 0x5F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xC3, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xE0, 0x01, 0x81, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x78, 0xC0, 0x01, 0xF3, 0x00, 0x06, 0x66, 0x00, 0x18, 0xCC, 0x00, 0x63,
  0x18, 0x03, 0x86, 0x30, 0x0E, 0x0C, 0xC0, 0x38, 0x19, 0x80, 0xC0, 0x33,
  0x03, 0x00, 0x66, 0x1C, 0x01, 0x8C, 0x70, 0x03, 0x19, 0xC0, 0x06, 0x66,
  0x00, 0x0C, 0xD8, 0x00, 0x19, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x18, 0x01,
  0xC0, 0x18, 0x07, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18,
  0x03, 0xC0, 0xFE, 0x1E, 0x67, 0xC3, 0x38, 0x1A, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xC3, 0xC0, 0x0E, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x78, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x38,
  0x03, 0xC0, 0x0F, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0xD8, 0x00, 0x01, 0x98, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x60, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38,
  0x00, 0x60, 0x70, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x3C, 0x00, 0x09, 0xFF, 0x00, 0x1F, 0x87, 0xC0, 0x1E,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x7F, 0x80,
  0xCF, 0xDF, 0x06, 0xE0, 0x1C, 0x6C, 0x00, 0x63, 0xC0, 0x03, 0x9C, 0x00,
  0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0x58,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0xCE, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x07, 0x06, 0x00, 0x70, 0x18,
  0x07, 0x00, 0xF9, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xE1, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0xE0,
  0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x81, 0x80, 0x0E, 0x01, 0x80, 0x38, 0x01, 0xE7, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0x9F, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x07, 0x1C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x70, 0x38, 0x03, 0xC0, 0x3E, 0x3E, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x07, 0xC7, 0x80, 0xE0, 0x1C, 0x1C,
  0x00, 0xE1, 0x80, 0x06, 0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00,
  0xE6, 0x00, 0x1E, 0x30, 0x07, 0x63, 0x81, 0xE6, 0x1F, 0xF8, 0xC0, 0x7E,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x3C, 0x78, 0xE0, 0x00, 0x80, 0x70, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xF8, 0xF0,
  0x70, 0x0E, 0x38, 0x01, 0x8C, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0xE0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x10,
  0x30, 0x3F, 0x03, 0x0C, 0x0E, 0x70, 0x61, 0x83, 0x02, 0x0C, 0x60, 0xC0,
  0x41, 0x8C, 0x10, 0x18, 0x33, 0x06, 0x03, 0x06, 0x60, 0x80, 0x40, 0xC8,
  0x30, 0x18, 0x1B, 0x06, 0x03, 0x02, 0x61, 0x80, 0x40, 0x48, 0x30, 0x08,
  0x19, 0x06, 0x03, 0x03, 0x60, 0x80, 0x60, 0x4C, 0x10, 0x08, 0x09, 0x82,
  0x03, 0x03, 0x30, 0x40, 0xE0, 0x46, 0x08, 0x14, 0x18, 0xC1, 0x84, 0x86,
  0x18, 0x3F, 0x99, 0x81, 0x03, 0xC1, 0xE0, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xA0, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x10, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0x00, 0x3C, 0x03, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18, 0x07,
  0xC0, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x60, 0x03,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1E, 0x3E,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x06, 0x00, 0x78, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x01,
  0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0xF0, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x0C, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0xC0,
  0x1F, 0xFC, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x30, 0x30, 0x00, 0x70, 0x1C,
  0x01, 0xE0, 0x0F, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x03,
  0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x7E, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x00, 0xC0,
  0x30, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x67, 0x80, 0x00, 0x19, 0xF0,
  0x00, 0x03, 0x73, 0x00, 0x00, 0x7C, 0x60, 0x00, 0x0F, 0x06, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0x60, 0x03, 0x60, 0xD8, 0x01, 0xD8, 0x33, 0x00, 0x66, 0x0C, 0xC0,
  0x31, 0x03, 0x30, 0x0C, 0xC0, 0xCC, 0x06, 0x30, 0x63, 0x01, 0x8C, 0x18,
  0x40, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x60, 0x61, 0x8E, 0x18,
  0x18, 0x63, 0x06, 0x0C, 0x09, 0x81, 0x83, 0x03, 0x60, 0x60, 0xC0, 0xF0,
  0x18, 0x30, 0x3C, 0x0C, 0x0C, 0x0E, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0x60, 0x3C, 0x00, 0x0C, 0x0D, 0x80, 0x01, 0x81, 0x98, 0x00, 0x60, 0x33,
  0x00, 0x0C, 0x06, 0x60, 0x01, 0x80, 0xC6, 0x00, 0x30, 0x10, 0xC0, 0x06,
  0x06, 0x0C, 0x00, 0xC0, 0xC1, 0x80, 0x30, 0x18, 0x30, 0x06, 0x03, 0x03,
  0x00, 0xC0, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60,
  0x60, 0x18, 0x18, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x30, 0x60, 0x30, 0x06,
  0x0C, 0x0C, 0x00, 0x61, 0x81, 0x80, 0x0C, 0x30, 0x30, 0x01, 0x8C, 0x06,
  0x00, 0x19, 0x80, 0xC0, 0x03, 0x30, 0x18, 0x00, 0x66, 0x06, 0x00, 0x06,
  0xC0, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xE3, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x84, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x18,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x38, 0x0C, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x83, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x70,
  0x01, 0x80, 0x1C, 0x03, 0x80, 0x07, 0xCF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x70, 0x18, 0x01,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x38, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x38,
  0x01, 0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0xCF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03,
  0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x01, 0xE0, 0x0C, 0x00, 0xB0, 0x07, 0x00, 0xD8, 0x07, 0x80, 0x6C, 0x03,
  0xC0, 0x36, 0x01, 0xE0, 0x33, 0x01, 0xB0, 0x19, 0x80, 0xD8, 0x0C, 0xC0,
  0x6C, 0x0C, 0x60, 0x66, 0x06, 0x30, 0x33, 0x03, 0x18, 0x19, 0x81, 0x0C,
  0x18, 0xC1, 0x86, 0x0C, 0x60, 0xC3, 0x06, 0x30, 0x61, 0x86, 0x18, 0x60,
  0xC3, 0x0C, 0x30, 0x61, 0x06, 0x18, 0x31, 0x83, 0x18, 0x18, 0xC1, 0x8C,
  0x0C, 0x40, 0xC6, 0x06, 0x60, 0x62, 0x03, 0x30, 0x33, 0x01, 0xB0, 0x19,
  0x80, 0xD8, 0x0C, 0x80, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0x60, 0x1E, 0x01,
  0xB0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x30, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x01, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x40, 0x30, 0x18, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xD8, 0x01, 0x8C,
  0x01, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x04, 0x06, 0x06, 0x0C, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0xE0, 0x03,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x83, 0x0C, 0x18, 0x30, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0xC0, 0x03, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0x07, 0xE0, 0x18, 0xF0,
  0x00, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0xF3, 0x00, 0x0D, 0x8C, 0x01,
  0xCC, 0x7C, 0x7C, 0xE0, 0xFF, 0x87, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0xF8, 0x01, 0x9F, 0xF8, 0x0C, 0xE0, 0xF0, 0x36, 0x00, 0xE0,
  0xF0, 0x01, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC7, 0x00, 0x06, 0x1C, 0x00,
  0x38, 0x78, 0x01, 0xC1, 0xB0, 0x0E, 0x06, 0x79, 0xF0, 0x30, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF0, 0x38, 0x0E,
  0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x60, 0xC0, 0x07, 0x03, 0x00, 0x70, 0x0F, 0x3E, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x0C, 0x01,
  0xFF, 0x8C, 0x03, 0xC1, 0xCC, 0x07, 0x00, 0x6C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x70,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60,
  0x01, 0xE0, 0x30, 0x03, 0xC0, 0x38, 0x07, 0xC0, 0x1F, 0x3C, 0xC0, 0x0F,
  0xF8, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x0E, 0x01, 0xC0,
  0x1C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x02,
  0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x01, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x0F, 0x8F, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x08, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x8C, 0x07, 0x83, 0x98, 0x1C, 0x01,
  0xB0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x1E, 0x06, 0x00, 0x78, 0x0E, 0x01, 0xF0, 0x0F, 0x9E,
  0x60, 0x0F, 0xF8, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x60, 0x01, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x7C, 0x03, 0x0F, 0xFC, 0x0C, 0x70, 0x78, 0x33, 0x00, 0x60,
  0xD8, 0x01, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x70, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x08, 0x60, 0x00,
  0xE0, 0xC0, 0x03, 0x81, 0x80, 0x0E, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0x30, 0x1C, 0x00, 0x60, 0xE0, 0x00, 0xC3, 0x80, 0x01,
  0x8E, 0x00, 0x06, 0x38, 0x00, 0x0D, 0xF0, 0x00, 0x1F, 0x30, 0x00, 0x3C,
  0x70, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x01,
  0x81, 0x80, 0x03, 0x83, 0x00, 0x03, 0x06, 0x00, 0x03, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x0F, 0x01, 0xBF, 0xC7, 0xF8, 0x2E,
  0x19, 0xC3, 0x0F, 0x01, 0xE0, 0x31, 0xC0, 0x38, 0x06, 0x30, 0x06, 0x00,
  0xC6, 0x00, 0xC0, 0x18, 0xC0, 0x18, 0x03, 0x10, 0x03, 0x00, 0x66, 0x00,
  0xC0, 0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C,
  0x60, 0x0C, 0x01, 0x88, 0x01, 0x00, 0x33, 0x00, 0x60, 0x0C, 0x60, 0x0C,
  0x01, 0x8C, 0x01, 0x80, 0x31, 0x80, 0x30, 0x06, 0x30, 0x06, 0x00, 0xCC,
  0x00, 0x80, 0x19, 0x80, 0x30, 0x06, 0x30, 0x06, 0x00, 0xC6, 0x00, 0xC0,
  0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x30,
  0xFF, 0xC0, 0xC7, 0x07, 0x83, 0x30, 0x06, 0x0D, 0x80, 0x1C, 0x38, 0x00,
  0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x67, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0x30, 0x70, 0x00,
  0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03,
  0x30, 0x00, 0x1C, 0xE0, 0x00, 0x61, 0x80, 0x03, 0x07, 0x00, 0x18, 0x0E,
  0x01, 0xC0, 0x1F, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x07, 0x80, 0x04, 0x7F, 0xE0, 0x19, 0xC1, 0xE0, 0x36, 0x00, 0xC0, 0x78,
  0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x07,
  0x00, 0x0E, 0x0F, 0x00, 0x38, 0x1B, 0x00, 0xE0, 0x33, 0xCF, 0x80, 0xC3,
  0xFC, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE,
  0x30, 0x3C, 0x1C, 0xC1, 0xC0, 0x1B, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0x80, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x07, 0x83, 0x00, 0x3C, 0x0E, 0x01,
  0xF0, 0x1E, 0x7C, 0xC0, 0x3F, 0xE3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xF0, 0xC1, 0xFF, 0x0C, 0x7C, 0x10, 0xCE, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01,
  0x80, 0x0E, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x71, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x31, 0x80, 0x01, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x1F, 0x1F, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x7C,
  0x60, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00,
  0x3C, 0x70, 0x03, 0x61, 0xC0, 0x32, 0x07, 0x9F, 0x30, 0x1F, 0xE1, 0x80,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC3,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x36, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x18, 0x03, 0xE0, 0x0C, 0x01, 0xB0, 0x0E, 0x00, 0xD8, 0x05, 0x00,
  0xCC, 0x06, 0x80, 0x66, 0x03, 0x40, 0x63, 0x03, 0x20, 0x31, 0x81, 0x90,
  0x18, 0xC0, 0x88, 0x18, 0x60, 0xC6, 0x0C, 0x30, 0x63, 0x04, 0x18, 0x61,
  0x86, 0x0C, 0x30, 0xC3, 0x06, 0x10, 0x63, 0x03, 0x18, 0x31, 0x81, 0x88,
  0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x66, 0x06, 0x60, 0x36, 0x01, 0x20, 0x1B,
  0x00, 0xB0, 0x05, 0x00, 0x58, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x84, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xBC, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x03,
  0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xC7,
  0xFC, 0x00, 0x33, 0x03, 0x80, 0x09, 0x80, 0x70, 0x06, 0x60, 0x0E, 0x03,
  0x30, 0x01, 0xE1, 0xCC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoMono_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 9, 10, 28, 12, -36 },
  { 47, 28, 34, 28, 1, -34 },
  { 166, 23, 44, 28, 3, -39 },
  { 293, 23, 36, 28, 3, -35 },
  { 397, 24, 35, 28, 2, -35 },
  { 502, 3, 10, 28, 14, -36 },
  { 506, 15, 49, 28, 8, -38 },
  { 598, 15, 49, 28, 4, -38 },
  { 690, 21, 20, 28, 6, -34 },
  { 743, 23, 25, 28, 3, -28 },
  { 815, 5, 10, 28, 6, -4 },
  { 822, 17, 1, 28, 5, -16 },
  { 825, 3, 4, 28, 11, -4 },
  { 827, 22, 37, 28, 4, -34 },
  { 929, 23, 35, 28, 3, -35 },
  { 1030, 13, 34, 28, 7, -34 },
  { 1086, 23, 35, 28, 1, -35 },
  { 1187, 24, 35, 28, 1, -35 },
  { 1292, 24, 34, 28, 1, -34 },
  { 1394, 24, 35, 28, 4, -34 },
  { 1499, 21, 36, 28, 3, -35 },
  { 1594, 22, 34, 28, 6, -34 },
  { 1688, 23, 35, 28, 3, -35 },
  { 1789, 20, 35, 28, 5, -35 },
  { 1877, 7, 25, 28, 12, -25 },
  { 1899, 10, 31, 28, 9, -25 },
  { 1938, 21, 19, 28, 4, -25 },
  { 1988, 22, 11, 28, 3, -21 },
  { 2019, 21, 19, 28, 3, -25 },
  { 2069, 18, 35, 28, 7, -35 },
  { 2148, 27, 34, 28, 1, -34 },
  { 2263, 24, 34, 28, 0, -34 },
  { 2365, 24, 34, 28, 2, -34 },
  { 2467, 24, 36, 28, 3, -35 },
  { 2575, 24, 34, 28, 2, -34 },
  { 2677, 25, 34, 28, 2, -34 },
  { 2784, 25, 34, 28, 3, -34 },
  { 2891, 24, 36, 28, 3, -35 },
  { 2999, 27, 34, 28, 1, -34 },
  { 3114, 25, 34, 28, 2, -34 },
  { 3221, 25, 34, 28, 2, -34 },
  { 3328, 27, 34, 28, 2, -34 },
  { 3443, 19, 34, 28, 3, -34 },
  { 3524, 26, 34, 28, 2, -34 },
  { 3635, 27, 34, 28, 1, -34 },
  { 3750, 23, 35, 28, 3, -35 },
  { 3851, 25, 34, 28, 3, -34 },
  { 3958, 25, 41, 28, 2, -35 },
  { 4087, 24, 34, 28, 2, -34 },
  { 4189, 25, 35, 28, 2, -35 },
  { 4299, 23, 34, 28, 6, -34 },
  { 4397, 25, 34, 28, 3, -34 },
  { 4504, 24, 34, 28, 5, -34 },
  { 4606, 25, 34, 28, 5, -34 },
  { 4713, 29, 34, 28, 0, -34 },
  { 4837, 24, 34, 28, 5, -34 },
  { 4939, 25, 34, 28, 1, -34 },
  { 5046, 15, 46, 28, 7, -39 },
  { 5133, 9, 37, 28, 10, -34 },
  { 5175, 14, 46, 28, 7, -39 },
  { 5256, 16, 18, 28, 6, -34 },
  { 5292, 20, 2, 28, 1, 0 },
  { 5297, 6, 6, 28, 14, -35 },
  { 5302, 21, 27, 28, 3, -26 },
  { 5373, 22, 37, 28, 2, -36 },
  { 5475, 21, 27, 28, 3, -26 },
  { 5546, 24, 36, 28, 3, -36 },
  { 5654, 22, 26, 28, 3, -26 },
  { 5726, 23, 37, 28, 6, -37 },
  { 5833, 23, 36, 28, 2, -26 },
  { 5937, 22, 36, 28, 2, -36 },
  { 6036, 20, 34, 28, 3, -34 },
  { 6121, 22, 44, 28, 0, -34 },
  { 6242, 23, 36, 28, 3, -36 },
  { 6346, 20, 36, 28, 3, -36 },
  { 6436, 27, 26, 28, 0, -26 },
  { 6524, 22, 26, 28, 2, -26 },
  { 6596, 22, 27, 28, 3, -26 },
  { 6671, 23, 36, 28, 1, -26 },
  { 6775, 22, 36, 28, 3, -26 },
  { 6874, 20, 26, 28, 6, -26 },
  { 6939, 22, 26, 28, 3, -26 },
  { 7011, 18, 33, 28, 6, -32 },
  { 7086, 21, 25, 28, 4, -25 },
  { 7152, 23, 25, 28, 4, -25 },
  { 7224, 25, 25, 28, 4, -25 },
  { 7303, 26, 25, 28, 1, -25 },
  { 7385, 29, 35, 28, -1, -25 },
  { 7512, 25, 25, 28, 1, -25 },
  { 7591, 19, 47, 28, 7, -37 },
  { 7703, 8, 41, 28, 10, -34 },
  { 7744, 19, 47, 28, 4, -37 },
  { 7856, 26, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC48PT7B_H_
