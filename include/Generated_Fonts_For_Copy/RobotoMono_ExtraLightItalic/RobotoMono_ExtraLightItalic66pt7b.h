#ifndef _ROBOTOMONO_EXTRALIGHTITALIC66PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x70, 0x00,
  0x38, 0x19, 0xC0, 0xCC, 0x06, 0x60, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xCE,
  0x06, 0x60, 0x33, 0x03, 0x98, 0x1D, 0xC0, 0xCE, 0x06, 0x60, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x70, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x38, 0x60,
  0x03, 0x00, 0x70, 0xE0, 0x03, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0xC0, 0xE0,
  0x07, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0xE0, 0x06, 0x03, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0x60, 0x1C, 0x0C, 0x00, 0x70,
  0x38, 0x1C, 0x00, 0x3C, 0xF0, 0x38, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x0F,
  0x80, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0xF8, 0x00, 0x1C, 0x0F, 0x3C, 0x00,
  0x38, 0x1C, 0x0E, 0x00, 0x30, 0x38, 0x06, 0x00, 0x70, 0x70, 0x06, 0x00,
  0xE0, 0x70, 0x07, 0x00, 0xC0, 0x60, 0x07, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0xE0, 0x07, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x06, 0x0E,
  0x00, 0xC0, 0x06, 0x1C, 0x00, 0xC0, 0x0E, 0x38, 0x00, 0xC0, 0x0E, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x70, 0xF0,
  0x1E, 0x00, 0x30, 0x70, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x1C, 0x70,
  0x00, 0xE0, 0x0E, 0x38, 0x00, 0x38, 0x0E, 0x38, 0x00, 0x0E, 0x07, 0x1C,
  0x00, 0x07, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x8E, 0x00, 0x00, 0xF3, 0x87,
  0x00, 0x00, 0x39, 0xC3, 0x80, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x07, 0xE0,
  0x60, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x01, 0xF8,
  0x07, 0x00, 0x01, 0xEE, 0x03, 0xC0, 0x03, 0xE3, 0x80, 0xF8, 0x07, 0xC1,
  0xC0, 0x1F, 0xFF, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x18, 0xCE, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x2E, 0x00, 0x60, 0x0E, 0xFC, 0x06,
  0x07, 0xFF, 0xF0, 0x61, 0xFE, 0x0F, 0xEE, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x10, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x38, 0x70, 0x70, 0xE0, 0x40, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x3F,
  0x38, 0x00, 0x01, 0xEC, 0xE0, 0x00, 0x0E, 0x73, 0x80, 0x00, 0x71, 0xCC,
  0x00, 0x03, 0x87, 0x30, 0x00, 0x3C, 0x1D, 0xC0, 0x01, 0xE0, 0x77, 0x00,
  0x0E, 0x01, 0xDC, 0x00, 0x70, 0x06, 0x70, 0x03, 0x80, 0x39, 0x80, 0x3C,
  0x00, 0xE6, 0x01, 0xE0, 0x03, 0xB8, 0x0E, 0x00, 0x0E, 0xE0, 0x70, 0x00,
  0x3B, 0x83, 0x80, 0x00, 0xCE, 0x3C, 0x00, 0x07, 0x39, 0xE0, 0x00, 0x1C,
  0xEF, 0x00, 0x00, 0x73, 0x70, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x3F, 0x38, 0x7E, 0x1D, 0xFC, 0x0D, 0xF0, 0x0E, 0xE0, 0x07, 0x40,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0x80,
  0x0F, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x07, 0xE0, 0x00, 0x0E, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x80,
  0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0xE0, 0xFF,
  0xF0, 0x07, 0x1F, 0xFF, 0xC0, 0x31, 0xE0, 0x1F, 0x03, 0xBC, 0x00, 0x3C,
  0x1F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x00,
  0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xF1, 0xC0, 0x00,
  0x1F, 0x0E, 0x00, 0x01, 0xD8, 0x38, 0x00, 0x1D, 0xC1, 0xE0, 0x03, 0xCE,
  0x07, 0xC0, 0x7C, 0x60, 0x1F, 0xFF, 0xC7, 0x00, 0x3F, 0xF8, 0x38, 0x00,
  0x3C, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x78,
  0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x18, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x00, 0x60, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x0C, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x0F, 0xF0,
  0x0C, 0x0E, 0x01, 0xFF, 0xC0, 0x60, 0x70, 0x1E, 0x0F, 0x03, 0x07, 0x01,
  0xC0, 0x30, 0x18, 0x30, 0x1C, 0x01, 0x80, 0xC3, 0x80, 0xE0, 0x0C, 0x06,
  0x18, 0x0E, 0x00, 0xC0, 0x31, 0xC0, 0x60, 0x06, 0x01, 0x8E, 0x07, 0x00,
  0x30, 0x0C, 0x60, 0x30, 0x01, 0x80, 0x67, 0x03, 0x80, 0x18, 0x03, 0x30,
  0x18, 0x00, 0xC0, 0x39, 0x80, 0xC0, 0x06, 0x01, 0x8C, 0x0E, 0x00, 0x70,
  0x0C, 0xE0, 0x70, 0x03, 0x00, 0x66, 0x03, 0x00, 0x18, 0x03, 0x30, 0x18,
  0x00, 0xC0, 0x39, 0x80, 0xC0, 0x0E, 0x01, 0x8C, 0x06, 0x00, 0x60, 0x0C,
  0x60, 0x70, 0x07, 0x00, 0xE3, 0x03, 0x80, 0x38, 0x06, 0x18, 0x1C, 0x03,
  0xC0, 0x70, 0xC0, 0x60, 0x36, 0x03, 0x06, 0x03, 0x03, 0xB0, 0x38, 0x30,
  0x1C, 0x39, 0x83, 0x81, 0x80, 0xFF, 0x8F, 0xF8, 0x0E, 0x03, 0xF8, 0x3F,
  0x80, 0x70, 0x06, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x1F,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x70,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x1C,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xFF, 0x1C, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x0F,
  0xFF, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x60, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x00, 0x18,
  0xFC, 0x00, 0x00, 0x01, 0xCF, 0x70, 0x00, 0x00, 0x0E, 0xF3, 0xC0, 0x00,
  0x00, 0x7F, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x1D, 0x80, 0x00, 0xE6, 0x01, 0x9C,
  0x00, 0x0E, 0xE0, 0x19, 0xC0, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x39, 0xC0, 0x03, 0x8C, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x38, 0xC0, 0x07,
  0x1C, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x30, 0xE0, 0x0E, 0x1C, 0x07, 0x0E,
  0x01, 0xC1, 0xC0, 0x70, 0x60, 0x1C, 0x18, 0x07, 0x06, 0x03, 0x81, 0x80,
  0x70, 0x70, 0x38, 0x38, 0x06, 0x07, 0x07, 0x03, 0x80, 0x60, 0x70, 0x70,
  0x38, 0x0E, 0x03, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0xC0, 0x30, 0x0E, 0x03,
  0x1C, 0x07, 0x00, 0xE0, 0x3B, 0x80, 0x70, 0x0C, 0x03, 0xB8, 0x07, 0x00,
  0xC0, 0x1F, 0x00, 0x70, 0x1C, 0x01, 0xF0, 0x07, 0x01, 0xC0, 0x1E, 0x00,
  0x60, 0x1C, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x06,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x0E, 0x01, 0xF8, 0x00,
  0x00, 0xE0, 0x1D, 0x80, 0x00, 0x0E, 0x01, 0x9C, 0x00, 0x00, 0xC0, 0x39,
  0xC0, 0x00, 0x0C, 0x03, 0x8E, 0x00, 0x01, 0xC0, 0x38, 0xE0, 0x00, 0x1C,
  0x03, 0x86, 0x00, 0x01, 0xC0, 0x30, 0x70, 0x00, 0x1C, 0x03, 0x07, 0x00,
  0x01, 0x80, 0x70, 0x30, 0x00, 0x18, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x38, 0x00, 0x38, 0x07, 0x01, 0x80, 0x03, 0x80, 0x60, 0x1C, 0x00, 0x38,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xC0,
  0x07, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x1C, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x1C, 0x00, 0x1C,
  0x0E, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x38, 0x00, 0x0E, 0x0C, 0x03, 0x80,
  0x00, 0xE1, 0xC0, 0x38, 0x00, 0x06, 0x1C, 0x03, 0x80, 0x00, 0x71, 0xC0,
  0x38, 0x00, 0x07, 0x1C, 0x03, 0x00, 0x00, 0x31, 0x80, 0x70, 0x00, 0x03,
  0x98, 0x07, 0x00, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x1F, 0x80, 0x60, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xF8, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0xC0,
  0x0C, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x07, 0xC0, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x1B, 0x80, 0x07, 0x00, 0x0E, 0xE0, 0x03,
  0xC0, 0x03, 0xB8, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x3E, 0x00, 0x33, 0x80,
  0x1F, 0x80, 0x1C, 0xE0, 0x07, 0xE0, 0x07, 0x38, 0x01, 0xB8, 0x01, 0x8E,
  0x00, 0xEE, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x38, 0xE0, 0x0C, 0xE0, 0x0C,
  0x38, 0x07, 0x38, 0x07, 0x0E, 0x01, 0x8E, 0x01, 0xC3, 0x80, 0x63, 0x80,
  0x60, 0xE0, 0x38, 0xE0, 0x18, 0x38, 0x0C, 0x38, 0x0E, 0x0C, 0x03, 0x0E,
  0x03, 0x83, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03, 0x01, 0x83, 0x80, 0xC1,
  0xC0, 0x60, 0xE0, 0x30, 0x70, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03,
  0x0E, 0x01, 0x87, 0x00, 0xC3, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x70, 0x06, 0x38, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x33, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x30, 0x01,
  0x98, 0x00, 0xDC, 0x00, 0x66, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0D, 0x80,
  0x06, 0xE0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x38, 0x00, 0x0C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x60, 0x70, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0,
  0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x81, 0xF8, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x30, 0x78, 0x00, 0x00, 0xC3,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x07,
  0xB8, 0x3C, 0x00, 0x3C, 0xE0, 0x7C, 0x07, 0xE3, 0x80, 0xFF, 0xFE, 0x0E,
  0x01, 0xFF, 0xE0, 0x38, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x01, 0x00, 0x00, 0xE0, 0xFF, 0xC0, 0x03, 0x8F, 0xFF, 0xC0,
  0x0C, 0x7C, 0x0F, 0x80, 0x33, 0x80, 0x0F, 0x00, 0xDC, 0x00, 0x1C, 0x07,
  0xE0, 0x00, 0x38, 0x1F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x1C,
  0x07, 0x70, 0x01, 0xE0, 0x18, 0xF0, 0x1F, 0x00, 0x61, 0xFF, 0xF8, 0x03,
  0x81, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x1E,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x1F, 0xF8, 0x18, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0xF8, 0x1F, 0x38, 0x03,
  0xE0, 0x07, 0x38, 0x07, 0x80, 0x01, 0xB8, 0x07, 0x00, 0x01, 0xF8, 0x0E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x3C, 0x00, 0x7B, 0x00, 0x1F, 0x01, 0xE7, 0x00, 0x0F,
  0xFF, 0xC7, 0x00, 0x07, 0xFF, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE6, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xC0, 0x03,
  0xFF, 0xE0, 0xC0, 0x03, 0xE0, 0x7C, 0xE0, 0x07, 0xC0, 0x0F, 0x70, 0x03,
  0x80, 0x01, 0xB8, 0x03, 0x80, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x0F, 0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x1E, 0x70, 0x00, 0x7F,
  0xFE, 0x38, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x80, 0x00, 0xE0, 0x3F, 0xE0, 0x03, 0x03, 0xFF, 0xE0, 0x0C, 0x3E, 0x07,
  0xC0, 0x71, 0xE0, 0x07, 0x81, 0xCE, 0x00, 0x0E, 0x07, 0x60, 0x00, 0x1C,
  0x1F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x06, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x0C, 0x3C, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x1D, 0xFC, 0x00,
  0x00, 0x1F, 0xCE, 0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x1F, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x80, 0x01, 0x00, 0x0E, 0x3F, 0xC0, 0x7F, 0x80,
  0x39, 0xFF, 0xC3, 0xFF, 0x00, 0xCE, 0x0F, 0x3C, 0x1E, 0x03, 0x60, 0x1F,
  0xC0, 0x3C, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x01, 0xC1,
  0xE0, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x60, 0x00, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x00, 0x07, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x00, 0x60, 0xE0, 0x01, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x30,
  0x00, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x01, 0xC1, 0x80,
  0x03, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x00,
  0x60, 0xE0, 0x01, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x30, 0x00, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x80, 0x03,
  0x87, 0x00, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x70, 0x00,
  0xE0, 0x01, 0xC1, 0x80, 0x03, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x0E, 0x03, 0xFE,
  0x00, 0x30, 0x3F, 0xFE, 0x00, 0xC3, 0xE0, 0x7C, 0x07, 0x1C, 0x00, 0x78,
  0x1C, 0xE0, 0x00, 0xE0, 0x76, 0x00, 0x01, 0xC1, 0xB0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0xFF, 0xC0, 0x00,
  0xE3, 0xFF, 0xF0, 0x00, 0xC7, 0xC0, 0xF8, 0x00, 0xCE, 0x00, 0x3C, 0x01,
  0xDC, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x1D,
  0xC0, 0x07, 0x80, 0x19, 0xF0, 0x1F, 0x00, 0x38, 0x7F, 0xFE, 0x00, 0x38,
  0x3F, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x70, 0x07, 0xFF, 0xE1, 0x80, 0x3E, 0x07, 0xCE, 0x03, 0xE0,
  0x07, 0xB8, 0x0E, 0x00, 0x06, 0xE0, 0x70, 0x00, 0x1F, 0x83, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0x7C,
  0x07, 0x9C, 0x00, 0xFF, 0xFC, 0x70, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x38, 0x07, 0xFF, 0x03, 0x81, 0xFF, 0xF0, 0x38, 0x7F,
  0x03, 0x03, 0x8F, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0F, 0x81, 0xC0, 0x00,
  0x7E, 0x07, 0x00, 0x03, 0xB8, 0x0E, 0x00, 0x1C, 0xC0, 0x3E, 0x03, 0xE3,
  0x00, 0x7F, 0xFF, 0x1C, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0E, 0xE0, 0x03, 0xC0,
  0x03, 0xB8, 0x00, 0xF8, 0x00, 0xCE, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x1B,
  0x80, 0x1C, 0xE0, 0x06, 0xE0, 0x06, 0x38, 0x03, 0xB8, 0x03, 0x8E, 0x00,
  0xC6, 0x00, 0xC3, 0x80, 0x71, 0x80, 0x70, 0xE0, 0x18, 0x60, 0x1C, 0x38,
  0x0E, 0x18, 0x06, 0x06, 0x03, 0x86, 0x03, 0x81, 0x80, 0xC1, 0x80, 0xC0,
  0x60, 0x70, 0x60, 0x70, 0x18, 0x18, 0x18, 0x1C, 0x06, 0x0E, 0x06, 0x06,
  0x01, 0x83, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x70, 0xC0, 0x18, 0x70, 0x1C,
  0x30, 0x06, 0x18, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x33, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xDC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x0F, 0xDF, 0x80, 0x00, 0x71,
  0xE0, 0x3C, 0x00, 0x06, 0x3C, 0x01, 0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x00,
  0x0E, 0x70, 0x00, 0x78, 0x01, 0xC7, 0x00, 0x03, 0xE0, 0x38, 0x60, 0x00,
  0x0F, 0xFF, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 12, 47, 39, 13, -47 },
  { 72, 13, 14, 39, 16, -50 },
  { 95, 38, 47, 39, 1, -47 },
  { 319, 32, 61, 39, 4, -54 },
  { 563, 32, 49, 39, 4, -48 },
  { 759, 33, 49, 39, 3, -48 },
  { 962, 5, 14, 39, 19, -50 },
  { 971, 20, 67, 39, 11, -52 },
  { 1139, 20, 67, 39, 6, -52 },
  { 1307, 28, 27, 39, 9, -47 },
  { 1402, 32, 34, 39, 4, -39 },
  { 1538, 8, 15, 39, 8, -6 },
  { 1553, 24, 3, 39, 7, -23 },
  { 1562, 5, 5, 39, 15, -5 },
  { 1566, 31, 51, 39, 5, -47 },
  { 1764, 30, 49, 39, 5, -48 },
  { 1948, 17, 47, 39, 10, -47 },
  { 2048, 32, 48, 39, 1, -48 },
  { 2240, 32, 49, 39, 2, -48 },
  { 2436, 32, 47, 39, 2, -47 },
  { 2624, 32, 48, 39, 6, -47 },
  { 2816, 29, 48, 39, 4, -47 },
  { 2990, 30, 47, 39, 8, -47 },
  { 3167, 32, 49, 39, 4, -48 },
  { 3363, 29, 48, 39, 6, -48 },
  { 3537, 11, 33, 39, 16, -33 },
  { 3583, 15, 42, 39, 12, -33 },
  { 3662, 30, 27, 39, 5, -35 },
  { 3764, 31, 16, 39, 4, -29 },
  { 3826, 30, 27, 39, 4, -35 },
  { 3928, 25, 48, 39, 10, -48 },
  { 4078, 37, 47, 39, 2, -47 },
  { 4296, 32, 47, 39, 0, -47 },
  { 4484, 33, 47, 39, 3, -47 },
  { 4678, 32, 49, 39, 4, -48 },
  { 4874, 33, 47, 39, 3, -47 },
  { 5068, 35, 47, 39, 3, -47 },
  { 5274, 34, 47, 39, 4, -47 },
  { 5474, 33, 49, 39, 4, -48 },
  { 5677, 36, 47, 39, 2, -47 },
  { 5889, 34, 47, 39, 3, -47 },
  { 6089, 34, 48, 39, 2, -47 },
  { 6293, 37, 47, 39, 3, -47 },
  { 6511, 27, 47, 39, 4, -47 },
  { 6670, 36, 47, 39, 2, -47 },
  { 6882, 36, 47, 39, 2, -47 },
  { 7094, 32, 49, 39, 4, -48 },
  { 7290, 34, 47, 39, 4, -47 },
  { 7490, 34, 56, 39, 3, -48 },
  { 7728, 33, 47, 39, 3, -47 },
  { 7922, 34, 49, 39, 3, -48 },
  { 8131, 32, 47, 39, 8, -47 },
  { 8319, 34, 48, 39, 4, -47 },
  { 8523, 33, 47, 39, 7, -47 },
  { 8717, 34, 47, 39, 7, -47 },
  { 8917, 39, 47, 39, 1, -47 },
  { 9147, 33, 47, 39, 7, -47 },
  { 9341, 35, 47, 39, 1, -47 },
  { 9547, 20, 64, 39, 10, -54 },
  { 9707, 13, 51, 39, 13, -47 },
  { 9790, 20, 64, 39, 9, -54 },
  { 9950, 23, 26, 39, 8, -47 },
  { 10025, 27, 3, 39, 2, 0 },
  { 10036, 8, 9, 39, 19, -49 },
  { 10045, 30, 37, 39, 3, -36 },
  { 10184, 30, 51, 39, 3, -50 },
  { 10376, 29, 37, 39, 5, -36 },
  { 10511, 32, 51, 39, 5, -50 },
  { 10715, 30, 37, 39, 4, -36 },
  { 10854, 32, 50, 39, 8, -50 },
  { 11054, 33, 50, 39, 2, -36 },
  { 11261, 30, 50, 39, 3, -50 },
  { 11449, 27, 47, 39, 4, -47 },
  { 11608, 30, 61, 39, 0, -47 },
  { 11837, 32, 50, 39, 4, -50 },
  { 12037, 27, 50, 39, 4, -50 },
  { 12206, 38, 36, 39, -1, -36 },
  { 12377, 30, 36, 39, 3, -36 },
  { 12512, 30, 37, 39, 4, -36 },
  { 12651, 32, 49, 39, 1, -36 },
  { 12847, 30, 49, 39, 5, -36 },
  { 13031, 28, 36, 39, 8, -36 },
  { 13157, 30, 37, 39, 4, -36 },
  { 13296, 25, 45, 39, 8, -44 },
  { 13437, 30, 36, 39, 5, -35 },
  { 13572, 31, 35, 39, 6, -35 },
  { 13708, 34, 35, 39, 5, -35 },
  { 13857, 36, 35, 39, 1, -35 },
  { 14015, 40, 49, 39, -1, -35 },
  { 14260, 34, 35, 39, 1, -35 },
  { 14409, 26, 66, 39, 10, -52 },
  { 14624, 12, 57, 39, 13, -47 },
  { 14710, 25, 65, 39, 6, -51 },
  { 14914, 36, 11, 39, 1, -25 },
};

const GFXfont RobotoMono_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC66PT7B_H_
