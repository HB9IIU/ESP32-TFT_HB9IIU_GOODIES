#ifndef _ROBOTOMONO_EXTRALIGHTITALIC51PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x3C, 0x0C, 0x00, 0x30, 0x66, 0x18, 0xC3, 0x30, 0x66,
  0x0C, 0xC1, 0x98, 0x23, 0x0C, 0x41, 0x98, 0x30, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x03, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x87,
  0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x03, 0xC0,
  0x0F, 0x9F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x31, 0x80, 0x60, 0x30, 0x80, 0x20, 0x30, 0xC0,
  0x30, 0x18, 0x60, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x06, 0x0C, 0x0C,
  0x06, 0x0C, 0x03, 0x03, 0x0C, 0x01, 0x87, 0x0E, 0x00, 0x7F, 0x06, 0x00,
  0x1E, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x83, 0xE0, 0x01, 0x87, 0xF8, 0x01, 0x83,
  0x06, 0x01, 0x83, 0x03, 0x00, 0xC3, 0x00, 0x80, 0xC1, 0x80, 0x60, 0xC0,
  0xC0, 0x30, 0x60, 0xC0, 0x10, 0x60, 0x60, 0x18, 0x60, 0x30, 0x0C, 0x70,
  0x18, 0x06, 0x30, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x18,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x70, 0x60, 0x0C, 0x70, 0x18, 0x06, 0x70, 0x0E, 0x03,
  0x30, 0x03, 0x03, 0xB8, 0x01, 0xC1, 0x98, 0x00, 0x70, 0xCC, 0x00, 0x18,
  0xC6, 0x00, 0x0E, 0xE3, 0x00, 0x03, 0x61, 0x80, 0x00, 0xF0, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x18, 0x00, 0x76, 0x0F, 0x00, 0xE3, 0x83, 0xF7,
  0xE0, 0xC0, 0x7F, 0xC0, 0x70, 0x02, 0x00, 0x00, 0x76, 0x66, 0x66, 0xCC,
  0xCC, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x02, 0x00, 0xC0, 0x3E, 0x06, 0x0F, 0xFC, 0x23, 0xF8, 0xFD, 0x7E, 0x00,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x60,
  0x00, 0xC1, 0x80, 0x0C, 0x0E, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xC0, 0xE0,
  0x07, 0x02, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x63, 0x84, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x27, 0xF7, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xC3,
  0xC0, 0x0E, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x39,
  0x80, 0x00, 0xF3, 0x00, 0x03, 0xEE, 0x00, 0x0C, 0xD8, 0x00, 0x31, 0xB0,
  0x01, 0xC3, 0x60, 0x07, 0x06, 0xC0, 0x1C, 0x0D, 0x80, 0x60, 0x37, 0x01,
  0x80, 0x6C, 0x0E, 0x00, 0xD8, 0x38, 0x01, 0xB0, 0xE0, 0x03, 0x63, 0x00,
  0x0E, 0xCC, 0x00, 0x19, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0x67, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x70, 0x00, 0x60,
  0x60, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFB, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x1F,
  0x77, 0xC3, 0x78, 0x1A, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0xF8, 0x7C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x06, 0x03, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30,
  0x70, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x78, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03,
  0x00, 0xE0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0x60, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x63, 0xF8, 0x00, 0x37, 0xFF, 0x00, 0x1F,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xE0, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0xEF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x7C, 0x01, 0x8F,
  0xFC, 0x0C, 0xF8, 0x78, 0x37, 0x00, 0x70, 0xF0, 0x00, 0xE7, 0x80, 0x01,
  0x9C, 0x00, 0x06, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x19, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x03, 0xEF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x0F, 0x00, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x18, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x1C, 0x0E,
  0x00, 0x30, 0x70, 0x00, 0xE1, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x98, 0x00, 0x1E, 0x70, 0x00, 0xD8, 0xE0, 0x06,
  0xC1, 0xC0, 0x73, 0x03, 0xFF, 0x8C, 0x07, 0xF8, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x06, 0x0E, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x00, 0xC0, 0x38, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x10, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xC0, 0x3E, 0x1E, 0x0E, 0x00, 0xC3, 0x80, 0x0C, 0xE0,
  0x01, 0x98, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x01, 0xF0, 0x30,
  0x30, 0x3F, 0xC0, 0x83, 0x03, 0x83, 0x06, 0x18, 0x38, 0x18, 0x31, 0x81,
  0x80, 0x81, 0x8C, 0x18, 0x0C, 0x0C, 0xC1, 0x80, 0x60, 0x46, 0x0C, 0x02,
  0x02, 0x30, 0x40, 0x10, 0x13, 0x06, 0x01, 0x81, 0x98, 0x30, 0x0C, 0x0C,
  0xC1, 0x80, 0x40, 0x64, 0x18, 0x06, 0x02, 0x60, 0xC0, 0x30, 0x33, 0x06,
  0x01, 0x81, 0x98, 0x30, 0x18, 0x08, 0xC1, 0x81, 0xC0, 0xC6, 0x0C, 0x0A,
  0x06, 0x30, 0x60, 0xD0, 0x61, 0x81, 0x8C, 0xC6, 0x04, 0x0F, 0xC7, 0xE0,
  0x30, 0x38, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xC0, 0x0F,
  0x80, 0x60, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x78, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x01, 0xF3, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x01,
  0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x38, 0x03, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xF6, 0x00, 0x7F, 0xF3,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x3C, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x70, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x01, 0x9F,
  0x00, 0x00, 0x1B, 0xB8, 0x00, 0x03, 0xF1, 0x80, 0x00, 0x3E, 0x0C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30,
  0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x70, 0x0C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x06, 0xC0, 0x03, 0x60, 0x6C, 0x00,
  0x76, 0x06, 0xC0, 0x06, 0x60, 0x6C, 0x00, 0xEC, 0x0C, 0xC0, 0x0C, 0xC0,
  0xC6, 0x01, 0xCC, 0x0C, 0x60, 0x18, 0xC0, 0xC6, 0x03, 0x0C, 0x0C, 0x60,
  0x31, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0x30, 0xE1, 0x81, 0x83, 0x0C, 0x18,
  0x18, 0x31, 0xC1, 0x81, 0x83, 0x18, 0x18, 0x18, 0x33, 0x83, 0x01, 0x83,
  0x30, 0x30, 0x30, 0x1E, 0x03, 0x03, 0x01, 0xE0, 0x30, 0x30, 0x1C, 0x03,
  0x03, 0x01, 0xC0, 0x70, 0x30, 0x18, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1E, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x30,
  0x6C, 0x00, 0x0C, 0x0D, 0x80, 0x01, 0x81, 0xB0, 0x00, 0x30, 0x73, 0x00,
  0x06, 0x0C, 0x60, 0x00, 0xC1, 0x8C, 0x00, 0x18, 0x30, 0xC0, 0x06, 0x06,
  0x18, 0x00, 0xC0, 0xC3, 0x80, 0x18, 0x38, 0x30, 0x03, 0x06, 0x06, 0x00,
  0x60, 0xC0, 0x60, 0x1C, 0x18, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x60,
  0x18, 0x0C, 0x18, 0x03, 0x01, 0x83, 0x00, 0x60, 0x30, 0x60, 0x06, 0x0E,
  0x0C, 0x00, 0xC1, 0x81, 0x80, 0x1C, 0x30, 0x30, 0x01, 0x86, 0x0C, 0x00,
  0x30, 0xC1, 0x80, 0x03, 0x18, 0x30, 0x00, 0x67, 0x06, 0x00, 0x0C, 0xC0,
  0xC0, 0x00, 0xD8, 0x18, 0x00, 0x1B, 0x06, 0x00, 0x03, 0x60, 0xC0, 0x00,
  0x3C, 0x18, 0x00, 0x07, 0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0xF0, 0x0C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38,
  0x30, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x0F,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0x60,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x78, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x38,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x18,
  0x00, 0x38, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x0E, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x68, 0x01, 0xC0, 0x19, 0x00, 0x38, 0x03,
  0x20, 0x0F, 0x00, 0x6C, 0x01, 0xE0, 0x19, 0x80, 0x3C, 0x03, 0x30, 0x0D,
  0x80, 0x66, 0x01, 0xB0, 0x18, 0xC0, 0x36, 0x03, 0x18, 0x0C, 0xC0, 0x63,
  0x01, 0x98, 0x0C, 0x60, 0x33, 0x03, 0x0C, 0x0C, 0x60, 0x61, 0x81, 0x8C,
  0x0C, 0x30, 0x31, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18,
  0x30, 0xC3, 0x03, 0x0C, 0x18, 0x60, 0x61, 0x83, 0x0C, 0x0C, 0x30, 0x61,
  0x81, 0x8C, 0x0C, 0x60, 0x31, 0x81, 0x8C, 0x06, 0x70, 0x31, 0x80, 0xCC,
  0x06, 0x60, 0x19, 0x80, 0xCC, 0x03, 0x70, 0x09, 0x80, 0x6C, 0x01, 0x60,
  0x0D, 0x80, 0x2C, 0x01, 0xE0, 0x05, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8C, 0x00, 0x01,
  0x87, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x60, 0x01, 0x80,
  0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x06, 0x18,
  0x01, 0x86, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03,
  0x00, 0xE1, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x6E, 0x00,
  0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0x86, 0x0C, 0x30, 0x60,
  0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x1F, 0xFF, 0xC0, 0xFF, 0x83, 0x87, 0x80, 0x06, 0x1C, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x3C, 0x70, 0x01, 0xD8, 0x70, 0x0F,
  0x30, 0x7D, 0xF8, 0x60, 0x7F, 0xC0, 0xC0, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xFE, 0x00, 0xCF, 0xFF, 0x01,
  0xB8, 0x0F, 0x03, 0xC0, 0x06, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x67, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xE0, 0x01, 0xC3,
  0xE0, 0x07, 0x06, 0xE0, 0x1C, 0x0C, 0xFF, 0xF0, 0x18, 0x7F, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x78, 0x07, 0x03,
  0x80, 0x0E, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x80,
  0x7D, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xE1, 0xC0, 0x3F, 0xFC,
  0xC0, 0x3C, 0x07, 0x60, 0x38, 0x01, 0xB0, 0x38, 0x00, 0x78, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0xF0, 0x1C, 0x00, 0xD8, 0x07, 0x01, 0xD8,
  0x01, 0xF7, 0xCC, 0x00, 0x7F, 0x86, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x1F, 0x9F,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xE0, 0x20, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xC1,
  0x80, 0x7F, 0xF9, 0x80, 0x78, 0x0E, 0xC0, 0x70, 0x03, 0x60, 0x70, 0x00,
  0xF0, 0x30, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x01, 0xE0, 0x38, 0x01, 0xF0,
  0x0E, 0x01, 0xF8, 0x03, 0xEF, 0x98, 0x00, 0xFF, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x40, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x83,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x06, 0x3F, 0xFC, 0x06,
  0x70, 0x1C, 0x0C, 0xC0, 0x0E, 0x0D, 0x80, 0x06, 0x0F, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0,
  0x0C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x03, 0x03, 0x80,
  0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x67, 0x00, 0x00, 0x37, 0xC0,
  0x00, 0x3F, 0x70, 0x00, 0x1F, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x03,
  0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0C,
  0x00, 0x0C, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0xFE, 0x0F, 0xE0, 0x6F, 0xF9, 0xFF, 0x83, 0xC0, 0xFC, 0x0C,
  0x1C, 0x03, 0xC0, 0x61, 0xC0, 0x1C, 0x01, 0x8E, 0x00, 0xC0, 0x0C, 0x60,
  0x06, 0x00, 0xE3, 0x00, 0x30, 0x06, 0x18, 0x03, 0x80, 0x30, 0xC0, 0x18,
  0x01, 0x8C, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x63, 0x00, 0x30, 0x03,
  0x18, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x01, 0x86, 0x00, 0xC0, 0x0C, 0x60,
  0x06, 0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x38, 0xC0, 0x0C,
  0x01, 0x86, 0x00, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x63, 0x00, 0x30, 0x03,
  0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0xE0, 0x0C, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xF0, 0x06, 0x3F, 0xFC, 0x06, 0x70, 0x1C,
  0x0C, 0xC0, 0x0E, 0x0D, 0x80, 0x06, 0x0F, 0x00, 0x06, 0x0E, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x38,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0E, 0x01, 0xE0, 0x38, 0x00, 0xC0,
  0xE0, 0x01, 0xC3, 0x80, 0x01, 0x8E, 0x00, 0x01, 0x98, 0x00, 0x03, 0x70,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCE, 0x00, 0x03,
  0x8C, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x1F, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x03, 0x0F, 0xF0,
  0x01, 0x9F, 0xFE, 0x00, 0xDC, 0x07, 0x00, 0xD8, 0x01, 0xC0, 0x78, 0x00,
  0x70, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x18,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xE0,
  0x37, 0x00, 0xE0, 0x19, 0xF7, 0xE0, 0x0C, 0x3F, 0xC0, 0x0E, 0x02, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x06, 0x07, 0xFF, 0x98, 0x1E,
  0x03, 0xB0, 0x70, 0x03, 0x61, 0xC0, 0x03, 0xC3, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x78, 0x38,
  0x01, 0xF0, 0x38, 0x07, 0xC0, 0x3E, 0xF9, 0x80, 0x3F, 0xE3, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x07, 0xFC, 0x18, 0x7F, 0xF0, 0x67, 0x80,
  0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xF0, 0x0E, 0x00, 0xF0, 0x38, 0x00, 0x60, 0xE0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x3F, 0xBF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xF7, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xE0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07,
  0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x38,
  0x00, 0x78, 0x30, 0x01, 0xB0, 0x70, 0x0E, 0x60, 0x7F, 0xF8, 0xC0, 0x7F,
  0xC3, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x00, 0x18,
  0x07, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x1F,
  0x00, 0x70, 0x06, 0xC0, 0x34, 0x01, 0xB0, 0x0D, 0x00, 0xCC, 0x02, 0x40,
  0x33, 0x01, 0x90, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C,
  0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x86, 0x0C,
  0x30, 0x61, 0x83, 0x0C, 0x18, 0xC0, 0x46, 0x06, 0x30, 0x11, 0x81, 0x8C,
  0x04, 0x40, 0x66, 0x01, 0xB0, 0x09, 0x80, 0x6C, 0x02, 0x60, 0x1E, 0x00,
  0xB0, 0x07, 0x80, 0x2C, 0x01, 0xC0, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0xE0, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x31, 0xFF, 0x80, 0x06, 0x38, 0x1C, 0x00, 0x67,
  0x00, 0xE0, 0x06, 0x60, 0x07, 0x00, 0xC6, 0x00, 0x38, 0x18, 0xC0, 0x01,
  0xFF, 0x04, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 9, 36, 30, 10, -36 },
  { 42, 11, 10, 30, 12, -38 },
  { 56, 29, 36, 30, 1, -36 },
  { 187, 25, 47, 30, 3, -42 },
  { 334, 25, 38, 30, 3, -37 },
  { 453, 25, 38, 30, 2, -37 },
  { 572, 4, 10, 30, 15, -38 },
  { 577, 15, 53, 30, 9, -41 },
  { 677, 15, 53, 30, 5, -41 },
  { 777, 21, 21, 30, 7, -36 },
  { 833, 25, 26, 30, 3, -30 },
  { 915, 6, 11, 30, 6, -4 },
  { 924, 18, 2, 30, 6, -17 },
  { 929, 4, 4, 30, 11, -4 },
  { 931, 24, 39, 30, 4, -36 },
  { 1048, 23, 38, 30, 4, -37 },
  { 1158, 13, 36, 30, 8, -36 },
  { 1217, 24, 37, 30, 1, -37 },
  { 1328, 25, 38, 30, 1, -37 },
  { 1447, 25, 36, 30, 1, -36 },
  { 1560, 25, 37, 30, 4, -36 },
  { 1676, 22, 38, 30, 3, -37 },
  { 1781, 23, 36, 30, 6, -36 },
  { 1885, 25, 38, 30, 3, -37 },
  { 2004, 22, 37, 30, 5, -37 },
  { 2106, 8, 26, 30, 13, -26 },
  { 2132, 11, 33, 30, 10, -26 },
  { 2178, 23, 21, 30, 4, -27 },
  { 2239, 24, 13, 30, 3, -23 },
  { 2278, 23, 21, 30, 3, -27 },
  { 2339, 19, 37, 30, 8, -37 },
  { 2427, 29, 37, 30, 1, -37 },
  { 2562, 25, 36, 30, 0, -36 },
  { 2675, 26, 36, 30, 2, -36 },
  { 2792, 25, 38, 30, 3, -37 },
  { 2911, 26, 36, 30, 2, -36 },
  { 3028, 27, 36, 30, 2, -36 },
  { 3150, 26, 36, 30, 3, -36 },
  { 3267, 25, 38, 30, 3, -37 },
  { 3386, 28, 36, 30, 1, -36 },
  { 3512, 27, 36, 30, 2, -36 },
  { 3634, 26, 37, 30, 2, -36 },
  { 3755, 28, 36, 30, 3, -36 },
  { 3881, 21, 36, 30, 3, -36 },
  { 3976, 28, 36, 30, 2, -36 },
  { 4102, 27, 36, 30, 2, -36 },
  { 4224, 25, 38, 30, 3, -37 },
  { 4343, 26, 36, 30, 3, -36 },
  { 4460, 25, 43, 30, 3, -37 },
  { 4595, 25, 36, 30, 3, -36 },
  { 4708, 25, 38, 30, 3, -37 },
  { 4827, 25, 36, 30, 6, -36 },
  { 4940, 26, 37, 30, 3, -36 },
  { 5061, 25, 36, 30, 6, -36 },
  { 5174, 27, 36, 30, 5, -36 },
  { 5296, 31, 36, 30, 0, -36 },
  { 5436, 25, 36, 30, 6, -36 },
  { 5549, 27, 36, 30, 1, -36 },
  { 5671, 15, 49, 30, 8, -41 },
  { 5763, 10, 39, 30, 10, -36 },
  { 5812, 16, 49, 30, 7, -41 },
  { 5910, 18, 19, 30, 6, -36 },
  { 5953, 22, 2, 30, 1, 0 },
  { 5959, 6, 7, 30, 15, -38 },
  { 5965, 23, 28, 30, 3, -27 },
  { 6046, 23, 39, 30, 3, -38 },
  { 6159, 22, 28, 30, 4, -27 },
  { 6236, 25, 39, 30, 4, -38 },
  { 6358, 23, 28, 30, 3, -27 },
  { 6439, 25, 39, 30, 6, -39 },
  { 6561, 25, 38, 30, 2, -27 },
  { 6680, 24, 38, 30, 2, -38 },
  { 6794, 21, 37, 30, 3, -37 },
  { 6892, 23, 48, 30, 0, -37 },
  { 7030, 25, 38, 30, 3, -38 },
  { 7149, 21, 38, 30, 3, -38 },
  { 7249, 29, 27, 30, 0, -27 },
  { 7347, 24, 27, 30, 2, -27 },
  { 7428, 23, 28, 30, 3, -27 },
  { 7509, 25, 37, 30, 1, -27 },
  { 7625, 23, 37, 30, 4, -27 },
  { 7732, 22, 27, 30, 6, -27 },
  { 7807, 23, 28, 30, 3, -27 },
  { 7888, 20, 35, 30, 6, -34 },
  { 7976, 23, 28, 30, 4, -27 },
  { 8057, 24, 27, 30, 5, -27 },
  { 8138, 26, 27, 30, 4, -27 },
  { 8226, 27, 27, 30, 1, -27 },
  { 8318, 31, 38, 30, -1, -27 },
  { 8466, 26, 27, 30, 1, -27 },
  { 8554, 20, 50, 30, 8, -40 },
  { 8679, 9, 44, 30, 10, -36 },
  { 8729, 20, 51, 30, 4, -40 },
  { 8857, 28, 8, 30, 1, -19 },
};

const GFXfont RobotoMono_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC51PT7B_H_
