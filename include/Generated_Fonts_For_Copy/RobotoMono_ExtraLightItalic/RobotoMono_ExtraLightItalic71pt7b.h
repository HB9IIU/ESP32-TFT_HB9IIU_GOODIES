#ifndef _ROBOTOMONO_EXTRALIGHTITALIC71PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x38,
  0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x06,
  0x38, 0x0C, 0x70, 0x38, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0x8E, 0x03, 0x1C,
  0x06, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x40, 0xC0, 0x07, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x0E,
  0x1C, 0x00, 0x70, 0x07, 0x06, 0x00, 0x1C, 0x01, 0xC1, 0x80, 0x06, 0x00,
  0xE0, 0x60, 0x01, 0x80, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x38,
  0x0E, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x60, 0x07, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x38, 0x00, 0x3F,
  0xF8, 0x0E, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x70, 0x3F, 0xF0, 0x00, 0x38,
  0x1E, 0x1E, 0x00, 0x1C, 0x0E, 0x03, 0x80, 0x06, 0x03, 0x00, 0x70, 0x03,
  0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x38, 0x00, 0xC0,
  0x38, 0x0E, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x0C, 0x0E, 0x01, 0xC0, 0x03,
  0x03, 0x80, 0x70, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x00,
  0x1C, 0x70, 0x01, 0xC0, 0x06, 0x1C, 0x00, 0x70, 0x03, 0x82, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0x00,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x01, 0xC3, 0xC0, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x1E,
  0x00, 0x3C, 0x01, 0xC7, 0x80, 0x03, 0x80, 0x38, 0xE0, 0x00, 0x38, 0x07,
  0x3C, 0x00, 0x07, 0x81, 0xC7, 0x00, 0x00, 0x70, 0x38, 0xE0, 0x00, 0x07,
  0x0F, 0x1C, 0x00, 0x00, 0xE1, 0xC3, 0x80, 0x00, 0x0E, 0x70, 0x70, 0x00,
  0x01, 0xFE, 0x0E, 0x00, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x07, 0xF8,
  0x0F, 0x00, 0x01, 0xE7, 0x80, 0xF0, 0x00, 0xF8, 0x70, 0x0F, 0xC0, 0x7E,
  0x0F, 0x00, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x31, 0xC7, 0x1C,
  0x61, 0x8E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x05, 0xC0, 0x06, 0x00, 0x77, 0xC0, 0x38, 0x0F, 0xFF, 0xE0, 0xE0, 0xFF,
  0x1F, 0xF3, 0x9F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83, 0x83, 0x80, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3E, 0x38,
  0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x3F, 0x8E, 0x00, 0x00, 0x39, 0xC7,
  0x00, 0x00, 0x38, 0xE7, 0x00, 0x00, 0x78, 0x73, 0x80, 0x00, 0x78, 0x39,
  0xC0, 0x00, 0x78, 0x18, 0xE0, 0x00, 0x78, 0x1C, 0x70, 0x00, 0x70, 0x0E,
  0x38, 0x00, 0xF0, 0x07, 0x38, 0x00, 0xF0, 0x03, 0x9C, 0x00, 0xF0, 0x01,
  0xCE, 0x00, 0xF0, 0x00, 0xC7, 0x00, 0xE0, 0x00, 0xE3, 0x81, 0xE0, 0x00,
  0x71, 0x81, 0xE0, 0x00, 0x39, 0xC1, 0xE0, 0x00, 0x1C, 0xE1, 0xE0, 0x00,
  0x0E, 0x71, 0xC0, 0x00, 0x0E, 0x39, 0xC0, 0x00, 0x07, 0x1F, 0xC0, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0x9C, 0x3F, 0x83, 0x1F, 0xC0,
  0xE7, 0xE0, 0x1C, 0xE0, 0x03, 0x90, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0x1F, 0xE0, 0x00, 0x03, 0x9F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x02, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0F,
  0xF8, 0x00, 0x70, 0x7F, 0xFC, 0x01, 0xC3, 0xFF, 0xFC, 0x03, 0x9F, 0x00,
  0x7C, 0x07, 0x78, 0x00, 0x3C, 0x1D, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00,
  0x38, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80,
  0x01, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x8E,
  0x00, 0x00, 0x7E, 0x3C, 0x00, 0x03, 0xB8, 0x70, 0x00, 0x3D, 0xC1, 0xF0,
  0x03, 0xE7, 0x03, 0xF0, 0x7E, 0x1C, 0x07, 0xFF, 0xF0, 0x60, 0x07, 0xFF,
  0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x7F, 0x00, 0x70, 0x38, 0x03, 0xFF, 0x80, 0xE0, 0x70, 0x0F,
  0x87, 0x80, 0xC1, 0xC0, 0x3C, 0x07, 0x01, 0x87, 0x00, 0xE0, 0x0C, 0x03,
  0x0E, 0x03, 0x80, 0x18, 0x06, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x70, 0x1C,
  0x00, 0xE0, 0x18, 0xC0, 0x30, 0x01, 0x80, 0x33, 0x80, 0xE0, 0x03, 0x00,
  0x67, 0x01, 0x80, 0x0E, 0x01, 0xCC, 0x07, 0x00, 0x1C, 0x03, 0xB8, 0x0E,
  0x00, 0x30, 0x07, 0x70, 0x18, 0x00, 0x60, 0x0C, 0xC0, 0x70, 0x01, 0xC0,
  0x19, 0x80, 0xE0, 0x03, 0x00, 0x37, 0x01, 0x80, 0x06, 0x00, 0xEE, 0x03,
  0x00, 0x0C, 0x01, 0x9C, 0x06, 0x00, 0x38, 0x03, 0x30, 0x1C, 0x00, 0x60,
  0x06, 0x60, 0x38, 0x01, 0xC0, 0x1C, 0xC0, 0x70, 0x03, 0x80, 0x31, 0x80,
  0xE0, 0x0F, 0x00, 0xE3, 0x01, 0xC0, 0x3E, 0x01, 0x86, 0x03, 0x80, 0xEC,
  0x07, 0x0C, 0x07, 0x03, 0x98, 0x1C, 0x18, 0x07, 0x0E, 0x30, 0x70, 0x38,
  0x0F, 0xF8, 0x7B, 0xE0, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xE0, 0x0F, 0x00,
  0x7C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x0E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x03, 0xE0, 0x0E, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x8E, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x01, 0xF8, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xF9, 0xC0, 0x00, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x00, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x1F,
  0xC0, 0x00, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0x00, 0x1D, 0xF3, 0x80, 0x00,
  0x00, 0x3F, 0x87, 0x80, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x1D, 0x80, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x76,
  0x00, 0x00, 0xEE, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x07,
  0x38, 0x07, 0x38, 0x00, 0x1C, 0x60, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x1C,
  0x60, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x38, 0x30, 0x07,
  0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x01,
  0xC0, 0x60, 0xF0, 0x38, 0x03, 0x80, 0xC1, 0xC0, 0x70, 0x07, 0x01, 0xC7,
  0x00, 0xE0, 0x0E, 0x03, 0x8E, 0x01, 0xC0, 0x38, 0x07, 0x38, 0x03, 0x80,
  0x70, 0x0E, 0x70, 0x07, 0x00, 0xE0, 0x0D, 0xC0, 0x1C, 0x01, 0xC0, 0x1F,
  0x80, 0x38, 0x03, 0x80, 0x3E, 0x00, 0x70, 0x06, 0x00, 0x78, 0x00, 0xE0,
  0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x00, 0x18, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x00, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x3F, 0x00,
  0x00, 0x07, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x00, 0x38,
  0x03, 0x9C, 0x00, 0x00, 0x70, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x30, 0x00, 0x03, 0x80, 0x70, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x0E,
  0x00, 0x03, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x70, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x0E, 0x00, 0x00,
  0x71, 0xC0, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x70, 0x00, 0x01, 0xCE, 0x01, 0xC0, 0x00, 0x01, 0xB8, 0x03, 0x80, 0x00,
  0x03, 0xF0, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xC0,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x06,
  0x00, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x0C, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x3B, 0x00, 0x03, 0x80, 0x01, 0xD8, 0x00, 0x1C, 0x00, 0x0C,
  0xC0, 0x01, 0xE0, 0x00, 0xE6, 0x00, 0x0F, 0x00, 0x07, 0x30, 0x00, 0x78,
  0x00, 0x31, 0x80, 0x07, 0xC0, 0x03, 0x8C, 0x00, 0x3F, 0x00, 0x1C, 0x60,
  0x01, 0xB8, 0x00, 0xE3, 0x00, 0x1D, 0xC0, 0x0E, 0x18, 0x00, 0xEE, 0x00,
  0x70, 0xC0, 0x0E, 0x70, 0x03, 0x86, 0x00, 0x73, 0x80, 0x18, 0x30, 0x03,
  0x9C, 0x01, 0xC1, 0x80, 0x38, 0xE0, 0x0E, 0x0C, 0x01, 0xC7, 0x00, 0x60,
  0x60, 0x0E, 0x38, 0x07, 0x03, 0x00, 0xE1, 0xC0, 0x38, 0x18, 0x07, 0x0E,
  0x01, 0xC0, 0xC0, 0x38, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x70,
  0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x01, 0xC0, 0xC0, 0x38, 0x38,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x70, 0x0E, 0x0C, 0x01, 0x83, 0x80,
  0x70, 0xE0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03,
  0x0E, 0x00, 0xE3, 0x80, 0x18, 0x60, 0x07, 0x1C, 0x00, 0xC7, 0x00, 0x38,
  0xC0, 0x06, 0x38, 0x01, 0xCE, 0x00, 0x31, 0x80, 0x0E, 0x70, 0x01, 0x9C,
  0x00, 0x73, 0x00, 0x0C, 0xE0, 0x03, 0xB8, 0x00, 0x66, 0x00, 0x1D, 0xC0,
  0x03, 0x70, 0x00, 0xEC, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0xDC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x1C, 0x1F,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0x78,
  0x00, 0x0F, 0x70, 0x7C, 0x00, 0x3C, 0x70, 0x3F, 0x01, 0xF8, 0x70, 0x1F,
  0xFF, 0xE0, 0x70, 0x07, 0xFF, 0x80, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0x00, 0x03, 0x87, 0xFF, 0xC0, 0x03, 0x0F, 0xFF, 0xF0, 0x07,
  0x3E, 0x00, 0xF8, 0x07, 0x78, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x03, 0xC0, 0xEE,
  0x00, 0x07, 0x80, 0xE7, 0x00, 0x1F, 0x00, 0xE3, 0xE0, 0x7E, 0x00, 0xE1,
  0xFF, 0xFC, 0x00, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x27, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x1F, 0xFF, 0x07, 0x00, 0x0F, 0xFF,
  0xF0, 0xE0, 0x03, 0xE0, 0x0F, 0x1C, 0x00, 0xF8, 0x00, 0x77, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x3F,
  0x00, 0x3C, 0x00, 0x0E, 0xC0, 0x03, 0xC0, 0x07, 0x98, 0x00, 0x3E, 0x07,
  0xE7, 0x00, 0x03, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0xF8, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x31, 0xE0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCE, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x40, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x70, 0x01, 0xFF, 0xFE, 0x1C,
  0x00, 0xF8, 0x03, 0xC7, 0x00, 0x7C, 0x00, 0x3B, 0x80, 0x3C, 0x00, 0x07,
  0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x03, 0xE0, 0x0E, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0xEC, 0x00,
  0x78, 0x00, 0xF7, 0x00, 0x0F, 0x81, 0xF9, 0xC0, 0x01, 0xFF, 0xF8, 0x70,
  0x00, 0x3F, 0xF8, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x10, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x7F, 0xC0, 0x01, 0x80, 0xFF, 0xF8, 0x01, 0xC1, 0xFF, 0xFE, 0x00,
  0xE1, 0xE0, 0x0F, 0x80, 0x71, 0xC0, 0x01, 0xC0, 0x39, 0xC0, 0x00, 0xF0,
  0x19, 0x80, 0x00, 0x38, 0x0D, 0x80, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x30, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0x03, 0x80, 0xF8, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x0E, 0x7E,
  0x00, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0x0F,
  0xE1, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC3, 0xF8, 0x03, 0xF8,
  0x00, 0xC7, 0xFF, 0x07, 0xFF, 0x00, 0xE7, 0xFF, 0x87, 0xFF, 0xC0, 0x77,
  0x01, 0xE7, 0x01, 0xE0, 0x3F, 0x00, 0x77, 0x00, 0x70, 0x1F, 0x00, 0x3F,
  0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x07, 0x80, 0x03, 0x80, 0x03, 0x83, 0x80, 0x03, 0x80, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x30, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x80, 0x01, 0x81,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x30, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x3F, 0xE0, 0x01, 0xC0, 0x7F, 0xFC, 0x00, 0xE0, 0xFF, 0xFF, 0x00, 0x70,
  0xF0, 0x07, 0xC0, 0x39, 0xE0, 0x01, 0xE0, 0x1D, 0xE0, 0x00, 0x78, 0x0C,
  0xC0, 0x00, 0x1C, 0x0E, 0xC0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x1F, 0xE0, 0x00, 0x0C, 0x1F, 0xFF,
  0x00, 0x01, 0x87, 0xFF, 0xF0, 0x00, 0x73, 0xE0, 0x0F, 0x00, 0x0E, 0xF0,
  0x00, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x78, 0x03, 0xB8, 0x00, 0x1E, 0x00, 0x77, 0x80, 0x0F,
  0x80, 0x0E, 0x7C, 0x07, 0xE0, 0x01, 0xC3, 0xFF, 0xF8, 0x00, 0x78, 0x3F,
  0xFC, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x1F, 0xFF, 0x07,
  0x00, 0x7F, 0xFF, 0x87, 0x00, 0xF8, 0x03, 0xC7, 0x01, 0xF0, 0x00, 0xEE,
  0x03, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0E, 0xC0, 0x1E, 0x00, 0x3D, 0xC0,
  0x0F, 0x80, 0xF9, 0xC0, 0x07, 0xFF, 0xE1, 0xC0, 0x03, 0xFF, 0xC1, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xFC,
  0x0E, 0x03, 0xFF, 0xF0, 0x38, 0x3F, 0xFF, 0xC0, 0xE1, 0xF8, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x40, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x0F, 0x70, 0x0F, 0x80, 0x0F,
  0x38, 0x03, 0xE0, 0x3F, 0x18, 0x00, 0xFF, 0xFE, 0x1C, 0x00, 0x1F, 0xFC,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0x00, 0x07, 0x70,
  0x00, 0x78, 0x00, 0x31, 0x80, 0x07, 0xC0, 0x03, 0x8C, 0x00, 0x36, 0x00,
  0x1C, 0x60, 0x03, 0xB0, 0x01, 0xC3, 0x00, 0x19, 0xC0, 0x0E, 0x18, 0x01,
  0xCE, 0x00, 0x70, 0xC0, 0x0E, 0x70, 0x07, 0x07, 0x00, 0x63, 0x80, 0x38,
  0x38, 0x07, 0x1C, 0x01, 0x81, 0xC0, 0x30, 0xE0, 0x1C, 0x0E, 0x03, 0x87,
  0x00, 0xE0, 0x70, 0x1C, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0xC0, 0x70, 0x1C,
  0x0E, 0x06, 0x03, 0x00, 0xE0, 0x60, 0x30, 0x38, 0x07, 0x07, 0x01, 0x81,
  0xC0, 0x38, 0x30, 0x0C, 0x1C, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x0E, 0x1C,
  0x03, 0x86, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x1C, 0x60, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x01,
  0xCC, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x37, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x1F, 0xFF, 0x00,
  0x00, 0x38, 0x78, 0x1F, 0x00, 0x00, 0x61, 0xE0, 0x0F, 0x00, 0x01, 0xC7,
  0x80, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x38, 0x00, 0x0F,
  0x00, 0x38, 0x70, 0x00, 0x0F, 0x81, 0xF0, 0xC0, 0x00, 0x0F, 0xFF, 0xC3,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 13, 50, 42, 14, -50 },
  { 83, 15, 15, 42, 17, -53 },
  { 112, 41, 50, 42, 1, -50 },
  { 369, 34, 65, 42, 5, -58 },
  { 646, 34, 52, 42, 4, -51 },
  { 867, 35, 52, 42, 3, -51 },
  { 1095, 6, 15, 42, 20, -53 },
  { 1107, 22, 72, 42, 12, -56 },
  { 1305, 22, 72, 42, 6, -56 },
  { 1503, 30, 29, 42, 9, -50 },
  { 1612, 34, 37, 42, 4, -42 },
  { 1770, 9, 16, 42, 8, -6 },
  { 1788, 25, 3, 42, 8, -24 },
  { 1798, 5, 5, 42, 16, -5 },
  { 1802, 33, 54, 42, 5, -50 },
  { 2025, 33, 52, 42, 5, -51 },
  { 2240, 19, 50, 42, 11, -50 },
  { 2359, 34, 51, 42, 1, -51 },
  { 2576, 34, 52, 42, 2, -51 },
  { 2797, 35, 50, 42, 2, -50 },
  { 3016, 35, 51, 42, 6, -50 },
  { 3240, 31, 52, 42, 4, -51 },
  { 3442, 32, 50, 42, 9, -50 },
  { 3642, 35, 52, 42, 4, -51 },
  { 3870, 30, 52, 42, 7, -51 },
  { 4065, 11, 35, 42, 18, -35 },
  { 4114, 16, 45, 42, 13, -35 },
  { 4204, 31, 28, 42, 6, -37 },
  { 4313, 33, 17, 42, 5, -31 },
  { 4384, 32, 28, 42, 4, -37 },
  { 4496, 26, 51, 42, 11, -51 },
  { 4662, 39, 51, 42, 2, -51 },
  { 4911, 35, 50, 42, 0, -50 },
  { 5130, 35, 50, 42, 3, -50 },
  { 5349, 35, 52, 42, 4, -51 },
  { 5577, 36, 50, 42, 3, -50 },
  { 5802, 38, 50, 42, 3, -50 },
  { 6040, 37, 50, 42, 4, -50 },
  { 6272, 35, 52, 42, 4, -51 },
  { 6500, 39, 50, 42, 2, -50 },
  { 6744, 37, 50, 42, 3, -50 },
  { 6976, 36, 51, 42, 3, -50 },
  { 7206, 39, 50, 42, 4, -50 },
  { 7450, 29, 50, 42, 4, -50 },
  { 7632, 39, 50, 42, 2, -50 },
  { 7876, 39, 50, 42, 2, -50 },
  { 8120, 35, 52, 42, 4, -51 },
  { 8348, 37, 50, 42, 4, -50 },
  { 8580, 36, 60, 42, 4, -51 },
  { 8850, 35, 50, 42, 4, -50 },
  { 9069, 36, 52, 42, 4, -51 },
  { 9303, 35, 50, 42, 8, -50 },
  { 9522, 37, 51, 42, 4, -50 },
  { 9758, 35, 51, 42, 8, -51 },
  { 9982, 37, 50, 42, 7, -50 },
  { 10214, 42, 51, 42, 1, -51 },
  { 10482, 35, 51, 42, 8, -51 },
  { 10706, 38, 50, 42, 1, -50 },
  { 10944, 21, 69, 42, 11, -58 },
  { 11126, 14, 55, 42, 14, -51 },
  { 11223, 21, 69, 42, 10, -58 },
  { 11405, 24, 27, 42, 9, -50 },
  { 11486, 30, 3, 42, 2, 0 },
  { 11498, 8, 9, 42, 21, -52 },
  { 11507, 32, 39, 42, 4, -38 },
  { 11663, 32, 54, 42, 4, -53 },
  { 11879, 31, 39, 42, 5, -38 },
  { 12031, 35, 54, 42, 5, -53 },
  { 12268, 33, 39, 42, 4, -38 },
  { 12429, 34, 54, 42, 9, -54 },
  { 12659, 34, 53, 42, 3, -38 },
  { 12885, 33, 53, 42, 3, -53 },
  { 13104, 29, 51, 42, 4, -51 },
  { 13289, 33, 66, 42, 0, -51 },
  { 13562, 35, 53, 42, 4, -53 },
  { 13794, 29, 53, 42, 4, -53 },
  { 13987, 41, 38, 42, -1, -38 },
  { 14182, 33, 38, 42, 3, -38 },
  { 14339, 33, 39, 42, 4, -38 },
  { 14500, 35, 52, 42, 1, -38 },
  { 14728, 32, 52, 42, 5, -38 },
  { 14936, 30, 38, 42, 9, -38 },
  { 15079, 32, 39, 42, 5, -38 },
  { 15235, 27, 48, 42, 9, -47 },
  { 15397, 33, 39, 42, 5, -38 },
  { 15558, 34, 38, 42, 6, -38 },
  { 15720, 37, 38, 42, 5, -38 },
  { 15896, 38, 38, 42, 1, -38 },
  { 16077, 42, 53, 42, -1, -38 },
  { 16356, 36, 38, 42, 2, -38 },
  { 16527, 27, 70, 42, 11, -55 },
  { 16764, 13, 60, 42, 14, -50 },
  { 16862, 27, 70, 42, 6, -55 },
  { 17099, 39, 12, 42, 1, -27 },
};

const GFXfont RobotoMono_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC71PT7B_H_
