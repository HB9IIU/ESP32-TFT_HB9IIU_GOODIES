#ifndef _ROBOTOMONO_EXTRALIGHTITALIC29PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x45, 0x14, 0xF2, 0x8A, 0x20, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x30, 0x80, 0x10, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x7F, 0xFE, 0x02,
  0x18, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x21, 0x03, 0xFF, 0xF8, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10,
  0x06, 0x10, 0x02, 0x08, 0x00, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0xF8,
  0x06, 0x30, 0x20, 0x21, 0x00, 0x84, 0x03, 0x30, 0x0C, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x48, 0x01, 0x20, 0x04, 0xC0, 0x31, 0x00, 0x86, 0x0C, 0x0F, 0xE0, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x38, 0x01, 0x90, 0x04, 0x20, 0x20, 0x86,
  0x82, 0x12, 0x08, 0x88, 0x44, 0x21, 0x30, 0x78, 0x80, 0x84, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x78, 0x22, 0x21, 0x90, 0x44, 0x41, 0x21, 0x0D, 0x84,
  0x24, 0x10, 0x80, 0x46, 0x00, 0xF0, 0x01, 0xE0, 0x04, 0x60, 0x10, 0x40,
  0x60, 0x80, 0x81, 0x01, 0x06, 0x02, 0x18, 0x06, 0x60, 0x05, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0xC8, 0x03, 0x18, 0x6C, 0x10, 0x90, 0x31, 0x20, 0x26,
  0xC0, 0x29, 0x80, 0x61, 0x00, 0xC3, 0x06, 0x41, 0xF8, 0xC0, 0x69, 0x25,
  0x80, 0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x08,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x60, 0xC0, 0x80, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x82,
  0x1F, 0x6E, 0x0F, 0x00, 0xE0, 0x1A, 0x03, 0x10, 0x21, 0x84, 0x0C, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x3F,
  0xFF, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x33, 0x22, 0x4C, 0xFF, 0xC0, 0x7C, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xC0, 0x18, 0xC1, 0x81, 0x84, 0x02, 0x30, 0x08, 0x80, 0x26,
  0x01, 0xD0, 0x0A, 0x40, 0x49, 0x02, 0x24, 0x30, 0xB1, 0x82, 0x8C, 0x1A,
  0x40, 0x6A, 0x01, 0x30, 0x04, 0x80, 0x33, 0x00, 0x84, 0x04, 0x18, 0x20,
  0x3F, 0x00, 0x01, 0x07, 0x19, 0x63, 0x82, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x03,
  0xC0, 0x71, 0x86, 0x06, 0x60, 0x12, 0x00, 0x90, 0x05, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xE0,
  0x18, 0xC1, 0x80, 0x84, 0x03, 0x30, 0x0C, 0x80, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x78, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0xCC, 0x02, 0x18, 0x30, 0x3F, 0x80, 0x00,
  0x08, 0x00, 0x60, 0x02, 0x80, 0x1E, 0x00, 0xD0, 0x06, 0x40, 0x11, 0x00,
  0x84, 0x04, 0x30, 0x30, 0x81, 0x82, 0x04, 0x08, 0x20, 0x21, 0x00, 0x8F,
  0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x07, 0xFE, 0x1F, 0xF8, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x17, 0xC0, 0x70, 0xC0, 0x80, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x40, 0x08, 0x40, 0x10, 0x80, 0x61, 0x01, 0x81,
  0x06, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x3C, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x30, 0x4F, 0xC7, 0x02, 0xE0, 0x3C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x02, 0x40, 0x46, 0x0C, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x00, 0x03,
  0xE0, 0x18, 0xE0, 0x80, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12, 0x00, 0xCC,
  0x02, 0x10, 0x10, 0x61, 0x80, 0x78, 0x06, 0x18, 0x60, 0x11, 0x00, 0x48,
  0x01, 0xA0, 0x06, 0x80, 0x12, 0x00, 0x4C, 0x02, 0x18, 0x30, 0x3F, 0x80,
  0x07, 0x81, 0x86, 0x30, 0x26, 0x03, 0x40, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x34, 0x07, 0x60, 0xA3, 0xF2, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x78, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x06, 0x08, 0x10, 0x41, 0x80, 0x00, 0x18, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x20, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x0F,
  0x83, 0x18, 0x81, 0xA0, 0x14, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xF0, 0x03, 0x9C, 0x04, 0x02, 0x08, 0x02,
  0x10, 0x41, 0x21, 0xF1, 0x22, 0x11, 0x44, 0x11, 0x44, 0x21, 0x88, 0x21,
  0x88, 0x22, 0x88, 0x42, 0x88, 0x42, 0x88, 0x42, 0x88, 0xC4, 0x89, 0x48,
  0x8E, 0x30, 0x80, 0x00, 0x40, 0x00, 0x20, 0x40, 0x1F, 0x80, 0x00, 0x20,
  0x00, 0x80, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44,
  0x02, 0x10, 0x08, 0x60, 0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0xFF,
  0x84, 0x02, 0x30, 0x0C, 0x80, 0x16, 0x00, 0x50, 0x01, 0xC0, 0x04, 0x0F,
  0xC0, 0x1F, 0xF0, 0x20, 0x30, 0xC0, 0x21, 0x00, 0x62, 0x00, 0xC4, 0x01,
  0x08, 0x02, 0x10, 0x08, 0x60, 0x60, 0xFF, 0x81, 0x00, 0x82, 0x00, 0x84,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x08, 0x80, 0x31, 0x00, 0xC2, 0x03,
  0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x18, 0xC1, 0x80, 0x84, 0x02, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x84, 0x06,
  0x18, 0x30, 0x3F, 0x00, 0x0F, 0x80, 0x30, 0xE0, 0x60, 0x60, 0x80, 0x61,
  0x00, 0x42, 0x00, 0xC4, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x19, 0x00, 0x32, 0x00, 0x4C, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x18,
  0x80, 0x61, 0x01, 0x86, 0x0E, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0xFF, 0xC2, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x38, 0xC1, 0x80, 0x84,
  0x03, 0x20, 0x05, 0x80, 0x14, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x7E, 0x81, 0xFA, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x13,
  0x00, 0x44, 0x03, 0x18, 0x18, 0x1F, 0x80, 0x18, 0x01, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x3F, 0xFC, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80,
  0x10, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x40, 0x08, 0x80,
  0x11, 0x80, 0x61, 0x01, 0x83, 0x06, 0x03, 0xF8, 0x00, 0x08, 0x01, 0x84,
  0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0x81, 0x80, 0x41, 0x00,
  0x21, 0x00, 0x11, 0x00, 0x19, 0x00, 0x09, 0xC0, 0x05, 0x20, 0x03, 0x18,
  0x01, 0x04, 0x00, 0x81, 0x00, 0xC0, 0xC0, 0x40, 0x20, 0x20, 0x18, 0x10,
  0x04, 0x08, 0x03, 0x0C, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x0F, 0xFE, 0x18,
  0x03, 0x18, 0x03, 0x1C, 0x07, 0x14, 0x0E, 0x14, 0x0A, 0x14, 0x1A, 0x34,
  0x12, 0x24, 0x36, 0x22, 0x24, 0x22, 0x44, 0x22, 0x44, 0x22, 0x84, 0x63,
  0x84, 0x43, 0x0C, 0x41, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0,
  0x08, 0x80, 0x18, 0x80, 0x10, 0x18, 0x03, 0x18, 0x02, 0x18, 0x02, 0x14,
  0x02, 0x14, 0x02, 0x14, 0x02, 0x32, 0x06, 0x22, 0x04, 0x23, 0x04, 0x21,
  0x04, 0x21, 0x04, 0x21, 0x84, 0x60, 0x8C, 0x40, 0x88, 0x40, 0x48, 0x40,
  0x48, 0x40, 0x68, 0xC0, 0x28, 0xC0, 0x38, 0x80, 0x30, 0x80, 0x10, 0x03,
  0xC0, 0x39, 0xC1, 0x81, 0x84, 0x02, 0x20, 0x08, 0x80, 0x34, 0x00, 0x50,
  0x01, 0x40, 0x07, 0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x01, 0xA0, 0x04, 0x80, 0x32, 0x00, 0x84, 0x04, 0x18, 0x20, 0x3F, 0x00,
  0x1F, 0xC0, 0x20, 0xF0, 0x40, 0x30, 0x80, 0x21, 0x00, 0x66, 0x00, 0xC8,
  0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x11, 0x80, 0xC3, 0xFF, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x30, 0xC0, 0x21,
  0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x34, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x21, 0x80, 0xC1, 0x83, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x0F, 0xE0, 0x10, 0xF0, 0x20, 0x30, 0x40, 0x21, 0x80,
  0x62, 0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x04, 0x60, 0x10, 0x80, 0x41,
  0xFF, 0x02, 0x04, 0x04, 0x08, 0x08, 0x18, 0x30, 0x10, 0x40, 0x20, 0x80,
  0x61, 0x00, 0x42, 0x00, 0xCC, 0x00, 0x80, 0x01, 0xF0, 0x0E, 0x30, 0x30,
  0x10, 0xC0, 0x31, 0x00, 0x22, 0x00, 0x44, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x20,
  0x06, 0x40, 0x0C, 0x80, 0x11, 0x80, 0x61, 0x81, 0x81, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x30, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x98, 0x03, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26,
  0x00, 0x48, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x31, 0x00,
  0x41, 0x01, 0x03, 0x06, 0x03, 0xF0, 0x00, 0xC0, 0x07, 0x00, 0x14, 0x00,
  0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x03, 0x18, 0x08, 0x20, 0x60, 0x81,
  0x02, 0x0C, 0x08, 0x20, 0x21, 0x80, 0x84, 0x03, 0x30, 0x04, 0x80, 0x12,
  0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x81, 0x03, 0x02, 0x06,
  0x0C, 0x14, 0x18, 0x28, 0x30, 0x50, 0xA1, 0xA1, 0x42, 0x42, 0x84, 0x89,
  0x19, 0x12, 0x22, 0x24, 0x44, 0x88, 0x89, 0x1A, 0x12, 0x34, 0x28, 0x68,
  0x50, 0x70, 0xE0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x04, 0x08, 0x08, 0x00,
  0x08, 0x00, 0x86, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0x40, 0x20, 0x40, 0x10,
  0x60, 0x0C, 0x60, 0x02, 0x20, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x16, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x18, 0x20, 0x08, 0x10,
  0x08, 0x04, 0x0C, 0x02, 0x0C, 0x01, 0x8C, 0x00, 0x40, 0xC0, 0x05, 0x00,
  0x34, 0x00, 0x98, 0x04, 0x20, 0x30, 0x80, 0x83, 0x04, 0x04, 0x30, 0x10,
  0x80, 0x44, 0x00, 0xB0, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x83, 0xC3, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x1F, 0x00, 0x84, 0x21,
  0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x18, 0x42, 0x10, 0x86, 0x10, 0x84,
  0x20, 0x0F, 0x87, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x02, 0x01, 0x80,
  0x60, 0x24, 0x09, 0x04, 0x41, 0x10, 0x86, 0x60, 0x90, 0x2C, 0x0A, 0x03,
  0xFF, 0xF0, 0x89, 0x80, 0x03, 0x00, 0x7F, 0x04, 0x0C, 0x40, 0x26, 0x01,
  0x80, 0x08, 0x00, 0x40, 0xFE, 0x38, 0x13, 0x00, 0xB0, 0x0D, 0x00, 0x48,
  0x02, 0x40, 0x33, 0x06, 0x8F, 0xC4, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x08, 0x05, 0xFC, 0x1C, 0x18, 0x60, 0x23,
  0x00, 0x88, 0x03, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x88, 0x02, 0x60, 0x09,
  0x00, 0x64, 0x01, 0x18, 0x08, 0x70, 0x63, 0x3E, 0x00, 0x03, 0x00, 0x7F,
  0x06, 0x0C, 0x60, 0x26, 0x01, 0xA0, 0x05, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x6C, 0x02, 0x20, 0x31, 0x83, 0x07, 0xE0, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x30, 0x83,
  0xF2, 0x18, 0x28, 0x80, 0x66, 0x01, 0x90, 0x04, 0x40, 0x13, 0x00, 0x48,
  0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x8C, 0x02, 0x10, 0x18, 0x60, 0xA0,
  0xFD, 0x80, 0x01, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x26, 0x00, 0xA0, 0x07,
  0x00, 0x3F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x10, 0x81, 0x83, 0xF0, 0x00, 0xFC, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x3F, 0xF8, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x1F, 0x90, 0xC1,
  0x44, 0x03, 0x30, 0x0C, 0x80, 0x22, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00,
  0x64, 0x01, 0x10, 0x04, 0x60, 0x10, 0x80, 0xC3, 0x05, 0x07, 0xEC, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x20, 0x30, 0x61, 0x80, 0xFC, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x06, 0x04, 0xFC,
  0x14, 0x08, 0xE0, 0x23, 0x00, 0xC8, 0x03, 0x20, 0x08, 0x80, 0x22, 0x00,
  0x98, 0x02, 0x60, 0x09, 0x00, 0x64, 0x01, 0x10, 0x04, 0x40, 0x13, 0x00,
  0x40, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x30, 0x3F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x4C, 0x06, 0x20, 0x30, 0x83, 0x02, 0x18,
  0x08, 0xC0, 0x66, 0x01, 0x70, 0x07, 0x40, 0x18, 0x80, 0x43, 0x01, 0x06,
  0x0C, 0x08, 0x20, 0x30, 0x80, 0x62, 0x00, 0xC0, 0x1F, 0xC0, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0x03, 0x0C, 0x2F, 0x9F, 0x30, 0xE1, 0x20,
  0xC1, 0x20, 0xC1, 0x20, 0x81, 0x60, 0x81, 0x40, 0x81, 0x40, 0x83, 0x40,
  0x82, 0x41, 0x02, 0x41, 0x02, 0x81, 0x02, 0x81, 0x02, 0x81, 0x06, 0x83,
  0x04, 0x00, 0x40, 0x4F, 0xC1, 0x40, 0x8E, 0x02, 0x30, 0x0C, 0x80, 0x32,
  0x00, 0x88, 0x02, 0x20, 0x09, 0x80, 0x24, 0x00, 0x90, 0x06, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x30, 0x04, 0x03, 0x00, 0x7F, 0x04, 0x0C, 0x40, 0x24,
  0x01, 0xA0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00,
  0x28, 0x02, 0x60, 0x31, 0x83, 0x07, 0xE0, 0x00, 0x40, 0x17, 0xF0, 0x38,
  0x30, 0x40, 0x21, 0x80, 0x42, 0x00, 0xC4, 0x01, 0x88, 0x02, 0x10, 0x04,
  0x20, 0x08, 0xC0, 0x11, 0x00, 0x62, 0x00, 0x86, 0x02, 0x0E, 0x0C, 0x37,
  0xE0, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x7E, 0x46, 0x0A, 0x40, 0x36, 0x01, 0xA0, 0x09, 0x00,
  0x58, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x00, 0x4C, 0x02, 0x20, 0x31,
  0x82, 0x87, 0xEC, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x00, 0x62, 0x3F, 0x2C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x01, 0x80, 0x7F, 0x04, 0x04, 0x40, 0x12, 0x00, 0x90, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x60, 0x11,
  0x81, 0x87, 0xF0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x7E, 0x00, 0x20, 0x09, 0x00, 0x48, 0x02, 0xC0,
  0x34, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x16, 0x01, 0xA0, 0x09,
  0x80, 0x44, 0x06, 0x30, 0xD0, 0xFC, 0x80, 0x80, 0x0C, 0x00, 0xB0, 0x0C,
  0x80, 0x44, 0x06, 0x20, 0x21, 0x83, 0x04, 0x10, 0x21, 0x01, 0x08, 0x0C,
  0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x00, 0x81, 0x03, 0x06, 0x0E,
  0x0C, 0x14, 0x18, 0x28, 0x58, 0x98, 0x91, 0x32, 0x22, 0x64, 0x48, 0x48,
  0x90, 0xA1, 0x61, 0x42, 0x83, 0x05, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30,
  0x00, 0x30, 0x06, 0x30, 0x10, 0x20, 0x60, 0x21, 0x80, 0x66, 0x00, 0x58,
  0x00, 0xE0, 0x01, 0x80, 0x02, 0x80, 0x09, 0x80, 0x21, 0x00, 0x83, 0x02,
  0x02, 0x08, 0x02, 0x30, 0x06, 0x00, 0x30, 0x01, 0x88, 0x01, 0x84, 0x00,
  0x83, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x40, 0x30, 0x60, 0x18, 0x20, 0x04,
  0x30, 0x02, 0x10, 0x01, 0x90, 0x00, 0x58, 0x00, 0x28, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x60, 0x0F, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x46, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x8C,
  0x42, 0x10, 0x84, 0x22, 0x10, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x70, 0x0E, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00,
  0xC0, 0x00, 0x3C, 0x02, 0xCC, 0x06, 0x04, 0x1C, 0x06, 0x60, 0x07, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 6, 6, 17, 7, -22 },
  { 20, 17, 21, 17, 0, -21 },
  { 65, 14, 27, 17, 2, -24 },
  { 113, 14, 21, 17, 2, -21 },
  { 150, 15, 21, 17, 1, -21 },
  { 190, 3, 6, 17, 8, -22 },
  { 193, 9, 30, 17, 5, -23 },
  { 227, 8, 30, 17, 3, -23 },
  { 257, 12, 12, 17, 4, -21 },
  { 275, 14, 15, 17, 2, -17 },
  { 302, 4, 6, 17, 3, -2 },
  { 305, 10, 1, 17, 3, -10 },
  { 307, 3, 2, 17, 6, -2 },
  { 308, 14, 23, 17, 2, -21 },
  { 349, 14, 21, 17, 2, -21 },
  { 386, 8, 21, 17, 4, -21 },
  { 407, 13, 21, 17, 1, -21 },
  { 442, 14, 21, 17, 1, -21 },
  { 479, 14, 21, 17, 1, -21 },
  { 516, 15, 21, 17, 2, -21 },
  { 556, 12, 21, 17, 2, -21 },
  { 588, 13, 21, 17, 4, -21 },
  { 623, 14, 21, 17, 2, -21 },
  { 660, 12, 21, 17, 3, -21 },
  { 692, 5, 14, 17, 7, -14 },
  { 701, 7, 18, 17, 5, -14 },
  { 717, 13, 12, 17, 2, -15 },
  { 737, 13, 7, 17, 2, -13 },
  { 749, 13, 11, 17, 2, -15 },
  { 767, 11, 21, 17, 4, -21 },
  { 796, 16, 21, 17, 1, -21 },
  { 838, 14, 21, 17, 0, -21 },
  { 875, 15, 21, 17, 1, -21 },
  { 915, 14, 21, 17, 2, -21 },
  { 952, 15, 21, 17, 1, -21 },
  { 992, 16, 21, 17, 1, -21 },
  { 1034, 15, 21, 17, 2, -21 },
  { 1074, 14, 21, 17, 2, -21 },
  { 1111, 16, 21, 17, 1, -21 },
  { 1153, 15, 21, 17, 1, -21 },
  { 1193, 15, 21, 17, 1, -21 },
  { 1233, 17, 21, 17, 1, -21 },
  { 1278, 11, 21, 17, 2, -21 },
  { 1307, 16, 21, 17, 1, -21 },
  { 1349, 16, 21, 17, 1, -21 },
  { 1391, 14, 21, 17, 2, -21 },
  { 1428, 15, 21, 17, 2, -21 },
  { 1468, 15, 25, 17, 1, -21 },
  { 1515, 15, 21, 17, 1, -21 },
  { 1555, 15, 21, 17, 1, -21 },
  { 1595, 15, 21, 17, 3, -21 },
  { 1635, 15, 21, 17, 2, -21 },
  { 1675, 14, 21, 17, 3, -21 },
  { 1712, 15, 21, 17, 3, -21 },
  { 1752, 17, 21, 17, 0, -21 },
  { 1797, 14, 21, 17, 3, -21 },
  { 1834, 15, 21, 17, 1, -21 },
  { 1874, 9, 28, 17, 4, -24 },
  { 1906, 5, 23, 17, 6, -21 },
  { 1921, 9, 28, 17, 4, -24 },
  { 1953, 10, 12, 17, 4, -21 },
  { 1968, 12, 1, 17, 1, 0 },
  { 1970, 3, 3, 17, 9, -21 },
  { 1972, 13, 16, 17, 2, -16 },
  { 1998, 14, 22, 17, 1, -22 },
  { 2037, 13, 16, 17, 2, -16 },
  { 2063, 14, 22, 17, 2, -22 },
  { 2102, 13, 16, 17, 2, -16 },
  { 2128, 14, 22, 17, 4, -22 },
  { 2167, 14, 22, 17, 1, -16 },
  { 2206, 14, 22, 17, 1, -22 },
  { 2245, 12, 21, 17, 2, -21 },
  { 2277, 13, 27, 17, 0, -21 },
  { 2321, 14, 22, 17, 2, -22 },
  { 2360, 12, 22, 17, 2, -22 },
  { 2393, 16, 16, 17, 0, -16 },
  { 2425, 14, 16, 17, 1, -16 },
  { 2453, 13, 16, 17, 2, -16 },
  { 2479, 15, 22, 17, 0, -16 },
  { 2521, 13, 22, 17, 2, -16 },
  { 2557, 12, 16, 17, 4, -16 },
  { 2581, 13, 16, 17, 2, -16 },
  { 2607, 11, 19, 17, 4, -19 },
  { 2634, 13, 15, 17, 2, -15 },
  { 2659, 13, 15, 17, 3, -15 },
  { 2684, 15, 15, 17, 2, -15 },
  { 2713, 15, 15, 17, 1, -15 },
  { 2742, 17, 21, 17, 0, -15 },
  { 2787, 14, 15, 17, 1, -15 },
  { 2814, 12, 29, 17, 4, -23 },
  { 2858, 5, 25, 17, 6, -21 },
  { 2874, 12, 29, 17, 2, -23 },
  { 2918, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC29PT7B_H_
