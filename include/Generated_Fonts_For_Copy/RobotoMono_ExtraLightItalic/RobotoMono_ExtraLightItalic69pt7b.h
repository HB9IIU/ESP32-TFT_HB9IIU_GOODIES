#ifndef _ROBOTOMONO_EXTRALIGHTITALIC69PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F,
  0x80, 0x70, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x01, 0x9C, 0x06, 0x70, 0x39,
  0xC0, 0xE7, 0x03, 0x98, 0x0C, 0x60, 0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x20,
  0xE0, 0x03, 0x00, 0x1C, 0x70, 0x01, 0x80, 0x1C, 0x30, 0x00, 0xC0, 0x0E,
  0x18, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x38, 0x06,
  0x07, 0x00, 0x18, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x01, 0xC0, 0x0E, 0x07,
  0x00, 0xE0, 0x06, 0x03, 0x80, 0x30, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x03,
  0x80, 0x0F, 0x07, 0x81, 0x80, 0x03, 0xFF, 0x81, 0xC0, 0x00, 0xFF, 0x01,
  0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x30, 0x1F, 0xE0, 0x00,
  0x38, 0x1F, 0xF8, 0x00, 0x38, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x03, 0x80,
  0x1C, 0x0C, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x30,
  0x0E, 0x07, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x0C, 0x0E, 0x01, 0x80, 0x06,
  0x06, 0x00, 0xC0, 0x07, 0x07, 0x00, 0x60, 0x03, 0x87, 0x00, 0x30, 0x01,
  0xC7, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0xE0, 0x80, 0x06, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x00, 0x1D, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x03, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x70, 0xF0, 0x07,
  0x00, 0x1C, 0x78, 0x01, 0xE0, 0x07, 0x1C, 0x00, 0x38, 0x03, 0x8E, 0x00,
  0x07, 0x00, 0xE3, 0x80, 0x01, 0xE0, 0x39, 0xC0, 0x00, 0x38, 0x1C, 0x70,
  0x00, 0x07, 0x07, 0x1C, 0x00, 0x01, 0xC3, 0x86, 0x00, 0x00, 0x39, 0xE3,
  0x80, 0x00, 0x0F, 0x70, 0xE0, 0x00, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0x3E,
  0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xF8, 0x0F, 0x00, 0x03, 0xEF, 0x01, 0xE0, 0x01, 0xE1, 0xC0, 0x3E, 0x03,
  0xF0, 0x38, 0x07, 0xFF, 0xF0, 0x0E, 0x00, 0x7F, 0xF0, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x19, 0xCE, 0x73,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x18, 0x01, 0xDF, 0x00, 0xC0, 0x3F, 0xFE, 0x06, 0x0F, 0xF1, 0xFE,
  0x73, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x70, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x39, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x1F, 0x1C, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x7F, 0x1C, 0x00,
  0x00, 0xE7, 0x38, 0x00, 0x01, 0xC7, 0x38, 0x00, 0x07, 0x87, 0x38, 0x00,
  0x0F, 0x07, 0x38, 0x00, 0x1E, 0x06, 0x38, 0x00, 0x38, 0x0E, 0x70, 0x00,
  0x70, 0x0E, 0x70, 0x00, 0xE0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70, 0x07,
  0x80, 0x0E, 0x70, 0x0F, 0x00, 0x0C, 0x70, 0x1C, 0x00, 0x1C, 0xE0, 0x38,
  0x00, 0x1C, 0xE0, 0xF0, 0x00, 0x1C, 0xE1, 0xE0, 0x00, 0x1C, 0xE3, 0xC0,
  0x00, 0x18, 0xE7, 0x00, 0x00, 0x38, 0xEE, 0x00, 0x00, 0x38, 0xFC, 0x00,
  0x00, 0x38, 0xF8, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x03,
  0xFB, 0x83, 0xF0, 0xE7, 0xF0, 0x3B, 0xE0, 0x0C, 0xE0, 0x07, 0x20, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0xFF, 0x80, 0x00, 0x19,
  0xFF, 0xF8, 0x00, 0x06, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0xC0, 0x07, 0x07,
  0xFF, 0xC0, 0x1C, 0x7F, 0xBF, 0xC0, 0x73, 0xC0, 0x0F, 0x83, 0x9C, 0x00,
  0x1E, 0x0E, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x06, 0xE3, 0x80, 0x00,
  0xE7, 0x0E, 0x00, 0x0F, 0x70, 0x7C, 0x01, 0xE3, 0x81, 0xFF, 0xFE, 0x1C,
  0x03, 0xFF, 0xC1, 0xC0, 0x07, 0xF8, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x78,
  0x1F, 0x83, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0xFC, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFC, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x1C, 0x01, 0xFC, 0x01, 0xC0, 0xE0, 0x0F, 0xFC,
  0x07, 0x07, 0x00, 0xF8, 0x78, 0x0C, 0x1C, 0x07, 0x80, 0xE0, 0x30, 0xE0,
  0x1C, 0x03, 0x00, 0xC3, 0x80, 0xE0, 0x0C, 0x03, 0x1C, 0x07, 0x00, 0x30,
  0x0C, 0x70, 0x18, 0x01, 0xC0, 0x31, 0x80, 0xE0, 0x06, 0x00, 0xCE, 0x03,
  0x00, 0x18, 0x07, 0x30, 0x1C, 0x00, 0x60, 0x1D, 0xC0, 0x60, 0x03, 0x80,
  0x77, 0x01, 0x80, 0x0C, 0x01, 0x98, 0x0E, 0x00, 0x30, 0x06, 0x60, 0x30,
  0x00, 0xC0, 0x1B, 0x80, 0xC0, 0x07, 0x00, 0xEE, 0x03, 0x00, 0x18, 0x03,
  0x30, 0x1C, 0x00, 0x60, 0x0C, 0xC0, 0x70, 0x03, 0x80, 0x33, 0x01, 0x80,
  0x0E, 0x01, 0xCC, 0x06, 0x00, 0x70, 0x06, 0x30, 0x18, 0x01, 0xC0, 0x18,
  0xC0, 0x60, 0x0F, 0x00, 0xC3, 0x01, 0x80, 0x7C, 0x03, 0x0C, 0x06, 0x03,
  0xB0, 0x18, 0x30, 0x1C, 0x1C, 0xC0, 0xE0, 0xC0, 0x38, 0xE3, 0x8F, 0x03,
  0x80, 0xFF, 0x07, 0xF8, 0x0E, 0x01, 0xF8, 0x0F, 0x80, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x80, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0x80, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xE0, 0x1C, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xFF, 0xFC, 0xE0, 0x00, 0x7F, 0xFF, 0x38, 0x00, 0x1F, 0xFF,
  0xCE, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x01, 0x80, 0xF0, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x00, 0x03, 0x8F, 0xC0, 0x00,
  0x00, 0x0E, 0x7B, 0x80, 0x00, 0x00, 0x33, 0xCF, 0x00, 0x00, 0x01, 0xDE,
  0x1C, 0x00, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0x60, 0x0D, 0xC0, 0x00,
  0x3F, 0x80, 0x77, 0x00, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x07,
  0x30, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x38,
  0x60, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0x70,
  0x60, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x30, 0x70, 0x0E, 0x0E, 0x01, 0xC0,
  0xC0, 0x70, 0x38, 0x07, 0x03, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x0E, 0x03,
  0x00, 0x70, 0x38, 0x38, 0x1C, 0x01, 0xC0, 0xE1, 0xC0, 0x70, 0x06, 0x03,
  0x8F, 0x01, 0xC0, 0x38, 0x06, 0x38, 0x07, 0x00, 0xE0, 0x19, 0xC0, 0x1C,
  0x03, 0x80, 0x77, 0x00, 0x60, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x38, 0x07,
  0xE0, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x3E, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x03, 0x60, 0x00,
  0x00, 0xE0, 0x1D, 0xC0, 0x00, 0x03, 0x80, 0x77, 0x00, 0x00, 0x1C, 0x01,
  0xCC, 0x00, 0x00, 0x70, 0x07, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0xE0, 0x00,
  0x07, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x03, 0x87, 0x00, 0x00, 0x60, 0x0E,
  0x1C, 0x00, 0x03, 0x80, 0x38, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x03, 0x80, 0x70,
  0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x30,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x70, 0x00,
  0x1C, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x00, 0xC1, 0xC0,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0xE0, 0x00, 0x0E, 0x38, 0x03, 0x80, 0x00,
  0x18, 0xE0, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x30, 0x00, 0x01, 0xCE, 0x01,
  0xC0, 0x00, 0x03, 0xB8, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x06,
  0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x0C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01,
  0xE0, 0x03, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x6E, 0x00, 0x0F, 0x00, 0x0E, 0xE0,
  0x01, 0xF0, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x0C, 0xE0, 0x01, 0xF0, 0x01,
  0xCE, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x03, 0xF0, 0x01, 0x8E, 0x00, 0x37,
  0x00, 0x38, 0xE0, 0x07, 0x70, 0x03, 0x8E, 0x00, 0x77, 0x00, 0x38, 0xE0,
  0x06, 0x70, 0x03, 0x0E, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x0E, 0x70, 0x07,
  0x0E, 0x00, 0xC7, 0x00, 0x60, 0xE0, 0x1C, 0x70, 0x0E, 0x0E, 0x01, 0xC3,
  0x00, 0xE0, 0xE0, 0x18, 0x30, 0x0C, 0x0E, 0x03, 0x83, 0x01, 0xC0, 0xE0,
  0x38, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x0E, 0x07, 0x03, 0x03, 0x80, 0xE0, 0xE0, 0x30, 0x38, 0x0E, 0x0E, 0x03,
  0x03, 0x00, 0xE0, 0xE0, 0x30, 0x70, 0x0E, 0x1C, 0x03, 0x07, 0x00, 0xE1,
  0xC0, 0x30, 0x60, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0xE3, 0x80, 0x30, 0xE0,
  0x0E, 0x38, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x60, 0x03, 0x98, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEC, 0x00, 0x3B, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0x0F, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0xE0, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38,
  0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x38, 0x00, 0x60, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x8E, 0x00, 0x03, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0x01, 0xC0, 0xF8, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF8, 0x70,
  0x00, 0x03, 0xF0, 0x70, 0x00, 0x1E, 0xE0, 0xF0, 0x00, 0xF9, 0xC0, 0xF8,
  0x0F, 0xC3, 0x80, 0xFF, 0xFF, 0x07, 0x00, 0x7F, 0xF8, 0x0E, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0x00, 0x01, 0x83, 0xFF, 0xC0, 0x03,
  0x8F, 0xFF, 0xF0, 0x03, 0x9E, 0x00, 0xF8, 0x03, 0xB8, 0x00, 0x38, 0x03,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x03, 0xC0, 0x77,
  0x00, 0x07, 0x80, 0x77, 0x80, 0x0F, 0x80, 0x73, 0xE0, 0x7E, 0x00, 0x71,
  0xFF, 0xFC, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x3F, 0xFE, 0x0E, 0x00, 0x1F,
  0xFF, 0xC3, 0x80, 0x0F, 0x80, 0x78, 0xE0, 0x07, 0x80, 0x07, 0x70, 0x03,
  0xC0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0x39, 0x80, 0x07, 0xE0, 0x7C, 0x60, 0x00, 0x7F, 0xFE, 0x38, 0x00, 0x0F,
  0xFE, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40,
  0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x20, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC1, 0xC0, 0x07, 0xFF, 0xF0, 0xE0, 0x07, 0xC0, 0x1C, 0x70,
  0x07, 0x80, 0x07, 0x30, 0x07, 0x80, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xB0, 0x01, 0xF8, 0x1F, 0x38, 0x00, 0x3F, 0xFF, 0x1C, 0x00,
  0x0F, 0xFE, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xC0, 0x03, 0x81,
  0xFF, 0xF0, 0x03, 0x83, 0xFF, 0xF8, 0x03, 0x8F, 0x80, 0x7C, 0x03, 0x9E,
  0x00, 0x1C, 0x03, 0x38, 0x00, 0x0E, 0x07, 0x70, 0x00, 0x0E, 0x07, 0xE0,
  0x00, 0x0E, 0x07, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x38, 0x0F, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x00, 0x0E, 0xFE,
  0x00, 0x00, 0x07, 0x7B, 0xC0, 0x00, 0x01, 0xFC, 0x70, 0x00, 0x00, 0x7E,
  0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x78, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0x8F, 0xFC, 0x1F, 0xFC, 0x03,
  0x9F, 0xFE, 0x3F, 0xFC, 0x03, 0xB8, 0x0E, 0x78, 0x1E, 0x03, 0xE0, 0x0F,
  0xE0, 0x0E, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x18, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x81,
  0xFF, 0xF0, 0x03, 0x83, 0xFF, 0xF8, 0x03, 0x8F, 0x80, 0x7C, 0x03, 0x1C,
  0x00, 0x1C, 0x03, 0x38, 0x00, 0x1E, 0x07, 0x70, 0x00, 0x0E, 0x07, 0xE0,
  0x00, 0x0E, 0x07, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFC,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38,
  0x3F, 0xFC, 0x00, 0x0E, 0x3F, 0xFF, 0xC0, 0x03, 0x9E, 0x00, 0xF8, 0x00,
  0xEE, 0x00, 0x1E, 0x00, 0x37, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x70,
  0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x80,
  0x01, 0xE0, 0x07, 0x78, 0x00, 0xF0, 0x01, 0xCF, 0x81, 0xF8, 0x00, 0x71,
  0xFF, 0xFC, 0x00, 0x38, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x1C, 0x01, 0xFF, 0xFC, 0x38, 0x07, 0xC0, 0x1C, 0x70, 0x1E,
  0x00, 0x1C, 0xC0, 0x78, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x38,
  0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x7B, 0x00, 0x7C, 0x07, 0xCE, 0x00, 0x7F,
  0xFF, 0x1C, 0x00, 0x3F, 0xF8, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1C, 0x07, 0xFF, 0xC0, 0xE0, 0xFF, 0xFC,
  0x06, 0x1F, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x02,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x83, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x03, 0xF0, 0x1C,
  0x00, 0x0E, 0xE0, 0x3C, 0x00, 0x79, 0xC0, 0x3E, 0x07, 0xE3, 0x80, 0x3F,
  0xFF, 0x86, 0x00, 0x3F, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x0E, 0x00,
  0x06, 0xE0, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x0E, 0xE0, 0x01,
  0xF0, 0x00, 0xCE, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x03, 0xF0, 0x01, 0xCE,
  0x00, 0x37, 0x00, 0x38, 0x60, 0x07, 0x70, 0x03, 0x86, 0x00, 0x67, 0x00,
  0x30, 0x60, 0x0E, 0x70, 0x07, 0x06, 0x00, 0xE3, 0x00, 0x70, 0x60, 0x0C,
  0x30, 0x0E, 0x06, 0x01, 0xC3, 0x00, 0xE0, 0x60, 0x18, 0x30, 0x0C, 0x06,
  0x03, 0x83, 0x01, 0xC0, 0x60, 0x38, 0x30, 0x1C, 0x07, 0x07, 0x03, 0x81,
  0x80, 0x70, 0x70, 0x38, 0x38, 0x07, 0x06, 0x03, 0x83, 0x00, 0x70, 0xE0,
  0x38, 0x70, 0x07, 0x0C, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x38, 0x60, 0x07,
  0x1C, 0x01, 0x8E, 0x00, 0x71, 0x80, 0x18, 0xC0, 0x07, 0x38, 0x01, 0x9C,
  0x00, 0x73, 0x00, 0x19, 0xC0, 0x07, 0x70, 0x01, 0x98, 0x00, 0x76, 0x00,
  0x1B, 0x80, 0x07, 0x60, 0x01, 0xB8, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0xFD, 0xFC,
  0x00, 0x01, 0x87, 0x80, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0xF0, 0x00, 0x38,
  0xE0, 0x01, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0xC0, 0x0F, 0x1C, 0x00, 0x07,
  0x80, 0x78, 0x60, 0x00, 0x0F, 0xC7, 0xC1, 0x80, 0x00, 0x0F, 0xFE, 0x08,
  0x00, 0x00, 0x1F, 0xE0, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 12, 49, 41, 14, -49 },
  { 75, 14, 15, 41, 17, -52 },
  { 102, 40, 49, 41, 1, -49 },
  { 347, 33, 63, 41, 5, -56 },
  { 607, 33, 51, 41, 4, -50 },
  { 818, 34, 51, 41, 3, -50 },
  { 1035, 5, 15, 41, 20, -52 },
  { 1045, 21, 71, 41, 12, -55 },
  { 1232, 21, 71, 41, 6, -55 },
  { 1419, 29, 28, 41, 9, -49 },
  { 1521, 33, 36, 41, 4, -41 },
  { 1670, 8, 15, 41, 8, -6 },
  { 1685, 24, 3, 41, 8, -24 },
  { 1694, 6, 5, 41, 15, -5 },
  { 1698, 32, 53, 41, 5, -49 },
  { 1910, 32, 51, 41, 5, -50 },
  { 2114, 18, 49, 41, 11, -49 },
  { 2225, 33, 50, 41, 1, -50 },
  { 2432, 33, 51, 41, 2, -50 },
  { 2643, 33, 49, 41, 2, -49 },
  { 2846, 34, 50, 41, 6, -49 },
  { 3059, 30, 51, 41, 4, -50 },
  { 3251, 32, 49, 41, 8, -49 },
  { 3447, 34, 51, 41, 4, -50 },
  { 3664, 29, 51, 41, 7, -50 },
  { 3849, 11, 35, 41, 17, -35 },
  { 3898, 15, 44, 41, 13, -35 },
  { 3981, 30, 28, 41, 6, -36 },
  { 4086, 32, 17, 41, 5, -31 },
  { 4154, 31, 28, 41, 4, -36 },
  { 4263, 25, 50, 41, 11, -50 },
  { 4420, 38, 49, 41, 2, -49 },
  { 4653, 34, 49, 41, 0, -49 },
  { 4862, 34, 49, 41, 3, -49 },
  { 5071, 34, 51, 41, 4, -50 },
  { 5288, 35, 49, 41, 3, -49 },
  { 5503, 36, 49, 41, 3, -49 },
  { 5724, 36, 49, 41, 4, -49 },
  { 5945, 34, 51, 41, 4, -50 },
  { 6162, 38, 49, 41, 2, -49 },
  { 6395, 36, 49, 41, 3, -49 },
  { 6616, 35, 50, 41, 3, -49 },
  { 6835, 38, 49, 41, 4, -49 },
  { 7068, 28, 49, 41, 4, -49 },
  { 7240, 38, 49, 41, 2, -49 },
  { 7473, 38, 49, 41, 2, -49 },
  { 7706, 34, 51, 41, 4, -50 },
  { 7923, 36, 49, 41, 4, -49 },
  { 8144, 35, 59, 41, 3, -50 },
  { 8403, 34, 49, 41, 4, -49 },
  { 8612, 35, 51, 41, 3, -50 },
  { 8836, 34, 49, 41, 8, -49 },
  { 9045, 36, 50, 41, 4, -49 },
  { 9270, 33, 49, 41, 8, -49 },
  { 9473, 36, 49, 41, 7, -49 },
  { 9694, 41, 49, 41, 1, -49 },
  { 9946, 34, 49, 41, 8, -49 },
  { 10155, 37, 49, 41, 1, -49 },
  { 10382, 21, 67, 41, 10, -56 },
  { 10558, 13, 53, 41, 14, -49 },
  { 10645, 21, 67, 41, 10, -56 },
  { 10821, 23, 27, 41, 9, -49 },
  { 10899, 29, 3, 41, 2, 0 },
  { 10910, 8, 9, 41, 20, -51 },
  { 10919, 31, 38, 41, 4, -37 },
  { 11067, 32, 53, 41, 3, -52 },
  { 11279, 30, 38, 41, 5, -37 },
  { 11422, 34, 53, 41, 5, -52 },
  { 11648, 32, 38, 41, 4, -37 },
  { 11800, 33, 53, 41, 9, -53 },
  { 12019, 33, 52, 41, 3, -37 },
  { 12234, 32, 52, 41, 3, -52 },
  { 12442, 28, 49, 41, 4, -49 },
  { 12614, 32, 64, 41, 0, -49 },
  { 12870, 34, 52, 41, 4, -52 },
  { 13091, 28, 52, 41, 4, -52 },
  { 13273, 40, 37, 41, -1, -37 },
  { 13458, 32, 37, 41, 3, -37 },
  { 13606, 32, 38, 41, 4, -37 },
  { 13758, 34, 51, 41, 1, -37 },
  { 13975, 31, 51, 41, 5, -37 },
  { 14173, 29, 37, 41, 9, -37 },
  { 14308, 31, 38, 41, 5, -37 },
  { 14456, 27, 47, 41, 8, -46 },
  { 14615, 31, 37, 41, 5, -36 },
  { 14759, 33, 36, 41, 6, -36 },
  { 14908, 36, 36, 41, 5, -36 },
  { 15070, 37, 36, 41, 1, -36 },
  { 15237, 41, 51, 41, -1, -36 },
  { 15499, 35, 36, 41, 2, -36 },
  { 15657, 26, 68, 41, 11, -54 },
  { 15878, 12, 59, 41, 14, -49 },
  { 15967, 26, 68, 41, 6, -54 },
  { 16188, 38, 11, 41, 1, -26 },
};

const GFXfont RobotoMono_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC69PT7B_H_
