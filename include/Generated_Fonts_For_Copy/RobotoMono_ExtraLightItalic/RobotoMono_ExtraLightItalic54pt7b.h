#ifndef _ROBOTOMONO_EXTRALIGHTITALIC54PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x00, 0x30, 0x66, 0x0C, 0xC1,
  0xB8, 0x36, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xD8, 0x33, 0x06, 0x60,
  0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x70, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0xC6, 0x00,
  0x80, 0x31, 0x80, 0x60, 0x18, 0x60, 0x18, 0x0C, 0x30, 0x06, 0x07, 0x0C,
  0x01, 0x81, 0x83, 0x00, 0x60, 0xC0, 0xC0, 0x30, 0x70, 0x18, 0x0C, 0x18,
  0x06, 0x06, 0x0C, 0x00, 0xC7, 0x06, 0x00, 0x3F, 0x83, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x83, 0xE0, 0x00, 0xC1, 0xFE, 0x00, 0x60, 0xC1,
  0x80, 0x30, 0x60, 0x30, 0x1C, 0x38, 0x0C, 0x06, 0x0C, 0x03, 0x03, 0x03,
  0x00, 0xC1, 0xC1, 0x80, 0x30, 0x60, 0x60, 0x0C, 0x30, 0x18, 0x03, 0x1C,
  0x06, 0x00, 0xCE, 0x01, 0x80, 0x61, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x18, 0x60, 0x38, 0x03, 0x1C, 0x03,
  0x80, 0xE7, 0x00, 0x30, 0x18, 0xC0, 0x07, 0x03, 0x38, 0x00, 0x60, 0xE6,
  0x00, 0x0E, 0x18, 0xC0, 0x00, 0xE7, 0x18, 0x00, 0x0D, 0xC3, 0x00, 0x01,
  0xF0, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF8, 0x1C,
  0x00, 0x7B, 0x81, 0xC0, 0x1C, 0x30, 0x1F, 0xFF, 0x07, 0x01, 0xFF, 0x80,
  0x70, 0x02, 0x00, 0x00, 0x36, 0x66, 0x66, 0x6C, 0xCC, 0xCC, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xB8, 0x0C, 0x07, 0xFC, 0x18, 0x7E, 0x7F,
  0x27, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x73, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x06,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x02, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x1C, 0x38, 0x60,
  0xC1, 0x87, 0x0C, 0x38, 0x61, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x6F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x01, 0xC0,
  0x38, 0x00, 0x60, 0x18, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0xF9, 0x80, 0x00, 0xCC, 0xC0, 0x01, 0xCE, 0x60, 0x01,
  0xC7, 0x70, 0x01, 0xC3, 0xB0, 0x01, 0xC1, 0x98, 0x01, 0xC0, 0xCC, 0x01,
  0x80, 0x66, 0x03, 0x80, 0x33, 0x03, 0x80, 0x3B, 0x83, 0x80, 0x19, 0x83,
  0x80, 0x0C, 0xC3, 0x00, 0x06, 0x67, 0x00, 0x03, 0x37, 0x00, 0x03, 0x9F,
  0x00, 0x01, 0x8F, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x06, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC1, 0xF3, 0x3E,
  0x1D, 0xE0, 0x6E, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x18,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xCF, 0xF8, 0x00, 0x6F, 0xFF, 0x80, 0x1F, 0x00,
  0xF0, 0x07, 0x00, 0x1C, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x3F, 0xC0, 0x18, 0xFF,
  0xF0, 0x3B, 0xC0, 0x78, 0x37, 0x00, 0x1C, 0x3E, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x78, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x1C, 0x70, 0x00, 0x18, 0x30, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06,
  0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x0F, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0x83, 0xC0, 0x3C, 0x01, 0xC0, 0x70, 0x01,
  0xC1, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0xF7, 0x00, 0x03, 0xC6, 0x00,
  0x0D, 0x8E, 0x00, 0x3B, 0x0E, 0x01, 0xEE, 0x0F, 0xFF, 0x18, 0x0F, 0xF8,
  0x30, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0x03, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x7C, 0x1C, 0x00, 0x00, 0xE0,
  0x0F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x18, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xC3, 0xC0, 0xE0, 0x0E, 0x1C, 0x00,
  0x63, 0x80, 0x07, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x70,
  0x0C, 0x0E, 0x03, 0xF8, 0x18, 0x18, 0x1E, 0x38, 0x30, 0x60, 0x70, 0x30,
  0x60, 0xC0, 0xC0, 0x60, 0xC3, 0x03, 0x00, 0x81, 0x86, 0x0C, 0x03, 0x03,
  0x18, 0x18, 0x06, 0x06, 0x30, 0x60, 0x0C, 0x0C, 0x60, 0xC0, 0x10, 0x19,
  0x81, 0x80, 0x60, 0x33, 0x06, 0x00, 0xC0, 0x66, 0x0C, 0x01, 0x80, 0x8C,
  0x18, 0x02, 0x03, 0x10, 0x30, 0x0C, 0x06, 0x60, 0x60, 0x18, 0x0C, 0xC0,
  0x80, 0x70, 0x31, 0x81, 0x00, 0xC0, 0x63, 0x02, 0x03, 0x81, 0x86, 0x06,
  0x0D, 0x03, 0x0C, 0x0C, 0x33, 0x0C, 0x08, 0x1F, 0xC7, 0x70, 0x18, 0x1F,
  0x07, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x06, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x78, 0x0C, 0x00, 0x3C, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x06,
  0x00, 0x3E, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xE0, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x60, 0x01, 0xE0, 0x0E, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFF,
  0x38, 0x01, 0xFF, 0xE6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x30, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x0F, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x01, 0x9F, 0x80, 0x00,
  0x06, 0xE7, 0x00, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x0D, 0x83, 0xE0, 0x00, 0xD8, 0x19, 0x80, 0x0E, 0xC0, 0xCC,
  0x00, 0x66, 0x06, 0x60, 0x07, 0x30, 0x33, 0x00, 0x31, 0x81, 0x98, 0x03,
  0x9C, 0x1C, 0x60, 0x18, 0xC0, 0xC3, 0x01, 0xC6, 0x06, 0x18, 0x0C, 0x30,
  0x30, 0xC0, 0xC1, 0x81, 0x86, 0x0E, 0x0C, 0x1C, 0x38, 0x60, 0xE0, 0xE0,
  0xC7, 0x06, 0x06, 0x06, 0x30, 0x30, 0x30, 0x33, 0x81, 0x81, 0x81, 0x98,
  0x0C, 0x0C, 0x0D, 0x80, 0xE0, 0xE0, 0x3C, 0x07, 0x07, 0x01, 0xC0, 0x30,
  0x30, 0x0E, 0x01, 0x81, 0x80, 0x60, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x60, 0x7C, 0x00, 0x03, 0x03, 0x70, 0x00,
  0x18, 0x19, 0x80, 0x00, 0xC0, 0xCC, 0x00, 0x0E, 0x06, 0x70, 0x00, 0x70,
  0x31, 0x80, 0x03, 0x03, 0x8C, 0x00, 0x18, 0x18, 0x30, 0x00, 0xC0, 0xC1,
  0x80, 0x06, 0x06, 0x0C, 0x00, 0x70, 0x30, 0x30, 0x03, 0x01, 0x81, 0x80,
  0x18, 0x1C, 0x0E, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x06, 0x01, 0x80, 0x30,
  0x30, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0xE0,
  0x06, 0x06, 0x06, 0x00, 0x30, 0x30, 0x30, 0x01, 0xC3, 0x81, 0x80, 0x06,
  0x1C, 0x0C, 0x00, 0x30, 0xC0, 0xE0, 0x01, 0xC6, 0x06, 0x00, 0x06, 0x30,
  0x30, 0x00, 0x31, 0x81, 0x80, 0x00, 0xDC, 0x0C, 0x00, 0x06, 0xE0, 0x60,
  0x00, 0x36, 0x07, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x07, 0x81, 0x80, 0x00,
  0x3C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x03, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x1C,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0C, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x18, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xF0,
  0x0C, 0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xF8, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0x60,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x3B, 0x00, 0x38, 0x01, 0x98, 0x01, 0xC0,
  0x0C, 0xC0, 0x1E, 0x00, 0xC6, 0x00, 0xF0, 0x06, 0x30, 0x07, 0x80, 0x31,
  0x80, 0x6C, 0x03, 0x8C, 0x03, 0x60, 0x18, 0x60, 0x1B, 0x00, 0xC3, 0x01,
  0x98, 0x06, 0x18, 0x0C, 0xC0, 0x60, 0xC0, 0x66, 0x03, 0x06, 0x06, 0x30,
  0x18, 0x30, 0x31, 0x81, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x18, 0x60, 0x60,
  0x60, 0xC3, 0x07, 0x03, 0x06, 0x18, 0x30, 0x18, 0x60, 0xC1, 0x80, 0xC3,
  0x06, 0x0C, 0x06, 0x18, 0x30, 0xC0, 0x31, 0x81, 0x86, 0x01, 0x8C, 0x0C,
  0x30, 0x0C, 0xE0, 0x63, 0x00, 0x66, 0x03, 0x98, 0x03, 0x30, 0x0C, 0xC0,
  0x1B, 0x80, 0x6E, 0x00, 0xD8, 0x03, 0x60, 0x06, 0xC0, 0x1B, 0x00, 0x3E,
  0x00, 0xD8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01,
  0xEC, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x66, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x87, 0x00,
  0xC0, 0xC0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xE1, 0x80,
  0x18, 0x60, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0F, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0x87, 0x0C,
  0x38, 0x60, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x3C,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0x80, 0x06, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0xF8, 0x60, 0x01, 0xD8, 0x78, 0x07, 0x98,
  0x3F, 0xFE, 0x18, 0x0F, 0xF8, 0x18, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x0F, 0xE0,
  0x0E, 0x3F, 0xF0, 0x0C, 0xF0, 0x3C, 0x0D, 0xC0, 0x1C, 0x0F, 0x80, 0x0E,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x70,
  0xF8, 0x00, 0xE0, 0xCE, 0x03, 0xC0, 0xC7, 0xFF, 0x80, 0xC3, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0x1C, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x06,
  0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x30, 0x70, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0x03, 0x00, 0x3F, 0xF0, 0xC0, 0x3E, 0x0E, 0x30, 0x1E, 0x00,
  0xDC, 0x0E, 0x00, 0x1F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xF0, 0x1C, 0x00, 0x7C,
  0x03, 0x80, 0x73, 0x00, 0x7F, 0xF9, 0xC0, 0x0F, 0xF8, 0x60, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C,
  0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x0F, 0xFC, 0x30, 0x0F, 0x83, 0xCC,
  0x07, 0x80, 0x37, 0x03, 0x80, 0x07, 0xC0, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x3C, 0x07,
  0x00, 0x1F, 0x00, 0xE0, 0x1E, 0xC0, 0x1F, 0xFE, 0x70, 0x03, 0xFE, 0x18,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x3F, 0x80, 0x30, 0x7F, 0xE0, 0x18, 0xF0, 0x38, 0x0C,
  0xE0, 0x0E, 0x06, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0x40, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x60,
  0x00, 0x70, 0x18, 0x00, 0x78, 0x06, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x1E, 0x00, 0x30, 0x0F, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x00, 0xC3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x7C,
  0x00, 0x01, 0xBB, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x03, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x1F, 0x01, 0xF8,
  0x0C, 0xFF, 0x8F, 0xF8, 0x1B, 0x87, 0x38, 0x38, 0x3C, 0x07, 0xC0, 0x30,
  0x70, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0x01, 0x86,
  0x00, 0x30, 0x03, 0x0C, 0x00, 0xE0, 0x06, 0x18, 0x01, 0x80, 0x0C, 0x30,
  0x03, 0x00, 0x18, 0x60, 0x06, 0x00, 0x71, 0x80, 0x0C, 0x00, 0xC3, 0x00,
  0x18, 0x01, 0x86, 0x00, 0x70, 0x03, 0x0C, 0x00, 0xC0, 0x06, 0x18, 0x01,
  0x80, 0x0C, 0x70, 0x03, 0x00, 0x38, 0xC0, 0x06, 0x00, 0x61, 0x80, 0x0C,
  0x00, 0xC3, 0x00, 0x38, 0x01, 0x86, 0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0,
  0x06, 0x38, 0x01, 0x80, 0x18, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x01, 0x8E, 0x00, 0x60, 0x07,
  0x00, 0x07, 0x03, 0xF8, 0x03, 0x07, 0xFE, 0x01, 0x8F, 0x03, 0x80, 0xCE,
  0x00, 0xE0, 0x6C, 0x00, 0x30, 0x7C, 0x00, 0x1C, 0x3C, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x31, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03,
  0x98, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x30,
  0x00, 0x70, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x01, 0x83, 0xF0, 0x00, 0xC3, 0xFF,
  0x00, 0x33, 0xC1, 0xE0, 0x0D, 0xC0, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0xE0,
  0x00, 0x60, 0x78, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x0D, 0x80, 0x0E, 0x03, 0x70, 0x0F, 0x00, 0xC7, 0xFF,
  0x80, 0x30, 0xFF, 0x80, 0x0C, 0x03, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0x00, 0xFF, 0xC3, 0x03, 0xE0,
  0xF3, 0x07, 0x80, 0x37, 0x0E, 0x00, 0x1F, 0x0C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x0E, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x38, 0x07,
  0xB0, 0x1F, 0xFE, 0x70, 0x0F, 0xF8, 0x60, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x06, 0x03, 0xFE, 0x0C, 0x1F, 0xF8, 0x38, 0xF8,
  0x10, 0x63, 0x80, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xE0,
  0x7C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38, 0x01,
  0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0xF0, 0x60, 0x00,
  0xF0, 0x38, 0x00, 0xD8, 0x0E, 0x01, 0xCC, 0x03, 0xFF, 0xC6, 0x00, 0xFF,
  0x87, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x38, 0x18, 0x00, 0x18,
  0x0E, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x03,
  0x80, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00, 0x7C, 0x00,
  0xE0, 0x06, 0xC0, 0x0A, 0x00, 0x6C, 0x01, 0xA0, 0x0C, 0xC0, 0x1A, 0x00,
  0xCC, 0x03, 0x20, 0x1C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xE0,
  0x63, 0x03, 0x0E, 0x06, 0x30, 0x30, 0x60, 0xC3, 0x07, 0x06, 0x0C, 0x30,
  0x60, 0x61, 0x83, 0x06, 0x06, 0x18, 0x30, 0xC0, 0x61, 0x83, 0x0C, 0x06,
  0x30, 0x30, 0xC0, 0x63, 0x03, 0x18, 0x06, 0x60, 0x31, 0x80, 0x66, 0x01,
  0x30, 0x06, 0xC0, 0x13, 0x00, 0x6C, 0x01, 0x30, 0x06, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xC7, 0xFF, 0x00, 0x06,
  0x70, 0x3C, 0x00, 0x33, 0x00, 0x70, 0x03, 0x30, 0x01, 0xC0, 0x39, 0x80,
  0x07, 0x03, 0x98, 0x00, 0x1F, 0xF8, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x20, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 38, 32, 11, -38 },
  { 44, 11, 12, 32, 13, -41 },
  { 61, 31, 38, 32, 1, -38 },
  { 209, 25, 49, 32, 4, -44 },
  { 363, 26, 40, 32, 3, -39 },
  { 493, 27, 40, 32, 2, -39 },
  { 628, 4, 12, 32, 16, -41 },
  { 634, 17, 55, 32, 9, -43 },
  { 751, 16, 55, 32, 5, -43 },
  { 861, 23, 22, 32, 7, -38 },
  { 925, 26, 28, 32, 3, -32 },
  { 1016, 7, 12, 32, 6, -5 },
  { 1027, 19, 2, 32, 6, -18 },
  { 1032, 4, 4, 32, 12, -4 },
  { 1034, 25, 41, 32, 4, -38 },
  { 1163, 25, 40, 32, 4, -39 },
  { 1288, 14, 38, 32, 8, -38 },
  { 1355, 26, 39, 32, 1, -39 },
  { 1482, 27, 40, 32, 1, -39 },
  { 1617, 27, 38, 32, 1, -38 },
  { 1746, 26, 39, 32, 5, -38 },
  { 1873, 24, 40, 32, 3, -39 },
  { 1993, 24, 38, 32, 7, -38 },
  { 2107, 27, 40, 32, 3, -39 },
  { 2242, 23, 39, 32, 5, -39 },
  { 2355, 9, 27, 32, 13, -27 },
  { 2386, 12, 34, 32, 10, -27 },
  { 2437, 24, 21, 32, 4, -28 },
  { 2500, 25, 13, 32, 4, -24 },
  { 2541, 24, 21, 32, 3, -28 },
  { 2604, 20, 39, 32, 8, -39 },
  { 2702, 31, 39, 32, 1, -39 },
  { 2854, 27, 38, 32, 0, -38 },
  { 2983, 27, 38, 32, 2, -38 },
  { 3112, 27, 40, 32, 3, -39 },
  { 3247, 28, 38, 32, 2, -38 },
  { 3380, 28, 38, 32, 3, -38 },
  { 3513, 28, 38, 32, 3, -38 },
  { 3646, 27, 40, 32, 3, -39 },
  { 3781, 29, 38, 32, 2, -38 },
  { 3919, 28, 38, 32, 2, -38 },
  { 4052, 28, 39, 32, 2, -38 },
  { 4189, 30, 38, 32, 3, -38 },
  { 4332, 22, 38, 32, 3, -38 },
  { 4437, 29, 38, 32, 2, -38 },
  { 4575, 29, 38, 32, 2, -38 },
  { 4713, 26, 40, 32, 3, -39 },
  { 4843, 28, 38, 32, 3, -38 },
  { 4976, 27, 46, 32, 3, -39 },
  { 5132, 27, 38, 32, 3, -38 },
  { 5261, 27, 40, 32, 3, -39 },
  { 5396, 27, 38, 32, 6, -38 },
  { 5525, 28, 39, 32, 3, -38 },
  { 5662, 26, 38, 32, 6, -38 },
  { 5786, 29, 38, 32, 5, -38 },
  { 5924, 33, 38, 32, 0, -38 },
  { 6081, 27, 38, 32, 6, -38 },
  { 6210, 29, 38, 32, 1, -38 },
  { 6348, 17, 52, 32, 8, -44 },
  { 6459, 10, 41, 32, 11, -38 },
  { 6511, 16, 52, 32, 8, -44 },
  { 6615, 18, 21, 32, 7, -38 },
  { 6663, 22, 2, 32, 2, 0 },
  { 6669, 6, 7, 32, 16, -40 },
  { 6675, 24, 30, 32, 3, -29 },
  { 6765, 24, 42, 32, 3, -41 },
  { 6891, 24, 30, 32, 4, -29 },
  { 6981, 26, 42, 32, 4, -41 },
  { 7118, 25, 30, 32, 3, -29 },
  { 7212, 26, 41, 32, 7, -41 },
  { 7346, 26, 40, 32, 2, -29 },
  { 7476, 25, 41, 32, 2, -41 },
  { 7605, 22, 39, 32, 3, -39 },
  { 7713, 25, 51, 32, 0, -39 },
  { 7873, 26, 41, 32, 3, -41 },
  { 8007, 22, 41, 32, 3, -41 },
  { 8120, 31, 29, 32, -1, -29 },
  { 8233, 25, 29, 32, 2, -29 },
  { 8324, 25, 30, 32, 3, -29 },
  { 8418, 26, 40, 32, 1, -29 },
  { 8548, 24, 40, 32, 4, -29 },
  { 8668, 23, 29, 32, 7, -29 },
  { 8752, 24, 30, 32, 4, -29 },
  { 8842, 20, 37, 32, 7, -36 },
  { 8935, 25, 30, 32, 4, -29 },
  { 9029, 25, 29, 32, 5, -29 },
  { 9120, 28, 29, 32, 4, -29 },
  { 9222, 29, 29, 32, 1, -29 },
  { 9328, 33, 41, 32, -1, -29 },
  { 9498, 28, 29, 32, 1, -29 },
  { 9600, 21, 53, 32, 8, -42 },
  { 9740, 9, 46, 32, 11, -38 },
  { 9792, 20, 53, 32, 5, -42 },
  { 9925, 29, 10, 32, 1, -21 },
};

const GFXfont RobotoMono_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC54PT7B_H_
