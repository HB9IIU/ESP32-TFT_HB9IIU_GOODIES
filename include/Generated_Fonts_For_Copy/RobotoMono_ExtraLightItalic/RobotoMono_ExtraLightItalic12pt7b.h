#ifndef _ROBOTOMONO_EXTRALIGHTITALIC12PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0xFC, 0x0A, 0x24, 0x53, 0x72, 0x85, 0x3F,
  0x28, 0x50, 0x10, 0xC4, 0x91, 0x40, 0x81, 0x82, 0x8B, 0x42, 0x00, 0x42,
  0xAA, 0xB4, 0x20, 0xE6, 0x69, 0x18, 0x18, 0x92, 0x8E, 0x21, 0x58, 0xE1,
  0x7C, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x40, 0x22, 0x11, 0x11,
  0x11, 0x22, 0x24, 0x80, 0x21, 0x2E, 0xCB, 0x00, 0x21, 0x09, 0xF2, 0x10,
  0x58, 0xF8, 0x80, 0x08, 0x42, 0x21, 0x11, 0x08, 0x84, 0x00, 0x32, 0x63,
  0x1B, 0xE6, 0x31, 0xF0, 0x3C, 0x92, 0x92, 0x40, 0x39, 0x14, 0x41, 0x08,
  0x42, 0x10, 0xF8, 0x18, 0x94, 0x41, 0x38, 0x10, 0x62, 0x78, 0x04, 0x31,
  0x45, 0x29, 0x2F, 0xC2, 0x08, 0x3D, 0x04, 0x1C, 0x48, 0x20, 0xA2, 0x70,
  0x19, 0x11, 0xE8, 0xC6, 0x31, 0xF0, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10,
  0xC0, 0x39, 0x18, 0x52, 0x72, 0x28, 0xA2, 0xF0, 0x32, 0x63, 0x18, 0xBC,
  0x22, 0xE0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x1B, 0x30, 0x60, 0x80, 0xF8,
  0x3E, 0xE0, 0x86, 0xC8, 0x00, 0x69, 0x11, 0x24, 0x40, 0x80, 0x1C, 0x45,
  0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x78, 0x08, 0x21, 0x8A, 0x25, 0x17, 0xD1,
  0x84, 0x61, 0x28, 0x62, 0xF2, 0x28, 0xA2, 0xF0, 0x39, 0x18, 0x60, 0x82,
  0x08, 0xA2, 0xF0, 0x38, 0x49, 0x0A, 0x14, 0x28, 0x51, 0x42, 0xF8, 0x7D,
  0x08, 0x20, 0xFA, 0x08, 0x20, 0xF0, 0x7D, 0x04, 0x20, 0xFA, 0x08, 0x20,
  0x80, 0x39, 0x18, 0x60, 0x82, 0x68, 0xA2, 0xF0, 0x22, 0x85, 0x0A, 0x17,
  0xC8, 0x91, 0x42, 0x84, 0x7C, 0x42, 0x08, 0x20, 0x82, 0x08, 0xF0, 0x02,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x44, 0x70, 0x45, 0x29, 0x28, 0xC2, 0x89,
  0x24, 0x88, 0x42, 0x11, 0x08, 0x42, 0x10, 0xF8, 0x22, 0x44, 0x9B, 0x55,
  0xAA, 0x91, 0x42, 0x84, 0x22, 0x45, 0x8A, 0x95, 0x4A, 0x93, 0x46, 0x84,
  0x31, 0x28, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x79, 0x14, 0x61, 0x8B, 0xC8,
  0x20, 0x80, 0x31, 0x28, 0x61, 0x86, 0x18, 0xA2, 0xF0, 0x40, 0x80, 0x71,
  0x28, 0x61, 0x8B, 0xC9, 0x24, 0x88, 0x39, 0x18, 0x60, 0x70, 0x20, 0xA2,
  0xF0, 0xFC, 0x41, 0x08, 0x20, 0x82, 0x08, 0x40, 0x46, 0x18, 0x61, 0x8A,
  0x28, 0xA2, 0xF0, 0x86, 0x18, 0x92, 0x49, 0x45, 0x18, 0x20, 0x96, 0x5B,
  0x6D, 0xD7, 0x6D, 0xA4, 0x90, 0x42, 0x44, 0x90, 0xC1, 0x02, 0x0A, 0x22,
  0x84, 0x86, 0x14, 0x94, 0x50, 0x82, 0x08, 0x40, 0x3E, 0x08, 0x10, 0x41,
  0x04, 0x08, 0x20, 0xFC, 0x29, 0x24, 0xA4, 0x92, 0x60, 0x91, 0x24, 0x91,
  0x24, 0x64, 0x92, 0x4A, 0x49, 0x60, 0x10, 0x8C, 0x9C, 0x80, 0xF8, 0xC0,
  0x7C, 0x5F, 0x18, 0xFC, 0x42, 0x2C, 0x98, 0xC6, 0x31, 0xF0, 0x7C, 0x61,
  0x08, 0xF8, 0x04, 0x13, 0x52, 0x8A, 0x28, 0xA2, 0xF0, 0x7C, 0x7F, 0x08,
  0x7C, 0x3A, 0x3C, 0x84, 0x22, 0x10, 0x80, 0x3D, 0x14, 0x51, 0x45, 0xE0,
  0xA2, 0x70, 0x42, 0x2C, 0x98, 0xC6, 0x31, 0x88, 0x10, 0x18, 0x22, 0x10,
  0x84, 0xF8, 0x04, 0x03, 0x02, 0x08, 0x20, 0x84, 0x10, 0x42, 0x30, 0x41,
  0x04, 0x66, 0xA3, 0x0A, 0x24, 0x98, 0x70, 0x84, 0x22, 0x10, 0x84, 0xF8,
  0x7F, 0x26, 0x4C, 0x99, 0x54, 0x80, 0xFC, 0x63, 0x18, 0xC4, 0x7C, 0x63,
  0x18, 0xF8, 0x3D, 0x14, 0x51, 0x45, 0xE8, 0x20, 0x7C, 0x63, 0x18, 0xF8,
  0x42, 0xFC, 0x21, 0x08, 0x40, 0x7C, 0x18, 0x38, 0xF8, 0x27, 0xC8, 0x42,
  0x21, 0x06, 0x8C, 0x63, 0x18, 0xF8, 0x86, 0x25, 0x14, 0x60, 0x80, 0xA6,
  0x9D, 0xB6, 0x92, 0x40, 0x66, 0x50, 0x41, 0x84, 0x98, 0x80, 0x42, 0x88,
  0xA1, 0x43, 0x02, 0x08, 0x20, 0x80, 0x7C, 0x21, 0x08, 0x43, 0xF0, 0x12,
  0x22, 0x48, 0x44, 0x44, 0x60, 0x25, 0x24, 0x92, 0x52, 0x00, 0x20, 0x84,
  0x21, 0x0C, 0x84, 0x21, 0x30, 0x61, 0x3C,
};

const GFXglyph RobotoMono_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 2, 3, 7, 3, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 6, 11, 7, 1, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 7, 3, -9 },
  { 38, 4, 13, 7, 2, -10 },
  { 45, 4, 13, 7, 1, -10 },
  { 52, 5, 5, 7, 2, -9 },
  { 56, 5, 6, 7, 1, -7 },
  { 60, 2, 3, 7, 1, -1 },
  { 61, 5, 1, 7, 1, -4 },
  { 62, 1, 1, 7, 3, -1 },
  { 63, 5, 10, 7, 1, -9 },
  { 70, 5, 9, 7, 1, -9 },
  { 76, 3, 9, 7, 2, -9 },
  { 80, 6, 9, 7, 0, -9 },
  { 87, 6, 9, 7, 0, -9 },
  { 94, 6, 9, 7, 0, -9 },
  { 101, 6, 9, 7, 1, -9 },
  { 108, 5, 9, 7, 1, -9 },
  { 114, 6, 9, 7, 1, -9 },
  { 121, 6, 9, 7, 1, -9 },
  { 128, 5, 9, 7, 1, -9 },
  { 134, 2, 6, 7, 3, -6 },
  { 136, 3, 8, 7, 2, -6 },
  { 139, 5, 5, 7, 1, -6 },
  { 143, 5, 3, 7, 1, -5 },
  { 145, 5, 5, 7, 1, -6 },
  { 149, 4, 9, 7, 2, -9 },
  { 154, 7, 9, 7, 0, -9 },
  { 162, 6, 9, 7, 0, -9 },
  { 169, 6, 9, 7, 1, -9 },
  { 176, 6, 9, 7, 1, -9 },
  { 183, 7, 9, 7, 0, -9 },
  { 191, 6, 9, 7, 1, -9 },
  { 198, 6, 9, 7, 1, -9 },
  { 205, 6, 9, 7, 1, -9 },
  { 212, 7, 9, 7, 0, -9 },
  { 220, 6, 9, 7, 1, -9 },
  { 227, 7, 9, 7, 0, -9 },
  { 235, 6, 9, 7, 1, -9 },
  { 242, 5, 9, 7, 1, -9 },
  { 248, 7, 9, 7, 0, -9 },
  { 256, 7, 9, 7, 0, -9 },
  { 264, 6, 9, 7, 1, -9 },
  { 271, 6, 9, 7, 1, -9 },
  { 278, 6, 11, 7, 1, -9 },
  { 287, 6, 9, 7, 1, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 6, 9, 7, 1, -9 },
  { 308, 6, 9, 7, 1, -9 },
  { 315, 6, 9, 7, 1, -9 },
  { 322, 6, 9, 7, 1, -9 },
  { 329, 7, 9, 7, 0, -9 },
  { 337, 6, 9, 7, 1, -9 },
  { 344, 7, 9, 7, 0, -9 },
  { 352, 3, 12, 7, 2, -10 },
  { 357, 3, 10, 7, 2, -9 },
  { 361, 3, 12, 7, 2, -10 },
  { 366, 5, 5, 7, 1, -9 },
  { 370, 5, 1, 7, 0, 0 },
  { 371, 1, 2, 7, 4, -9 },
  { 372, 5, 6, 7, 1, -6 },
  { 376, 5, 9, 7, 1, -9 },
  { 382, 5, 6, 7, 1, -6 },
  { 386, 6, 9, 7, 1, -9 },
  { 393, 5, 6, 7, 1, -6 },
  { 397, 5, 9, 7, 2, -9 },
  { 403, 6, 9, 7, 0, -6 },
  { 410, 5, 9, 7, 1, -9 },
  { 416, 5, 9, 7, 1, -9 },
  { 422, 6, 12, 7, 0, -9 },
  { 431, 6, 9, 7, 1, -9 },
  { 438, 5, 9, 7, 1, -9 },
  { 444, 7, 6, 7, 0, -6 },
  { 450, 5, 6, 7, 1, -6 },
  { 454, 5, 6, 7, 1, -6 },
  { 458, 6, 8, 7, 0, -6 },
  { 464, 5, 8, 7, 1, -6 },
  { 469, 5, 6, 7, 2, -6 },
  { 473, 5, 6, 7, 1, -6 },
  { 477, 5, 8, 7, 1, -8 },
  { 482, 5, 6, 7, 1, -6 },
  { 486, 6, 6, 7, 1, -6 },
  { 491, 6, 6, 7, 1, -6 },
  { 496, 7, 6, 7, 0, -6 },
  { 502, 7, 9, 7, 0, -6 },
  { 510, 6, 6, 7, 0, -6 },
  { 515, 4, 11, 7, 2, -9 },
  { 521, 3, 11, 7, 2, -9 },
  { 526, 5, 11, 7, 1, -9 },
  { 533, 7, 2, 7, 0, -5 },
};

const GFXfont RobotoMono_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC12PT7B_H_
