#ifndef _ROBOTOMONO_EXTRALIGHTITALIC45PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x61, 0xB0, 0xD8,
  0x6C, 0x34, 0x12, 0x1B, 0x0D, 0x86, 0xC3, 0x41, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00,
  0x30, 0x18, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0x18, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x1E,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1,
  0xC0, 0x06, 0x03, 0x80, 0x78, 0x07, 0x8F, 0x80, 0x0F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xC6, 0x00, 0x18, 0x10, 0x00, 0xC0, 0xC0, 0x0C,
  0x06, 0x03, 0x60, 0x30, 0x33, 0x01, 0x83, 0x18, 0x08, 0x18, 0x80, 0x41,
  0x84, 0x06, 0x18, 0x30, 0x30, 0x81, 0x83, 0x0C, 0x07, 0x70, 0xC0, 0x1F,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0xF8, 0x03, 0x0E, 0x60, 0x30, 0xC1, 0x81, 0x84, 0x0C, 0x18,
  0x60, 0x21, 0x83, 0x01, 0x0C, 0x10, 0x08, 0xC1, 0x80, 0xCC, 0x0C, 0x06,
  0xC0, 0x60, 0x32, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x73, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xCE, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x43, 0x00, 0x01, 0xB8,
  0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x60, 0x00,
  0x38, 0xC0, 0x01, 0xC3, 0x80, 0xCE, 0x06, 0x03, 0x30, 0x0C, 0x0D, 0x80,
  0x30, 0x66, 0x00, 0x61, 0xB0, 0x00, 0xCE, 0xC0, 0x03, 0x33, 0x00, 0x07,
  0x8C, 0x00, 0x1E, 0x18, 0x00, 0x70, 0x60, 0x03, 0xE0, 0xC0, 0x1D, 0xC1,
  0xE3, 0xC3, 0x03, 0xFC, 0x06, 0x2D, 0xB6, 0x96, 0xD8, 0x00, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x38,
  0x18, 0x3F, 0xC2, 0x1F, 0x1F, 0x5F, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x30,
  0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x31, 0x86, 0x18, 0x63,
  0x0C, 0x63, 0x00, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0x8E, 0x00, 0xE0, 0x18, 0x0E,
  0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x19, 0x80, 0x03, 0xCC, 0x00, 0x3E, 0x60, 0x03, 0x32, 0x00,
  0x31, 0xB0, 0x03, 0x0D, 0x80, 0x70, 0x6C, 0x07, 0x02, 0x60, 0x60, 0x33,
  0x06, 0x01, 0x90, 0x60, 0x0D, 0x8E, 0x00, 0x6C, 0xE0, 0x02, 0x6C, 0x00,
  0x33, 0xC0, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x18, 0x07, 0x00, 0x71, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x30, 0x0E, 0x07, 0xE1, 0xE6, 0xF8, 0x6C, 0x06,
  0x80, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0x0F, 0x00, 0xE0, 0x1C, 0x0E,
  0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xC3, 0x80, 0x1C, 0x03, 0x00,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23,
  0x00, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x70, 0x01, 0x80, 0xE0,
  0x0E, 0x01, 0xE1, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0,
  0x00, 0x73, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x80, 0x03,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x06,
  0x00, 0x20, 0x30, 0x01, 0x81, 0x80, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x19, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xC0, 0x38, 0x0C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xE0, 0x60, 0x07, 0x00, 0xC0, 0x38, 0x03, 0xC3, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x7E, 0x03, 0x3F, 0xF0, 0xCC, 0x07,
  0x1F, 0x00, 0x73, 0x80, 0x06, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x30,
  0x70, 0x1C, 0x07, 0x8F, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC7,
  0x80, 0x38, 0x07, 0x01, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x18, 0x03, 0x00, 0x3C, 0x78,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x38, 0x07, 0x01, 0x80, 0x0E, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30,
  0x60, 0x01, 0x81, 0xC0, 0x1E, 0x03, 0xE3, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x3C, 0x78, 0x07, 0x01, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0x63,
  0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x00, 0x36, 0x38, 0x06, 0x41, 0xC1,
  0xCC, 0x0F, 0xF8, 0xC0, 0x18, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0F, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0x20, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x07, 0x8F, 0x06, 0x01, 0x86, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x1C, 0x01, 0x80, 0x38, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x18, 0x0C, 0x06, 0x18, 0x1F,
  0x83, 0x0C, 0x18, 0x61, 0x8C, 0x18, 0x30, 0x44, 0x18, 0x18, 0x26, 0x08,
  0x08, 0x12, 0x0C, 0x04, 0x1B, 0x04, 0x06, 0x0D, 0x86, 0x03, 0x06, 0x83,
  0x01, 0x03, 0x41, 0x00, 0x81, 0x61, 0x80, 0xC0, 0xB0, 0xC0, 0x60, 0xD8,
  0x60, 0x60, 0x4C, 0x30, 0x30, 0x26, 0x18, 0x38, 0x33, 0x0C, 0x34, 0x31,
  0x86, 0x32, 0x30, 0xC1, 0xF1, 0xF0, 0x20, 0x20, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x3C, 0x7C,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x44, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x06, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x04, 0x03,
  0x00, 0x10, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x03, 0x81, 0x80,
  0x78, 0x07, 0xFF, 0xC0, 0x18, 0x03, 0xC0, 0x40, 0x03, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x88,
  0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x07, 0x18, 0x00,
  0x38, 0x60, 0x01, 0xC1, 0x00, 0x1E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xC7, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0C, 0x0E,
  0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x03, 0x00, 0xC0, 0x18, 0x01, 0xC3,
  0xC0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x88,
  0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x70, 0x18, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xC7, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x0E,
  0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x7F, 0xCC, 0x01, 0xFF, 0x30, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x70, 0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xE1,
  0xF0, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x10,
  0x00, 0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x10, 0x3F, 0xFF, 0xF8, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x0F, 0x0F, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x10,
  0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0x30, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x67, 0x80, 0x00, 0x1B, 0x30, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x03, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x68, 0x00, 0xD0,
  0x36, 0x00, 0x78, 0x1B, 0x00, 0x6C, 0x0D, 0x80, 0x66, 0x04, 0xC0, 0x33,
  0x06, 0x20, 0x31, 0x83, 0x10, 0x18, 0x81, 0x8C, 0x18, 0xC0, 0xC6, 0x0C,
  0x60, 0x63, 0x0C, 0x30, 0x21, 0x84, 0x18, 0x30, 0x46, 0x0C, 0x18, 0x36,
  0x0C, 0x0C, 0x1B, 0x06, 0x06, 0x0F, 0x03, 0x03, 0x07, 0x81, 0x83, 0x01,
  0x80, 0xC1, 0x80, 0xC0, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x40, 0xF0, 0x00,
  0x60, 0x78, 0x00, 0x30, 0x36, 0x00, 0x18, 0x1B, 0x00, 0x0C, 0x08, 0x80,
  0x06, 0x0C, 0x60, 0x02, 0x06, 0x30, 0x03, 0x03, 0x0C, 0x01, 0x81, 0x86,
  0x00, 0xC0, 0xC3, 0x00, 0x60, 0x40, 0xC0, 0x30, 0x60, 0x60, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x01, 0x03, 0x02,
  0x00, 0xC1, 0x83, 0x00, 0x61, 0x81, 0x80, 0x18, 0xC0, 0xC0, 0x0C, 0x60,
  0x60, 0x06, 0x30, 0x30, 0x01, 0x98, 0x30, 0x00, 0xC8, 0x18, 0x00, 0x2C,
  0x0C, 0x00, 0x1E, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x03, 0x81, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0x8E, 0x00, 0xE0, 0x18,
  0x0E, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x30, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x16,
  0x00, 0x00, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x18, 0x07, 0x00, 0x78,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x18, 0x00,
  0xE0, 0x20, 0x00, 0xE0, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x38, 0x30, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xF1, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0,
  0x70, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0x40, 0x00, 0x30,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03,
  0x00, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x18, 0x01, 0xC0, 0x30,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x02, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x70,
  0x18, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x20,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60, 0x00, 0x18, 0x00, 0x3F,
  0xE0, 0x01, 0xF1, 0xE0, 0x07, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x60, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x83, 0x00, 0x0E, 0x07, 0x00, 0x38,
  0x03, 0xC7, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x01, 0xC0,
  0x07, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0x90, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x80, 0x07, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x10, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x86, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x05,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x07, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x16, 0x03, 0x80, 0x6C, 0x07, 0x00,
  0xD8, 0x0A, 0x01, 0x30, 0x34, 0x06, 0x60, 0x6C, 0x0C, 0xC0, 0x98, 0x11,
  0x03, 0x30, 0x62, 0x06, 0x60, 0xC4, 0x08, 0xC1, 0x88, 0x31, 0x82, 0x10,
  0x63, 0x0C, 0x20, 0x86, 0x18, 0x43, 0x0C, 0x20, 0x86, 0x18, 0xC1, 0x08,
  0x31, 0x82, 0x30, 0x62, 0x04, 0x60, 0xCC, 0x08, 0x81, 0x98, 0x13, 0x03,
  0x30, 0x26, 0x06, 0x40, 0x58, 0x0D, 0x80, 0xB0, 0x1B, 0x01, 0x60, 0x34,
  0x02, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x60,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x02, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xC0, 0x60,
  0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0xC0, 0x05, 0x80, 0x1B, 0x00, 0x62, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18,
  0x18, 0x30, 0x30, 0x20, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x01, 0x30,
  0x03, 0xC0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x0C, 0x61, 0x84,
  0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xE0, 0x18, 0x0C, 0x00, 0x60, 0xC0,
  0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0xF8, 0x03, 0x0E, 0x00,
  0x10, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30,
  0x00, 0x38, 0x80, 0x03, 0x86, 0x00, 0x3C, 0x38, 0x07, 0x60, 0xF1, 0xF3,
  0x03, 0xFE, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x0F, 0xE0, 0x19, 0xFF, 0x80, 0xD8,
  0x0E, 0x07, 0x80, 0x30, 0x38, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x10,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x88,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x06,
  0x0F, 0x00, 0xE0, 0xCF, 0x1E, 0x06, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0x00, 0xC0, 0xE0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x70,
  0x03, 0x83, 0x80, 0x70, 0x1E, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x0F, 0xE1, 0x00, 0xFF, 0xCC, 0x07, 0x01, 0xB0, 0x38, 0x03, 0xC1,
  0xC0, 0x07, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x04,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x40, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x38, 0x0C, 0x03,
  0xE0, 0x1C, 0x39, 0x80, 0x3F, 0xC6, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0x01, 0xC0, 0xE0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x03, 0x30, 0x00,
  0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x08, 0x30, 0x01, 0xC3,
  0x80, 0x38, 0x1E, 0x1E, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xF8,
  0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x0C, 0x07, 0xFE, 0x60, 0x38, 0x0D, 0x81, 0xC0, 0x1E,
  0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x21, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x82, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0, 0x60,
  0x1F, 0x00, 0xE1, 0xCC, 0x01, 0xFE, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x07, 0x03, 0x00, 0x18, 0x0E,
  0x01, 0xC0, 0x1E, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x07, 0xE0, 0x18, 0xFF, 0xC0, 0xCC, 0x07, 0x04, 0x80, 0x18,
  0x68, 0x00, 0xC3, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x20, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x0E, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x0C, 0x00, 0xC0, 0x60, 0x1C, 0x03,
  0x01, 0xC0, 0x18, 0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0x63, 0x80,
  0x03, 0x38, 0x00, 0x1B, 0xE0, 0x00, 0xF3, 0x00, 0x07, 0x0C, 0x00, 0x60,
  0x70, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x20, 0x03, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0xF8, 0x3E, 0x0D, 0xFE,
  0x7F, 0x87, 0x83, 0xE0, 0x63, 0x80, 0xE0, 0x31, 0x80, 0x60, 0x18, 0xC0,
  0x30, 0x0C, 0x40, 0x18, 0x06, 0x60, 0x0C, 0x03, 0x30, 0x04, 0x01, 0x98,
  0x06, 0x00, 0xCC, 0x03, 0x00, 0x46, 0x01, 0x80, 0x62, 0x00, 0xC0, 0x33,
  0x00, 0x60, 0x19, 0x80, 0x20, 0x0C, 0xC0, 0x30, 0x06, 0x60, 0x18, 0x02,
  0x20, 0x0C, 0x03, 0x10, 0x06, 0x01, 0x98, 0x02, 0x00, 0xCC, 0x01, 0x00,
  0x66, 0x01, 0x80, 0x33, 0x00, 0xC0, 0x11, 0x00, 0x60, 0x18, 0x0C, 0x1F,
  0x80, 0x63, 0xFF, 0x03, 0x70, 0x1C, 0x16, 0x00, 0x61, 0xA0, 0x03, 0x0E,
  0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x18, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xE0,
  0xC0, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x06, 0x40, 0x00, 0x33, 0x00, 0x03,
  0x18, 0x00, 0x18, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x0C, 0x03, 0x80, 0x38,
  0x78, 0x00, 0xFF, 0x00, 0x06, 0x1F, 0x80, 0x19, 0xFF, 0x80, 0x6C, 0x07,
  0x01, 0x60, 0x0C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0xF0, 0x0E, 0x06, 0x79, 0xF0, 0x18, 0xFF, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x18, 0x1F, 0xF9, 0x81, 0xC0, 0x6C, 0x1C, 0x01, 0xE1, 0xC0, 0x07,
  0x0C, 0x00, 0x38, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x04, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x10, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x18, 0x07, 0xC0, 0x79, 0xE6, 0x01,
  0xFE, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x0C, 0x1F, 0xE1, 0x0F, 0xF8, 0x67, 0x80, 0x0D, 0xC0, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0x00, 0xE0, 0xC0, 0x07, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00,
  0x0C, 0x60, 0x01, 0xC7, 0x00, 0x38, 0x3E, 0x1F, 0x00, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0xC6, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00,
  0x18, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x06,
  0x00, 0x68, 0x18, 0x06, 0xC0, 0xF1, 0xE6, 0x03, 0xFE, 0x30, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x21, 0x80, 0x01, 0x98, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0xC0, 0x38, 0x06, 0xC0, 0x38,
  0x06, 0x40, 0x28, 0x0C, 0x40, 0x68, 0x0C, 0x40, 0x48, 0x08, 0x40, 0xC8,
  0x18, 0x40, 0xC8, 0x18, 0x41, 0x88, 0x30, 0x61, 0x8C, 0x30, 0x61, 0x0C,
  0x20, 0x63, 0x0C, 0x60, 0x62, 0x0C, 0x60, 0x66, 0x0C, 0x40, 0x66, 0x0C,
  0xC0, 0x64, 0x0C, 0xC0, 0x6C, 0x0D, 0x80, 0x68, 0x05, 0x80, 0x78, 0x05,
  0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0x63, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x06,
  0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x1F, 0xE0, 0x03, 0x30, 0x70,
  0x03, 0x60, 0x18, 0x06, 0x40, 0x0C, 0x06, 0xC0, 0x07, 0x3C, 0xC0, 0x03,
  0xF8,
};

const GFXglyph RobotoMono_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 8, 32, 26, 9, -32 },
  { 33, 9, 10, 26, 11, -34 },
  { 45, 26, 32, 26, 1, -32 },
  { 149, 22, 42, 26, 3, -37 },
  { 265, 21, 32, 26, 3, -32 },
  { 349, 22, 32, 26, 2, -32 },
  { 437, 3, 10, 26, 13, -34 },
  { 441, 13, 46, 26, 8, -36 },
  { 516, 14, 46, 26, 4, -36 },
  { 597, 19, 18, 26, 6, -32 },
  { 640, 21, 24, 26, 3, -27 },
  { 703, 6, 10, 26, 5, -4 },
  { 711, 16, 1, 26, 5, -15 },
  { 713, 4, 3, 26, 10, -3 },
  { 715, 21, 35, 26, 3, -32 },
  { 807, 21, 32, 26, 3, -32 },
  { 891, 12, 32, 26, 7, -32 },
  { 939, 21, 32, 26, 1, -32 },
  { 1023, 22, 32, 26, 1, -32 },
  { 1111, 22, 32, 26, 1, -32 },
  { 1199, 22, 32, 26, 4, -32 },
  { 1287, 19, 32, 26, 3, -32 },
  { 1363, 21, 32, 26, 5, -32 },
  { 1447, 22, 32, 26, 3, -32 },
  { 1535, 20, 32, 26, 4, -32 },
  { 1615, 7, 22, 26, 11, -22 },
  { 1635, 9, 28, 26, 9, -22 },
  { 1667, 20, 19, 26, 4, -24 },
  { 1715, 21, 11, 26, 3, -20 },
  { 1744, 20, 19, 26, 3, -24 },
  { 1792, 17, 32, 26, 7, -32 },
  { 1860, 25, 32, 26, 1, -32 },
  { 1960, 22, 32, 26, 0, -32 },
  { 2048, 22, 32, 26, 2, -32 },
  { 2136, 22, 32, 26, 3, -32 },
  { 2224, 23, 32, 26, 2, -32 },
  { 2316, 24, 32, 26, 2, -32 },
  { 2412, 24, 32, 26, 2, -32 },
  { 2508, 22, 32, 26, 3, -32 },
  { 2596, 25, 32, 26, 1, -32 },
  { 2696, 23, 32, 26, 2, -32 },
  { 2788, 23, 32, 26, 2, -32 },
  { 2880, 26, 32, 26, 2, -32 },
  { 2984, 18, 32, 26, 3, -32 },
  { 3056, 25, 32, 26, 1, -32 },
  { 3156, 25, 32, 26, 1, -32 },
  { 3256, 21, 32, 26, 3, -32 },
  { 3340, 23, 32, 26, 3, -32 },
  { 3432, 23, 38, 26, 2, -32 },
  { 3542, 23, 32, 26, 2, -32 },
  { 3634, 23, 32, 26, 2, -32 },
  { 3726, 22, 32, 26, 5, -32 },
  { 3814, 23, 32, 26, 3, -32 },
  { 3906, 22, 32, 26, 5, -32 },
  { 3994, 23, 32, 26, 5, -32 },
  { 4086, 27, 32, 26, 0, -32 },
  { 4194, 22, 32, 26, 5, -32 },
  { 4282, 24, 32, 26, 1, -32 },
  { 4378, 13, 44, 26, 7, -37 },
  { 4450, 9, 35, 26, 9, -32 },
  { 4490, 14, 44, 26, 6, -37 },
  { 4567, 15, 17, 26, 6, -32 },
  { 4599, 19, 2, 26, 1, 0 },
  { 4604, 5, 6, 26, 13, -33 },
  { 4608, 21, 24, 26, 2, -24 },
  { 4671, 21, 34, 26, 2, -34 },
  { 4761, 20, 24, 26, 3, -24 },
  { 4821, 22, 34, 26, 3, -34 },
  { 4915, 20, 24, 26, 3, -24 },
  { 4975, 21, 34, 26, 6, -34 },
  { 5065, 22, 34, 26, 2, -24 },
  { 5159, 21, 34, 26, 2, -34 },
  { 5249, 18, 32, 26, 3, -32 },
  { 5321, 21, 42, 26, 0, -32 },
  { 5432, 21, 34, 26, 3, -34 },
  { 5522, 18, 34, 26, 3, -34 },
  { 5599, 25, 24, 26, 0, -24 },
  { 5674, 21, 24, 26, 2, -24 },
  { 5737, 21, 24, 26, 2, -24 },
  { 5800, 22, 33, 26, 1, -24 },
  { 5891, 21, 33, 26, 3, -24 },
  { 5978, 19, 24, 26, 6, -24 },
  { 6035, 20, 24, 26, 3, -24 },
  { 6095, 18, 30, 26, 5, -30 },
  { 6163, 21, 24, 26, 3, -24 },
  { 6226, 21, 24, 26, 4, -24 },
  { 6289, 24, 24, 26, 3, -24 },
  { 6361, 24, 24, 26, 1, -24 },
  { 6433, 27, 34, 26, -1, -24 },
  { 6548, 23, 24, 26, 1, -24 },
  { 6617, 17, 44, 26, 7, -35 },
  { 6711, 8, 39, 26, 9, -32 },
  { 6750, 17, 44, 26, 4, -35 },
  { 6844, 24, 7, 26, 1, -17 },
};

const GFXfont RobotoMono_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC45PT7B_H_
