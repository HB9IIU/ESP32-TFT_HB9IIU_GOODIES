#ifndef _ROBOTOMONO_EXTRALIGHTITALIC65PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x30, 0x39, 0x81, 0xCC, 0x0E, 0xE0, 0x67,
  0x03, 0x38, 0x19, 0x81, 0xCC, 0x0E, 0x60, 0x67, 0x03, 0x38, 0x19, 0x80,
  0xCC, 0x0E, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x04, 0x30, 0x03, 0x80, 0x1C, 0x60, 0x07, 0x00, 0x71, 0xC0,
  0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x03, 0x07, 0x00, 0x30, 0x0E, 0x0C, 0x00,
  0x60, 0x38, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x03, 0x81, 0xC0, 0x70, 0x06,
  0x07, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0xC0, 0x70, 0x30, 0x01, 0xC1, 0xC0,
  0xE0, 0x01, 0xFF, 0x03, 0x80, 0x01, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x02, 0x00, 0x00, 0x60, 0x3F,
  0x80, 0x01, 0xC1, 0xFF, 0x80, 0x07, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x03,
  0x00, 0x38, 0x38, 0x07, 0x00, 0xE0, 0x60, 0x06, 0x01, 0x81, 0xC0, 0x0C,
  0x07, 0x03, 0x80, 0x18, 0x1C, 0x06, 0x00, 0x30, 0x70, 0x0C, 0x00, 0x60,
  0xC0, 0x18, 0x01, 0xC3, 0x80, 0x70, 0x03, 0x8E, 0x00, 0xE0, 0x06, 0x38,
  0x01, 0xC0, 0x0C, 0x30, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x0E, 0x00,
  0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x06, 0x38, 0x00, 0x70, 0x0E, 0x38, 0x00,
  0x78, 0x0E, 0x70, 0x00, 0x38, 0x0C, 0x70, 0x00, 0x1C, 0x1C, 0x60, 0x00,
  0x1C, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0xE0, 0x00, 0x07, 0x78, 0xE0, 0x00,
  0x07, 0x70, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0F, 0xF0, 0x3C, 0x00,
  0x3C, 0x70, 0x1F, 0x00, 0xF8, 0x38, 0x0F, 0xFF, 0xE0, 0x38, 0x03, 0xFF,
  0x80, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x39, 0x8C, 0x67, 0x39, 0xCC, 0x63,
  0x39, 0x8C, 0x60, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0x7E, 0x01, 0xC0,
  0x7F, 0xF8, 0x38, 0x3F, 0x9F, 0xC6, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x80,
  0x78, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0xE0, 0xE0, 0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x31, 0xE7, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x7F,
  0x38, 0x00, 0x03, 0x9C, 0xE0, 0x00, 0x1C, 0x73, 0x00, 0x00, 0xE1, 0xDC,
  0x00, 0x0F, 0x06, 0x70, 0x00, 0x78, 0x19, 0xC0, 0x03, 0xC0, 0xE7, 0x00,
  0x1C, 0x03, 0x9C, 0x00, 0xE0, 0x0E, 0x60, 0x07, 0x00, 0x3B, 0x80, 0x78,
  0x00, 0xCE, 0x03, 0xC0, 0x03, 0x38, 0x1C, 0x00, 0x1C, 0xE0, 0xE0, 0x00,
  0x73, 0x87, 0x00, 0x01, 0xCC, 0x78, 0x00, 0x06, 0x33, 0xC0, 0x00, 0x38,
  0xDC, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x78, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7E, 0x30, 0xFC,
  0x3B, 0xF8, 0x1D, 0xE0, 0x0E, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x03,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0xE0, 0x00, 0x3B, 0xFF, 0xF0, 0x00,
  0x7F, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0xFF, 0x80, 0x1C, 0x3F, 0xFE, 0x01, 0x8F, 0xC1, 0xF0, 0x39,
  0xE0, 0x07, 0x83, 0xB8, 0x00, 0x3C, 0x36, 0x00, 0x01, 0xC7, 0xC0, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x30, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x7E, 0x3C, 0x00, 0x0E, 0xE1, 0xC0,
  0x01, 0xCC, 0x0F, 0x00, 0x79, 0xC0, 0x7F, 0xFF, 0x1C, 0x03, 0xFF, 0xC1,
  0x80, 0x0F, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0x81, 0xF0,
  0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x0F, 0x83,
  0xE0, 0x70, 0x00, 0x00, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x06, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x1F, 0x00, 0x60, 0x30, 0x07, 0xFC, 0x06, 0x07, 0x00, 0xF1, 0xE0,
  0x70, 0xE0, 0x3C, 0x06, 0x07, 0x0E, 0x03, 0x80, 0x60, 0x71, 0xC0, 0x70,
  0x0C, 0x07, 0x18, 0x0E, 0x00, 0xC0, 0x71, 0x80, 0xC0, 0x0C, 0x07, 0x38,
  0x1C, 0x00, 0xC0, 0x73, 0x01, 0x80, 0x18, 0x06, 0x70, 0x38, 0x01, 0x80,
  0x67, 0x03, 0x00, 0x18, 0x06, 0x60, 0x30, 0x03, 0x80, 0x66, 0x07, 0x00,
  0x30, 0x06, 0xE0, 0x60, 0x03, 0x00, 0xEC, 0x06, 0x00, 0x30, 0x0C, 0xC0,
  0x60, 0x07, 0x00, 0xCC, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0xE0, 0x06, 0x01,
  0xCC, 0x0E, 0x00, 0xE0, 0x18, 0xC0, 0xC0, 0x1E, 0x01, 0x8C, 0x0C, 0x01,
  0xC0, 0x30, 0xC0, 0xE0, 0x3C, 0x03, 0x0C, 0x0E, 0x06, 0xE0, 0x60, 0xC0,
  0x60, 0xE6, 0x0E, 0x0C, 0x07, 0xFC, 0x73, 0xC0, 0xC0, 0x3F, 0x03, 0xF8,
  0x0E, 0x01, 0xE0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xC0,
  0x07, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x3F, 0xC0, 0x0C, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0xC0, 0x60, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0xFF, 0xFC, 0xE0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x40, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x03,
  0x1F, 0x80, 0x00, 0x00, 0x39, 0xFC, 0x00, 0x00, 0x01, 0xDE, 0x70, 0x00,
  0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0x60,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x19, 0x80, 0x00,
  0xEE, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x39, 0xC0, 0x01, 0xCC, 0x03, 0x9C,
  0x00, 0x39, 0xC0, 0x39, 0xC0, 0x03, 0x1C, 0x03, 0x8C, 0x00, 0x71, 0xC0,
  0x30, 0xC0, 0x0E, 0x18, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x70, 0xE0, 0x1C,
  0x18, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x07, 0x06,
  0x03, 0x83, 0x80, 0x60, 0x60, 0x70, 0x30, 0x06, 0x07, 0x06, 0x03, 0x00,
  0xE0, 0x70, 0xE0, 0x70, 0x0E, 0x07, 0x1C, 0x07, 0x00, 0xE0, 0x31, 0xC0,
  0x70, 0x0E, 0x03, 0x38, 0x07, 0x00, 0xC0, 0x33, 0x80, 0x60, 0x0C, 0x03,
  0xF0, 0x06, 0x01, 0xC0, 0x3E, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x1C, 0x07, 0xC0, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x00, 0x70, 0x1F, 0x00,
  0x00, 0x0E, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x6E, 0x00, 0x00, 0x70, 0x0C,
  0xC0, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x01, 0xC0, 0x73, 0x80, 0x00, 0x38,
  0x0E, 0x30, 0x00, 0x07, 0x01, 0xC7, 0x00, 0x00, 0xC0, 0x30, 0x60, 0x00,
  0x38, 0x06, 0x0E, 0x00, 0x07, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x18,
  0x00, 0x1C, 0x07, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x18,
  0x06, 0x00, 0x1C, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x70,
  0x1C, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x01, 0x80, 0x70, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x70, 0x00,
  0xC0, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x30,
  0x00, 0x30, 0x18, 0x06, 0x00, 0x07, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0,
  0x38, 0x00, 0x0C, 0x1C, 0x07, 0x00, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0x18,
  0x60, 0x18, 0x00, 0x03, 0x9C, 0x03, 0x00, 0x00, 0x73, 0x80, 0xE0, 0x00,
  0x06, 0x70, 0x1C, 0x00, 0x00, 0xEE, 0x03, 0x80, 0x00, 0x1D, 0xC0, 0x70,
  0x00, 0x01, 0xB0, 0x0C, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0C, 0x03, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xFC, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xA0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xF8,
  0x00, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0x00, 0x3B, 0x80, 0x0F, 0x00, 0x0C,
  0xE0, 0x03, 0xC0, 0x03, 0x30, 0x00, 0xF0, 0x01, 0xCC, 0x00, 0x7C, 0x00,
  0x63, 0x00, 0x1B, 0x00, 0x18, 0xC0, 0x06, 0xC0, 0x0E, 0x30, 0x03, 0xB0,
  0x03, 0x8C, 0x00, 0xCC, 0x00, 0xC3, 0x00, 0x73, 0x00, 0x70, 0xC0, 0x1C,
  0xC0, 0x1C, 0x30, 0x06, 0x30, 0x06, 0x0C, 0x03, 0x8C, 0x01, 0x83, 0x00,
  0xE3, 0x00, 0xE0, 0xC0, 0x30, 0xE0, 0x30, 0x30, 0x1C, 0x38, 0x0C, 0x0C,
  0x07, 0x0E, 0x07, 0x03, 0x01, 0x83, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x30, 0x38, 0x38, 0x38, 0x0C, 0x0C, 0x0E, 0x0E, 0x03, 0x07, 0x03, 0x83,
  0x00, 0xC1, 0xC0, 0xE0, 0xC0, 0x30, 0x60, 0x38, 0x70, 0x0C, 0x38, 0x0E,
  0x18, 0x03, 0x0E, 0x03, 0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x31, 0xC0,
  0x38, 0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCE,
  0x00, 0x67, 0x00, 0x33, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x77, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x70, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0x03, 0xE0, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x78, 0x60, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xEC, 0x0F, 0x00, 0x1F, 0x70, 0x1E, 0x01,
  0xF1, 0xC0, 0x3F, 0xFF, 0x87, 0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0xE1, 0xFF,
  0xE0, 0x03, 0x1F, 0xFF, 0xC0, 0x0C, 0xF0, 0x07, 0x80, 0x77, 0x00, 0x0F,
  0x01, 0xF8, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x1F, 0x00, 0x01, 0xE0, 0x7E, 0x00,
  0x0F, 0x01, 0xDC, 0x00, 0x78, 0x06, 0x3C, 0x07, 0xC0, 0x38, 0x7F, 0xFE,
  0x00, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x1F, 0xFC, 0x1C,
  0x00, 0x7F, 0xFF, 0x1C, 0x00, 0xF8, 0x07, 0x9C, 0x01, 0xE0, 0x01, 0xB8,
  0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x3B, 0x80,
  0x0F, 0x01, 0xF3, 0x80, 0x07, 0xFF, 0xE3, 0x00, 0x03, 0xFF, 0x87, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x02, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x07, 0x00,
  0x1F, 0xFF, 0xC7, 0x00, 0x3E, 0x01, 0xE7, 0x00, 0x78, 0x00, 0x66, 0x00,
  0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x0E, 0xE0, 0x03,
  0xC0, 0x7C, 0xE0, 0x01, 0xFF, 0xF8, 0xC0, 0x00, 0xFF, 0xE0, 0xC0, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x20,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x07, 0xF0, 0x00, 0xC0, 0xFF, 0xF0, 0x03, 0x07, 0xFF, 0xE0, 0x1C,
  0x78, 0x03, 0xC0, 0x73, 0x80, 0x07, 0x81, 0xDC, 0x00, 0x0E, 0x06, 0xE0,
  0x00, 0x38, 0x1B, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x60, 0xF0, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07,
  0x3F, 0x00, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x3E,
  0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x0E, 0x7F, 0xE0, 0xFF, 0x80, 0x33, 0xFF, 0xC7,
  0xFF, 0x00, 0xDC, 0x07, 0x38, 0x1E, 0x03, 0xE0, 0x1D, 0x80, 0x38, 0x1F,
  0x00, 0x3C, 0x00, 0x60, 0x78, 0x00, 0xF0, 0x01, 0x81, 0xC0, 0x03, 0x80,
  0x06, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0x60, 0x60,
  0x01, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE0, 0x01,
  0xC1, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0x03, 0x83, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x60, 0x00, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0C, 0x0F, 0xFF, 0x00, 0x30, 0x7F, 0xFE, 0x01, 0xC7, 0x80,
  0x3C, 0x07, 0x38, 0x00, 0x70, 0x1D, 0xC0, 0x00, 0xE0, 0x6E, 0x00, 0x03,
  0x81, 0xF0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x00, 0xC1,
  0xFF, 0xC0, 0x00, 0xC7, 0xFF, 0xF0, 0x00, 0xCF, 0x00, 0xF8, 0x01, 0xDC,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x1F, 0xC0,
  0x07, 0x80, 0x19, 0xE0, 0x1F, 0x00, 0x38, 0xFF, 0xFE, 0x00, 0x38, 0x3F,
  0xF8, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x70, 0x07, 0xFF, 0xF1, 0xC0, 0x3E, 0x01, 0xE6, 0x01, 0xE0, 0x01,
  0xD8, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xF8, 0x07, 0x80, 0x0E, 0xE0, 0x0F, 0x01, 0xF3, 0x80, 0x1F, 0xFF,
  0x8C, 0x00, 0x3F, 0xF8, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x38, 0x0F,
  0xFF, 0x03, 0x83, 0xFF, 0xE0, 0x30, 0xF8, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1F, 0x07,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x1D, 0x80, 0xE0, 0x03, 0xDC, 0x07, 0xC0,
  0x7C, 0xE0, 0x1F, 0xFF, 0x87, 0x00, 0x3F, 0xF0, 0x38, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xEC, 0x00, 0x3C,
  0x00, 0x3B, 0x80, 0x0F, 0x00, 0x0C, 0xE0, 0x03, 0xC0, 0x07, 0x38, 0x01,
  0xF0, 0x01, 0xCE, 0x00, 0x6C, 0x00, 0x63, 0x80, 0x3B, 0x00, 0x38, 0xE0,
  0x0C, 0xC0, 0x0C, 0x38, 0x03, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01, 0xC3,
  0x80, 0x63, 0x80, 0x60, 0xE0, 0x38, 0xE0, 0x38, 0x38, 0x0C, 0x38, 0x0C,
  0x0E, 0x03, 0x06, 0x07, 0x01, 0x81, 0xC1, 0x81, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x18, 0x38, 0x18, 0x38, 0x06, 0x0C, 0x06, 0x0C, 0x01, 0x87, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x61, 0xC0, 0x18, 0x60, 0x18, 0x60, 0x06, 0x38,
  0x06, 0x38, 0x01, 0x8C, 0x01, 0x8E, 0x00, 0x67, 0x00, 0x73, 0x00, 0x19,
  0x80, 0x1D, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x0F, 0xFF, 0x00, 0x00,
  0x61, 0xE0, 0x7C, 0x00, 0x0E, 0x1C, 0x01, 0xE0, 0x00, 0xE3, 0x80, 0x0F,
  0x00, 0x1C, 0x70, 0x00, 0x78, 0x01, 0xC7, 0x00, 0x03, 0xC0, 0x78, 0x60,
  0x00, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 11, 46, 38, 13, -46 },
  { 65, 13, 14, 38, 16, -49 },
  { 88, 38, 46, 38, 1, -46 },
  { 307, 31, 60, 38, 4, -53 },
  { 540, 31, 48, 38, 4, -47 },
  { 726, 32, 48, 38, 3, -47 },
  { 918, 5, 14, 38, 19, -49 },
  { 927, 20, 67, 38, 11, -52 },
  { 1095, 20, 67, 38, 6, -52 },
  { 1263, 27, 26, 38, 9, -46 },
  { 1351, 31, 33, 38, 4, -38 },
  { 1479, 8, 15, 38, 8, -6 },
  { 1494, 23, 2, 38, 7, -22 },
  { 1500, 6, 5, 38, 14, -5 },
  { 1504, 30, 50, 38, 5, -46 },
  { 1692, 30, 48, 38, 5, -47 },
  { 1872, 17, 46, 38, 10, -46 },
  { 1970, 31, 47, 38, 1, -47 },
  { 2153, 31, 48, 38, 2, -47 },
  { 2339, 31, 46, 38, 2, -46 },
  { 2518, 31, 47, 38, 6, -46 },
  { 2701, 28, 48, 38, 4, -47 },
  { 2869, 29, 46, 38, 8, -46 },
  { 3036, 32, 48, 38, 4, -47 },
  { 3228, 28, 47, 38, 6, -47 },
  { 3393, 10, 33, 38, 16, -33 },
  { 3435, 14, 42, 38, 12, -33 },
  { 3509, 29, 26, 38, 5, -34 },
  { 3604, 31, 16, 38, 4, -29 },
  { 3666, 29, 26, 38, 4, -34 },
  { 3761, 24, 47, 38, 10, -47 },
  { 3902, 36, 47, 38, 2, -47 },
  { 4114, 32, 46, 38, 0, -46 },
  { 4298, 32, 46, 38, 3, -46 },
  { 4482, 32, 48, 38, 4, -47 },
  { 4674, 34, 46, 38, 2, -46 },
  { 4870, 34, 46, 38, 3, -46 },
  { 5066, 34, 46, 38, 3, -46 },
  { 5262, 32, 48, 38, 4, -47 },
  { 5454, 35, 46, 38, 2, -46 },
  { 5656, 33, 46, 38, 3, -46 },
  { 5846, 34, 47, 38, 2, -46 },
  { 6046, 37, 46, 38, 3, -46 },
  { 6259, 26, 46, 38, 4, -46 },
  { 6409, 36, 46, 38, 2, -46 },
  { 6616, 35, 46, 38, 2, -46 },
  { 6818, 31, 48, 38, 4, -47 },
  { 7004, 34, 46, 38, 4, -46 },
  { 7200, 33, 55, 38, 3, -47 },
  { 7427, 33, 46, 38, 3, -46 },
  { 7617, 33, 48, 38, 3, -47 },
  { 7815, 33, 46, 38, 7, -46 },
  { 8005, 33, 47, 38, 4, -46 },
  { 8199, 32, 46, 38, 7, -46 },
  { 8383, 34, 46, 38, 7, -46 },
  { 8579, 38, 46, 38, 1, -46 },
  { 8798, 32, 46, 38, 7, -46 },
  { 8982, 35, 46, 38, 1, -46 },
  { 9184, 19, 63, 38, 10, -53 },
  { 9334, 13, 50, 38, 13, -46 },
  { 9416, 20, 63, 38, 9, -53 },
  { 9574, 22, 25, 38, 8, -46 },
  { 9643, 27, 2, 38, 2, 0 },
  { 9650, 7, 9, 38, 19, -48 },
  { 9658, 30, 36, 38, 3, -35 },
  { 9793, 30, 50, 38, 3, -49 },
  { 9981, 29, 36, 38, 4, -35 },
  { 10112, 32, 50, 38, 4, -49 },
  { 10312, 30, 36, 38, 4, -35 },
  { 10447, 32, 50, 38, 8, -50 },
  { 10647, 32, 49, 38, 2, -35 },
  { 10843, 30, 49, 38, 3, -49 },
  { 11027, 27, 47, 38, 4, -47 },
  { 11186, 30, 61, 38, 0, -47 },
  { 11415, 31, 49, 38, 4, -49 },
  { 11605, 27, 49, 38, 4, -49 },
  { 11771, 38, 35, 38, -1, -35 },
  { 11938, 30, 35, 38, 3, -35 },
  { 12070, 31, 36, 38, 3, -35 },
  { 12210, 32, 48, 38, 1, -35 },
  { 12402, 30, 48, 38, 4, -35 },
  { 12582, 28, 35, 38, 8, -35 },
  { 12705, 30, 36, 38, 4, -35 },
  { 12840, 25, 44, 38, 8, -43 },
  { 12978, 29, 35, 38, 5, -34 },
  { 13105, 31, 34, 38, 6, -34 },
  { 13237, 34, 34, 38, 5, -34 },
  { 13382, 35, 34, 38, 1, -34 },
  { 13531, 39, 48, 38, -1, -34 },
  { 13765, 34, 34, 38, 1, -34 },
  { 13910, 25, 64, 38, 10, -51 },
  { 14110, 11, 56, 38, 13, -46 },
  { 14187, 25, 64, 38, 6, -51 },
  { 14387, 36, 11, 38, 1, -25 },
};

const GFXfont RobotoMono_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC65PT7B_H_
