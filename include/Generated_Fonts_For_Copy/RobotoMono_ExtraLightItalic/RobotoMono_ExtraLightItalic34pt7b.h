#ifndef _ROBOTOMONO_EXTRALIGHTITALIC34PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x30, 0x82,
  0x08, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x62, 0xC5, 0x0A, 0x34, 0x48,
  0xB1, 0x42, 0x00, 0x10, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x0C,
  0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x01, 0xFF, 0xFF, 0x00, 0x83,
  0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x03, 0x04, 0x00, 0x20,
  0x40, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x7F, 0xFF, 0x88, 0x41, 0x80, 0x0C,
  0x10, 0x00, 0x81, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x10, 0x60, 0x03,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x1F,
  0xC0, 0x38, 0x30, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x01, 0x0C, 0x00, 0x84,
  0x00, 0x43, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x18, 0x80, 0x08, 0x40, 0x0C, 0x30, 0x0C, 0x0C, 0x1C, 0x03,
  0xFC, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3E, 0x00,
  0x21, 0x00, 0x41, 0x02, 0x41, 0x06, 0xC1, 0x04, 0x81, 0x08, 0x81, 0x18,
  0x83, 0x10, 0xC6, 0x20, 0x7C, 0x60, 0x10, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x0C, 0x02, 0x3F, 0x04, 0x61, 0x0C, 0x41, 0x08, 0xC1, 0x10, 0xC1,
  0x30, 0x81, 0x60, 0x81, 0x20, 0xC2, 0x00, 0x46, 0x00, 0x7C, 0x00, 0x20,
  0x00, 0xFC, 0x00, 0xC3, 0x00, 0x40, 0x80, 0x60, 0x40, 0x20, 0x20, 0x10,
  0x30, 0x08, 0x10, 0x06, 0x10, 0x03, 0x30, 0x00, 0xB0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x64, 0x00, 0x63, 0x02, 0x60, 0x81, 0x20, 0x61, 0xB0, 0x18,
  0x90, 0x04, 0xC8, 0x03, 0x44, 0x00, 0xE2, 0x00, 0x61, 0x80, 0x78, 0x60,
  0xE6, 0x1F, 0xC1, 0x00, 0x55, 0xEA, 0x00, 0x40, 0x30, 0x10, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x30, 0x08, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x04, 0x18, 0x7E, 0x23, 0xC7, 0xFC, 0x01,
  0xC0, 0x07, 0x80, 0x09, 0x80, 0x21, 0x00, 0x83, 0x07, 0x03, 0x04, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x13, 0x32, 0x26, 0xC8, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x01, 0xFC, 0x06, 0x06, 0x0C, 0x02, 0x08, 0x03, 0x18, 0x01, 0x10, 0x01,
  0x30, 0x03, 0x20, 0x07, 0x20, 0x09, 0x60, 0x31, 0x60, 0x63, 0x60, 0xC3,
  0x41, 0x83, 0x42, 0x02, 0x4C, 0x02, 0xD8, 0x06, 0xF0, 0x06, 0xE0, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0,
  0x01, 0x83, 0xCF, 0x7C, 0x38, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x00, 0x40, 0x03, 0xF8, 0x06, 0x0E, 0x0C, 0x06, 0x18,
  0x03, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x03, 0xFC, 0x06, 0x06, 0x0C,
  0x03, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x04, 0xC0,
  0x0C, 0x60, 0x18, 0x30, 0x70, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0A, 0x00, 0x16, 0x00, 0x36, 0x00, 0x66, 0x00, 0xC4, 0x00, 0x84, 0x01,
  0x04, 0x03, 0x0C, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x08, 0x10, 0x08, 0x20,
  0x08, 0x60, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x07, 0xFF, 0x86, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x1F, 0xF0, 0x0E, 0x0E, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x20, 0x02, 0x10,
  0x01, 0x0C, 0x01, 0x82, 0x01, 0x80, 0xC3, 0x80, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x21, 0xE0, 0xDE, 0xF1, 0xE0, 0x23, 0x80, 0x66, 0x00, 0x48, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x44,
  0x01, 0x8C, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x01,
  0xC1, 0x81, 0x80, 0x60, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x06, 0x20, 0x02,
  0x10, 0x01, 0x0C, 0x01, 0x82, 0x01, 0x81, 0xC3, 0x80, 0x3F, 0x00, 0x71,
  0xC0, 0x60, 0x30, 0x40, 0x0C, 0x60, 0x02, 0x60, 0x01, 0x30, 0x00, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x60, 0x60, 0x60, 0x1F, 0xE0,
  0x00, 0x00, 0x80, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63, 0x00, 0x44, 0x00,
  0xD8, 0x01, 0xA0, 0x03, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x34,
  0x00, 0xCC, 0x01, 0x98, 0x0D, 0x1C, 0x76, 0x1F, 0x88, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x7C, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x30, 0x30, 0x60, 0xC0,
  0x40, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x20, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x7F, 0x0E, 0x0C, 0x40, 0x26, 0x01, 0xA0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x30, 0x18, 0x03, 0x06,
  0x00, 0x20, 0x80, 0x04, 0x20, 0xF8, 0xCC, 0x21, 0x09, 0x08, 0x21, 0x63,
  0x04, 0x28, 0x41, 0x0D, 0x18, 0x21, 0x62, 0x04, 0x28, 0x41, 0x85, 0x08,
  0x20, 0xA3, 0x04, 0x34, 0x61, 0x84, 0x8C, 0x51, 0x90, 0x9A, 0x22, 0x1E,
  0x78, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x7F,
  0x00, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x02, 0x40,
  0x03, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x41,
  0x80, 0x60, 0x40, 0x20, 0x20, 0x30, 0x10, 0x10, 0x08, 0x18, 0x06, 0x0F,
  0xFF, 0x0C, 0x01, 0x84, 0x00, 0x46, 0x00, 0x22, 0x00, 0x13, 0x00, 0x09,
  0x00, 0x07, 0x80, 0x03, 0x0F, 0xF8, 0x18, 0x0E, 0x18, 0x02, 0x18, 0x03,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x03, 0x30, 0x02, 0x30, 0x04,
  0x20, 0x18, 0x3F, 0xF0, 0x20, 0x38, 0x60, 0x04, 0x60, 0x06, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x80, 0x18,
  0x80, 0xF0, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFE, 0x01, 0xC1, 0x81, 0x80,
  0x61, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00,
  0xC2, 0x00, 0x41, 0x80, 0x60, 0x60, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x03, 0x03, 0x80, 0x80, 0x30, 0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x21,
  0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0xC0,
  0x02, 0x30, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01,
  0x18, 0x00, 0xC6, 0x00, 0x21, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x0E, 0x04,
  0x1E, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x84, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x07, 0xFF, 0x82, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC2, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0xFE, 0x01, 0xC1, 0x81, 0x80, 0x61, 0x80, 0x10,
  0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0xFD, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x98, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x21,
  0x80, 0x30, 0x70, 0x70, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x61, 0x00, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x20,
  0x80, 0x04, 0x10, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x06, 0x1F, 0xFF, 0xC2,
  0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x08,
  0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x30,
  0x01, 0x84, 0x00, 0x20, 0x0F, 0xFF, 0x88, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x43, 0x00, 0x30, 0x40, 0x08, 0x18, 0x06, 0x03, 0x07, 0x00, 0x7F,
  0x00, 0x08, 0x00, 0xE1, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x30, 0x04, 0x0C, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x30,
  0x00, 0x8C, 0x00, 0x13, 0x80, 0x02, 0xD8, 0x00, 0x71, 0x00, 0x18, 0x30,
  0x03, 0x02, 0x00, 0x40, 0x60, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x0C,
  0x0C, 0x00, 0x81, 0x80, 0x18, 0x20, 0x01, 0x04, 0x00, 0x30, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x38, 0x07, 0x05,
  0x00, 0xA1, 0xA0, 0x34, 0x34, 0x05, 0x86, 0x81, 0xB0, 0x98, 0x24, 0x13,
  0x08, 0x82, 0x23, 0x10, 0xC4, 0x42, 0x18, 0x98, 0xC3, 0x1A, 0x18, 0x43,
  0xC2, 0x08, 0x30, 0x41, 0x06, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x00,
  0x0C, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00,
  0x30, 0x0C, 0x00, 0x61, 0x80, 0x08, 0x38, 0x01, 0x05, 0x00, 0x61, 0xA0,
  0x0C, 0x36, 0x01, 0x84, 0x40, 0x20, 0x88, 0x04, 0x11, 0x80, 0x82, 0x10,
  0x30, 0xC2, 0x06, 0x18, 0x60, 0xC2, 0x04, 0x10, 0x40, 0xC2, 0x08, 0x08,
  0x41, 0x01, 0x18, 0x60, 0x33, 0x0C, 0x02, 0x61, 0x00, 0x48, 0x20, 0x0D,
  0x04, 0x00, 0xA1, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x20, 0x00, 0x20,
  0x01, 0xFE, 0x01, 0xC1, 0x81, 0x80, 0x41, 0x80, 0x30, 0x80, 0x08, 0xC0,
  0x04, 0x40, 0x02, 0x60, 0x01, 0x30, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x16, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x02, 0x40, 0x01,
  0x30, 0x01, 0x98, 0x00, 0x84, 0x00, 0xC2, 0x00, 0xC1, 0x80, 0xC0, 0x60,
  0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x02, 0x01, 0xC0, 0x80, 0x18, 0x20,
  0x06, 0x18, 0x00, 0x86, 0x00, 0x31, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x20, 0x3C, 0x0F, 0xFC, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x01, 0xFE, 0x01, 0xC1, 0x81, 0x80, 0x61, 0x80, 0x10, 0x80, 0x08, 0xC0,
  0x06, 0x40, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0xCC, 0x00, 0xC2, 0x00, 0x41, 0x80, 0x40, 0x60,
  0xC0, 0x1F, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x0F, 0xF8, 0x04, 0x07, 0x06, 0x00, 0xC3, 0x00, 0x21, 0x80, 0x10, 0x80,
  0x0C, 0x40, 0x06, 0x20, 0x02, 0x30, 0x01, 0x18, 0x01, 0x88, 0x01, 0x84,
  0x01, 0x83, 0xFF, 0x81, 0xFF, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x30,
  0x20, 0x08, 0x10, 0x04, 0x08, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x62, 0x00,
  0x31, 0x00, 0x08, 0x00, 0x20, 0x01, 0xFE, 0x01, 0x81, 0x81, 0x80, 0x61,
  0x80, 0x10, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x20, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x66,
  0x00, 0x21, 0x80, 0x30, 0x60, 0x70, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x30, 0x01, 0x8C,
  0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00,
  0x31, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x43, 0x00, 0x30, 0x40, 0x18, 0x18,
  0x0C, 0x03, 0x06, 0x00, 0x7F, 0x00, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x06, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x18, 0x60, 0x10,
  0x60, 0x30, 0x60, 0x20, 0x20, 0x60, 0x20, 0x40, 0x20, 0xC0, 0x20, 0x80,
  0x30, 0x80, 0x31, 0x80, 0x11, 0x00, 0x13, 0x00, 0x12, 0x00, 0x16, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x40, 0x40, 0x50, 0x30, 0x34, 0x0C,
  0x09, 0x03, 0x02, 0x41, 0x41, 0x90, 0x50, 0x44, 0x34, 0x11, 0x09, 0x04,
  0x42, 0x43, 0x11, 0x90, 0x84, 0x44, 0x21, 0x11, 0x18, 0x4C, 0x44, 0x12,
  0x11, 0x04, 0x86, 0xC1, 0x61, 0xA0, 0x50, 0x68, 0x14, 0x1A, 0x07, 0x07,
  0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x60, 0x06, 0x02, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x10, 0x30, 0x01, 0x82, 0x00, 0x08, 0x60, 0x00, 0xCC, 0x00, 0x05,
  0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x00, 0x00,
  0x98, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x04, 0x00,
  0x80, 0x60, 0x18, 0x02, 0x03, 0x00, 0x30, 0x60, 0x01, 0x0C, 0x00, 0x18,
  0xC0, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x60, 0x08, 0x20, 0x18,
  0x30, 0x30, 0x30, 0x20, 0x10, 0x60, 0x10, 0xC0, 0x18, 0x80, 0x09, 0x80,
  0x0B, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x23, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x10, 0xF8, 0x00,
  0x83, 0x0C, 0x10, 0x41, 0x06, 0x18, 0x20, 0x82, 0x0C, 0x30, 0x41, 0x04,
  0x18, 0x60, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x07, 0xC1, 0xF0, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0xF8, 0x00, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x2C, 0x06, 0x40, 0xC4, 0x08,
  0x41, 0x86, 0x10, 0x23, 0x02, 0x20, 0x26, 0x03, 0xC0, 0x30, 0xFF, 0xFC,
  0xC4, 0x63, 0x03, 0xF8, 0x1C, 0x18, 0x60, 0x19, 0x80, 0x32, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x0F, 0xFC, 0x70, 0x09, 0x80, 0x16, 0x00,
  0x2C, 0x00, 0xD0, 0x01, 0xA0, 0x06, 0x60, 0x1C, 0x60, 0xC8, 0x7F, 0x10,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x13, 0xF0, 0x2C, 0x38, 0xE0, 0x11, 0x80, 0x33, 0x00,
  0x64, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0, 0x0D, 0x00, 0x1A,
  0x00, 0x24, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x70, 0x18, 0xB0, 0x61, 0x1F,
  0x80, 0x03, 0xF8, 0x1C, 0x18, 0x60, 0x18, 0x80, 0x33, 0x00, 0x24, 0x00,
  0x58, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x68, 0x01, 0x90, 0x02, 0x30, 0x0C, 0x30, 0x70, 0x3F, 0x80, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x03, 0xF3, 0x07, 0x0D, 0x86, 0x03, 0x82, 0x00,
  0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x08, 0x40, 0x04, 0x60,
  0x02, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x60,
  0xC0, 0x70, 0x30, 0x68, 0x0F, 0xCC, 0x00, 0x03, 0xF8, 0x06, 0x0C, 0x18,
  0x04, 0x10, 0x06, 0x30, 0x02, 0x60, 0x02, 0x40, 0x02, 0x7F, 0xFE, 0xFF,
  0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x0C, 0x38, 0x30, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x78, 0x80,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0xFF, 0xFC, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xF9, 0x83, 0x86, 0xC3, 0x01, 0xC1, 0x00, 0x61,
  0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x20, 0x02, 0x30, 0x01,
  0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x20, 0x80, 0x30, 0x60,
  0x38, 0x18, 0x34, 0x07, 0xE6, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x82,
  0x00, 0x83, 0x00, 0xC0, 0xE1, 0xC0, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x11, 0xF8, 0x6E, 0x18, 0xF0, 0x19, 0x40, 0x13, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xB0, 0x03, 0x60, 0x06, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x2C, 0x00,
  0x58, 0x01, 0xB0, 0x03, 0x40, 0x04, 0x80, 0x09, 0x00, 0x10, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x3F, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x88, 0x03, 0x04, 0x06, 0x02, 0x06, 0x03, 0x06, 0x01, 0x86, 0x00,
  0xCC, 0x00, 0x4C, 0x00, 0x2E, 0x00, 0x1D, 0x80, 0x18, 0x60, 0x0C, 0x18,
  0x04, 0x0C, 0x02, 0x03, 0x01, 0x00, 0xC0, 0x80, 0x60, 0xC0, 0x18, 0x60,
  0x06, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0,
  0x17, 0xC7, 0xC3, 0x8D, 0x8C, 0xE0, 0xC0, 0x98, 0x18, 0x12, 0x02, 0x02,
  0x40, 0x40, 0xC8, 0x18, 0x19, 0x03, 0x03, 0x60, 0x40, 0x4C, 0x08, 0x09,
  0x01, 0x01, 0x20, 0x20, 0x64, 0x0C, 0x0D, 0x81, 0x81, 0x30, 0x20, 0x24,
  0x04, 0x04, 0x80, 0x80, 0x90, 0x30, 0x30, 0x11, 0xF8, 0x6E, 0x18, 0xF0,
  0x19, 0x40, 0x33, 0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x03, 0x60, 0x06,
  0x80, 0x09, 0x00, 0x12, 0x00, 0x2C, 0x00, 0x58, 0x01, 0xB0, 0x03, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x10, 0x03, 0xF0, 0x0E, 0x1C, 0x18, 0x04, 0x30,
  0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x0C, 0x40, 0x08, 0x60,
  0x30, 0x30, 0x60, 0x1F, 0xC0, 0x04, 0xFC, 0x06, 0xC3, 0x83, 0x80, 0xC1,
  0x80, 0x30, 0xC0, 0x18, 0x40, 0x04, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00,
  0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x21, 0x00, 0x31, 0x80, 0x10, 0xC0,
  0x18, 0x70, 0x18, 0x2C, 0x18, 0x13, 0xF8, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF3, 0x0E, 0x1B, 0x18, 0x0E, 0x10, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60,
  0x06, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x0C, 0x40, 0x08, 0x40, 0x18, 0x60, 0x38, 0x30, 0x68, 0x1F, 0x98, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x18, 0xFE, 0x37, 0x00, 0x58, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x00, 0x03,
  0xF8, 0x0E, 0x0C, 0x18, 0x06, 0x10, 0x02, 0x30, 0x03, 0x30, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0xC0, 0x04, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x38, 0x1F, 0xE0, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x7F, 0xFC, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0x80, 0x20, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x01, 0x90, 0x03, 0x20, 0x0C, 0x60, 0x38, 0x61, 0xD0, 0x7E, 0x60, 0xC0,
  0x03, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x60, 0x08, 0x20,
  0x18, 0x20, 0x30, 0x30, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0xC0, 0x18,
  0x80, 0x09, 0x80, 0x0B, 0x00, 0x0A, 0x00, 0x0E, 0x00, 0x04, 0x00, 0xC0,
  0x40, 0x50, 0x30, 0x34, 0x0C, 0x09, 0x07, 0x02, 0x41, 0x41, 0x90, 0x50,
  0x44, 0x24, 0x31, 0x09, 0x08, 0x46, 0x62, 0x11, 0x19, 0x84, 0xC6, 0x41,
  0x20, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x18, 0x00, 0xC2, 0x00, 0x60, 0xC0, 0x30, 0x18,
  0x18, 0x02, 0x0C, 0x00, 0xC6, 0x00, 0x13, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x16, 0x00, 0x08, 0x80, 0x06, 0x30, 0x03, 0x06, 0x01,
  0x80, 0x80, 0xC0, 0x30, 0x60, 0x04, 0x30, 0x01, 0x80, 0x08, 0x00, 0x18,
  0x60, 0x01, 0x83, 0x00, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x40, 0x20, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00,
  0x41, 0x80, 0x02, 0x18, 0x00, 0x18, 0x80, 0x00, 0xCC, 0x00, 0x02, 0xC0,
  0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x70, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x80,
  0x08, 0x00, 0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x10,
  0xC2, 0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x78, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x9C, 0xC0,
  0x14, 0x18, 0x0F, 0x01, 0x86, 0x80, 0x3F, 0x00, 0x07, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 24, 20, 7, -24 },
  { 19, 7, 8, 20, 8, -26 },
  { 26, 20, 24, 20, 0, -24 },
  { 86, 17, 31, 20, 2, -28 },
  { 152, 16, 25, 20, 2, -25 },
  { 202, 17, 25, 20, 1, -25 },
  { 256, 2, 8, 20, 10, -26 },
  { 258, 10, 35, 20, 6, -27 },
  { 302, 10, 35, 20, 3, -27 },
  { 346, 15, 14, 20, 4, -24 },
  { 373, 16, 18, 20, 2, -20 },
  { 409, 4, 8, 20, 4, -3 },
  { 413, 12, 2, 20, 4, -12 },
  { 416, 2, 3, 20, 8, -3 },
  { 417, 15, 26, 20, 3, -24 },
  { 466, 16, 25, 20, 2, -25 },
  { 516, 9, 24, 20, 5, -24 },
  { 543, 16, 25, 20, 1, -25 },
  { 593, 16, 25, 20, 1, -25 },
  { 643, 16, 24, 20, 1, -24 },
  { 691, 17, 24, 20, 3, -24 },
  { 742, 15, 24, 20, 2, -24 },
  { 787, 16, 24, 20, 4, -24 },
  { 835, 17, 25, 20, 2, -25 },
  { 889, 15, 25, 20, 3, -25 },
  { 936, 6, 18, 20, 8, -18 },
  { 950, 8, 23, 20, 6, -18 },
  { 973, 15, 14, 20, 3, -18 },
  { 1000, 16, 8, 20, 2, -15 },
  { 1016, 15, 14, 20, 2, -18 },
  { 1043, 13, 25, 20, 5, -25 },
  { 1084, 19, 24, 20, 1, -24 },
  { 1141, 17, 24, 20, 0, -24 },
  { 1192, 16, 24, 20, 2, -24 },
  { 1240, 17, 25, 20, 2, -25 },
  { 1294, 18, 24, 20, 1, -24 },
  { 1348, 17, 24, 20, 2, -24 },
  { 1399, 18, 24, 20, 2, -24 },
  { 1453, 17, 25, 20, 2, -25 },
  { 1507, 19, 24, 20, 1, -24 },
  { 1564, 17, 24, 20, 2, -24 },
  { 1615, 18, 24, 20, 1, -24 },
  { 1669, 19, 24, 20, 2, -24 },
  { 1726, 14, 24, 20, 2, -24 },
  { 1768, 19, 24, 20, 1, -24 },
  { 1825, 19, 24, 20, 1, -24 },
  { 1882, 17, 25, 20, 2, -25 },
  { 1936, 18, 24, 20, 2, -24 },
  { 1990, 17, 29, 20, 2, -25 },
  { 2052, 17, 24, 20, 2, -24 },
  { 2103, 17, 25, 20, 2, -25 },
  { 2157, 17, 24, 20, 4, -24 },
  { 2208, 18, 24, 20, 2, -24 },
  { 2262, 16, 24, 20, 4, -24 },
  { 2310, 18, 24, 20, 3, -24 },
  { 2364, 20, 24, 20, 0, -24 },
  { 2424, 16, 24, 20, 4, -24 },
  { 2472, 18, 24, 20, 1, -24 },
  { 2526, 10, 33, 20, 5, -28 },
  { 2568, 6, 26, 20, 7, -24 },
  { 2588, 10, 33, 20, 5, -28 },
  { 2630, 12, 13, 20, 4, -24 },
  { 2650, 14, 1, 20, 1, 0 },
  { 2652, 4, 4, 20, 10, -25 },
  { 2654, 15, 18, 20, 2, -18 },
  { 2688, 15, 26, 20, 2, -26 },
  { 2737, 15, 18, 20, 2, -18 },
  { 2771, 17, 26, 20, 2, -26 },
  { 2827, 16, 18, 20, 2, -18 },
  { 2863, 17, 26, 20, 4, -26 },
  { 2919, 17, 25, 20, 1, -18 },
  { 2973, 15, 26, 20, 2, -26 },
  { 3022, 14, 24, 20, 2, -24 },
  { 3064, 16, 31, 20, 0, -24 },
  { 3126, 17, 26, 20, 2, -26 },
  { 3182, 14, 26, 20, 2, -26 },
  { 3228, 19, 18, 20, 0, -18 },
  { 3271, 15, 18, 20, 2, -18 },
  { 3305, 16, 18, 20, 2, -18 },
  { 3341, 17, 25, 20, 0, -18 },
  { 3395, 16, 25, 20, 2, -18 },
  { 3445, 15, 18, 20, 4, -18 },
  { 3479, 16, 18, 20, 2, -18 },
  { 3515, 13, 23, 20, 4, -23 },
  { 3553, 15, 18, 20, 3, -18 },
  { 3587, 16, 18, 20, 3, -18 },
  { 3623, 18, 18, 20, 2, -18 },
  { 3664, 18, 18, 20, 1, -18 },
  { 3705, 21, 25, 20, -1, -18 },
  { 3771, 17, 18, 20, 1, -18 },
  { 3810, 13, 34, 20, 5, -27 },
  { 3866, 6, 29, 20, 7, -24 },
  { 3888, 13, 34, 20, 3, -27 },
  { 3944, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC34PT7B_H_
