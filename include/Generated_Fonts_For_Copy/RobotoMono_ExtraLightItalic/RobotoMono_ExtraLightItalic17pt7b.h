#ifndef _ROBOTOMONO_EXTRALIGHTITALIC17PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x40, 0x60, 0x99, 0xAA, 0x04, 0x81, 0x20, 0x88,
  0xFF, 0x09, 0x04, 0x41, 0x20, 0x48, 0xFF, 0x89, 0x04, 0x41, 0x20, 0x04,
  0x04, 0x1A, 0x21, 0x41, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x82, 0x82,
  0x6C, 0x10, 0x10, 0x70, 0x91, 0x92, 0x94, 0xE4, 0x08, 0x12, 0x15, 0x29,
  0x49, 0x89, 0x0E, 0x1C, 0x22, 0x22, 0x24, 0x28, 0x30, 0x50, 0x89, 0x85,
  0x86, 0x86, 0x7B, 0xF0, 0x08, 0x44, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x41, 0x00, 0x21, 0x04, 0x20, 0x84, 0x21, 0x08, 0x44, 0x21,
  0x10, 0x88, 0x84, 0x00, 0x08, 0x13, 0x49, 0xE2, 0x85, 0x11, 0x00, 0x08,
  0x08, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x58, 0xFC, 0x80, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x1E, 0x21, 0x41, 0x41, 0x47, 0x89, 0x91, 0xA1, 0xC2, 0x82, 0x84, 0x78,
  0x3D, 0x11, 0x22, 0x22, 0x22, 0x44, 0x1F, 0x21, 0x21, 0x41, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x1F, 0x10, 0x48, 0x20, 0x10, 0x10,
  0xF0, 0x08, 0x02, 0x01, 0x40, 0x90, 0x87, 0x80, 0x01, 0x01, 0x81, 0x41,
  0x20, 0x90, 0x90, 0x88, 0x84, 0xFF, 0x81, 0x00, 0x80, 0x80, 0x1F, 0x90,
  0x08, 0x04, 0x03, 0xC3, 0x10, 0x04, 0x02, 0x01, 0x41, 0x10, 0x87, 0x80,
  0x0E, 0x20, 0x82, 0x07, 0xC8, 0x60, 0xC1, 0x83, 0x06, 0x13, 0xC0, 0xFF,
  0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x1E,
  0x21, 0x41, 0x41, 0x21, 0x1E, 0x22, 0x41, 0x81, 0x81, 0x82, 0x7C, 0x3C,
  0x86, 0x0C, 0x18, 0x30, 0x61, 0xBE, 0x04, 0x10, 0x47, 0x00, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x04, 0x48, 0x01, 0x0E, 0x30, 0xC0, 0x70, 0x0C,
  0x02, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x40, 0x30, 0x0C, 0x03, 0x0C, 0x70,
  0x80, 0x7A, 0x18, 0x41, 0x08, 0x42, 0x10, 0x40, 0x00, 0x30, 0x0F, 0x84,
  0x12, 0x65, 0x25, 0x52, 0x54, 0x99, 0x26, 0x8A, 0x94, 0xA6, 0x44, 0x00,
  0xF8, 0x02, 0x06, 0x06, 0x0A, 0x0A, 0x11, 0x11, 0x21, 0x3F, 0x41, 0x41,
  0x81, 0x3E, 0x41, 0x41, 0x41, 0x43, 0x7C, 0x42, 0x81, 0x81, 0x82, 0x82,
  0xFC, 0x1E, 0x21, 0x41, 0x41, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x82,
  0x7C, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x84,
  0xF8, 0x3F, 0xA0, 0x10, 0x08, 0x04, 0x03, 0xF1, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x1F, 0xC0, 0x3F, 0x90, 0x10, 0x08, 0x04, 0x03, 0xF1, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x21, 0x41, 0x40, 0x80, 0x80, 0x8F,
  0x81, 0x81, 0x82, 0x82, 0x7C, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x8F,
  0xE4, 0x09, 0x02, 0x41, 0x10, 0x44, 0x12, 0x04, 0x3F, 0x84, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x1F, 0xC0, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x82, 0x84, 0x78, 0x20, 0x90,
  0x90, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x90, 0x84, 0x42, 0x20, 0x90, 0x60,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x07, 0xF0, 0x20,
  0xB0, 0xD8, 0xAC, 0x65, 0x52, 0xAA, 0x65, 0x22, 0x81, 0x41, 0x20, 0x90,
  0x40, 0x40, 0xB0, 0x58, 0x4A, 0x25, 0x14, 0x8A, 0x25, 0x12, 0x86, 0x43,
  0x21, 0x90, 0x40, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x84, 0x78, 0x3F, 0x10, 0x90, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x84, 0x78, 0x04, 0x02, 0x3E, 0x21, 0x41, 0x41, 0x41,
  0x42, 0x7C, 0x84, 0x84, 0x84, 0x82, 0x82, 0x1E, 0x21, 0x41, 0x40, 0x20,
  0x18, 0x04, 0x02, 0x01, 0x81, 0x82, 0x7C, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0xA0, 0x50, 0x48, 0x24,
  0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x0F, 0x00, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20, 0x20, 0x88, 0xCC, 0xA6,
  0x55, 0x2A, 0xA5, 0x53, 0x29, 0x98, 0xCC, 0x46, 0x22, 0x11, 0x00, 0x20,
  0x44, 0x21, 0x10, 0x24, 0x0A, 0x01, 0x00, 0xC0, 0x48, 0x12, 0x08, 0x84,
  0x12, 0x04, 0x81, 0x82, 0x42, 0x44, 0x48, 0x28, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x1F, 0xE0, 0x39, 0x08, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x10, 0xC0, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x10, 0x1C, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0xE0, 0x08,
  0x62, 0x8A, 0x45, 0x18, 0x40, 0xFF, 0xA4, 0x3E, 0x42, 0x01, 0x02, 0x7E,
  0x82, 0x82, 0x86, 0x7A, 0x20, 0x20, 0x40, 0x40, 0x5E, 0x62, 0x41, 0x41,
  0x81, 0x82, 0x82, 0x84, 0xF8, 0x3E, 0x42, 0x41, 0x80, 0x80, 0x80, 0x82,
  0x82, 0x7C, 0x00, 0x80, 0x80, 0x40, 0x23, 0xD2, 0x19, 0x05, 0x04, 0x82,
  0x41, 0x20, 0x90, 0xC7, 0xA0, 0x1E, 0x62, 0x41, 0x81, 0xFE, 0x80, 0x80,
  0x42, 0x7C, 0x0F, 0x10, 0x10, 0x10, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x3D, 0x43, 0x41, 0x82, 0x82, 0x82, 0x82, 0x86, 0x7A,
  0x04, 0x04, 0x88, 0x70, 0x20, 0x20, 0x40, 0x40, 0x5E, 0x61, 0x41, 0x41,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x04, 0x00, 0x03, 0xC0, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x47, 0xF0, 0x03, 0x00, 0x00, 0x1E, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x10, 0xE0, 0x20, 0x20, 0x20, 0x20,
  0x41, 0x46, 0x48, 0x50, 0x70, 0x48, 0x88, 0x84, 0x82, 0x3C, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x8F, 0xE0, 0x7B, 0x91, 0x14,
  0x45, 0x12, 0x88, 0xA2, 0x28, 0x8A, 0x22, 0x88, 0x80, 0x5E, 0x61, 0x41,
  0x41, 0x82, 0x82, 0x82, 0x82, 0x82, 0x3E, 0x42, 0x41, 0x81, 0x81, 0x81,
  0x82, 0x84, 0x78, 0x2F, 0x18, 0x88, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x84,
  0x7C, 0x20, 0x20, 0x10, 0x00, 0x3D, 0x43, 0x41, 0x82, 0x82, 0x82, 0x82,
  0x86, 0x7A, 0x04, 0x04, 0x04, 0x5E, 0xC1, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x80, 0x3E, 0x41, 0x40, 0x20, 0x1C, 0x02, 0x02, 0x82, 0x7C, 0x10, 0x23,
  0xF9, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0xE0, 0x41, 0x41, 0x41, 0x41,
  0x82, 0x82, 0x82, 0x86, 0x7A, 0x83, 0x82, 0x84, 0x84, 0x48, 0x48, 0x50,
  0x60, 0x20, 0x88, 0xC4, 0x66, 0x53, 0x2A, 0x95, 0x32, 0x98, 0x88, 0x44,
  0x00, 0x20, 0x88, 0x84, 0x81, 0x80, 0x80, 0xA0, 0x48, 0x44, 0xC1, 0x00,
  0x40, 0x48, 0x22, 0x08, 0x84, 0x22, 0x04, 0x81, 0x40, 0x60, 0x08, 0x04,
  0x01, 0x00, 0x80, 0xC0, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x00, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x10, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x08, 0x10, 0x24, 0x92, 0x4A, 0x49, 0x25, 0x20, 0x10,
  0x10, 0x10, 0x20, 0x81, 0x02, 0x02, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08,
  0x30, 0x80, 0x78, 0x61, 0xE0,
};

const GFXglyph RobotoMono_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 4, 4, 10, 4, -13 },
  { 8, 10, 12, 10, 0, -12 },
  { 23, 8, 16, 10, 1, -14 },
  { 39, 8, 12, 10, 1, -12 },
  { 51, 8, 12, 10, 1, -12 },
  { 63, 1, 4, 10, 5, -13 },
  { 64, 5, 18, 10, 3, -14 },
  { 76, 5, 18, 10, 2, -14 },
  { 88, 7, 7, 10, 2, -12 },
  { 95, 8, 9, 10, 1, -10 },
  { 104, 2, 3, 10, 2, -1 },
  { 105, 6, 1, 10, 2, -6 },
  { 106, 1, 1, 10, 4, -1 },
  { 107, 8, 13, 10, 1, -12 },
  { 120, 8, 12, 10, 1, -12 },
  { 132, 4, 12, 10, 3, -12 },
  { 138, 8, 12, 10, 0, -12 },
  { 150, 9, 12, 10, 0, -12 },
  { 164, 9, 12, 10, 0, -12 },
  { 178, 9, 12, 10, 1, -12 },
  { 192, 7, 12, 10, 1, -12 },
  { 203, 8, 12, 10, 2, -12 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 7, 12, 10, 2, -12 },
  { 238, 3, 8, 10, 4, -8 },
  { 241, 4, 10, 10, 3, -8 },
  { 246, 8, 7, 10, 1, -9 },
  { 253, 8, 5, 10, 1, -8 },
  { 258, 8, 7, 10, 1, -9 },
  { 265, 6, 12, 10, 3, -12 },
  { 274, 10, 12, 10, 0, -12 },
  { 289, 8, 12, 10, 0, -12 },
  { 301, 8, 12, 10, 1, -12 },
  { 313, 8, 12, 10, 1, -12 },
  { 325, 8, 12, 10, 1, -12 },
  { 337, 9, 12, 10, 1, -12 },
  { 351, 9, 12, 10, 1, -12 },
  { 365, 8, 12, 10, 1, -12 },
  { 377, 10, 12, 10, 0, -12 },
  { 392, 9, 12, 10, 1, -12 },
  { 406, 8, 12, 10, 1, -12 },
  { 418, 9, 12, 10, 1, -12 },
  { 432, 7, 12, 10, 1, -12 },
  { 443, 9, 12, 10, 1, -12 },
  { 457, 9, 12, 10, 1, -12 },
  { 471, 8, 12, 10, 1, -12 },
  { 483, 9, 12, 10, 1, -12 },
  { 497, 8, 14, 10, 1, -12 },
  { 511, 8, 12, 10, 1, -12 },
  { 523, 8, 12, 10, 1, -12 },
  { 535, 8, 12, 10, 2, -12 },
  { 547, 9, 12, 10, 1, -12 },
  { 561, 8, 12, 10, 2, -12 },
  { 573, 9, 12, 10, 2, -12 },
  { 587, 10, 12, 10, 0, -12 },
  { 602, 8, 12, 10, 2, -12 },
  { 614, 9, 12, 10, 0, -12 },
  { 628, 5, 17, 10, 3, -14 },
  { 639, 4, 13, 10, 3, -12 },
  { 646, 6, 17, 10, 2, -14 },
  { 659, 6, 7, 10, 2, -12 },
  { 665, 8, 1, 10, 0, 0 },
  { 666, 2, 3, 10, 5, -13 },
  { 667, 8, 9, 10, 1, -9 },
  { 676, 8, 13, 10, 1, -13 },
  { 689, 8, 9, 10, 1, -9 },
  { 698, 9, 13, 10, 1, -13 },
  { 713, 8, 9, 10, 1, -9 },
  { 722, 8, 13, 10, 2, -13 },
  { 735, 8, 13, 10, 1, -9 },
  { 748, 8, 13, 10, 1, -13 },
  { 761, 7, 12, 10, 1, -12 },
  { 772, 8, 16, 10, 0, -12 },
  { 788, 8, 13, 10, 1, -13 },
  { 801, 7, 13, 10, 1, -13 },
  { 813, 10, 9, 10, 0, -9 },
  { 825, 8, 9, 10, 1, -9 },
  { 834, 8, 9, 10, 1, -9 },
  { 843, 9, 12, 10, 0, -9 },
  { 857, 8, 12, 10, 1, -9 },
  { 869, 7, 9, 10, 2, -9 },
  { 877, 8, 9, 10, 1, -9 },
  { 886, 7, 11, 10, 2, -11 },
  { 896, 8, 9, 10, 1, -9 },
  { 905, 8, 9, 10, 2, -9 },
  { 914, 9, 9, 10, 1, -9 },
  { 925, 9, 9, 10, 0, -9 },
  { 936, 10, 13, 10, 0, -9 },
  { 953, 9, 9, 10, 0, -9 },
  { 964, 6, 17, 10, 3, -13 },
  { 977, 3, 15, 10, 3, -12 },
  { 983, 7, 17, 10, 1, -13 },
  { 998, 10, 2, 10, 0, -6 },
};

const GFXfont RobotoMono_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC17PT7B_H_
