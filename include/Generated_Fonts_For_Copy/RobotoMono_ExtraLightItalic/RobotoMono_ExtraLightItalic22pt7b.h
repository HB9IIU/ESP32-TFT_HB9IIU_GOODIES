#ifndef _ROBOTOMONO_EXTRALIGHTITALIC22PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x00, 0x0C, 0x4A, 0x53, 0x29,
  0x00, 0x01, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x42, 0x1F, 0xFC, 0x11,
  0x01, 0x08, 0x08, 0x80, 0x44, 0x04, 0x21, 0xFF, 0xC1, 0x10, 0x10, 0x80,
  0x88, 0x0C, 0x40, 0x01, 0x00, 0x20, 0x1E, 0x04, 0x21, 0x02, 0x40, 0x48,
  0x09, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x90, 0x12,
  0x04, 0x41, 0x87, 0xE0, 0x20, 0x04, 0x00, 0x38, 0x08, 0x81, 0x11, 0x42,
  0x48, 0x49, 0x12, 0x1C, 0x80, 0x10, 0x04, 0x01, 0x38, 0x28, 0x89, 0x12,
  0x22, 0x88, 0x40, 0x90, 0x1C, 0x07, 0x01, 0x10, 0x42, 0x08, 0x41, 0x10,
  0x26, 0x05, 0x00, 0x40, 0x34, 0x0C, 0x85, 0x08, 0xC1, 0x28, 0x15, 0x01,
  0x10, 0x61, 0xF2, 0x55, 0x80, 0x06, 0x10, 0x41, 0x02, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x04,
  0x00, 0x18, 0x10, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x20, 0x41, 0x04, 0x10, 0x00, 0x04, 0x02, 0x02,
  0x11, 0x17, 0xF0, 0x40, 0x50, 0x48, 0xC2, 0x00, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00,
  0x56, 0x80, 0xFF, 0xB0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x00, 0x0F, 0x04, 0x22, 0x09, 0x01, 0x40, 0x60, 0x78, 0x26, 0x11,
  0x88, 0xA4, 0x2E, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x21, 0xF0, 0x04, 0x76,
  0x61, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x07, 0x81,
  0x08, 0x40, 0x90, 0x12, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFE, 0x0F, 0x04, 0x22, 0x05,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x0C, 0x1F, 0x00, 0x20, 0x08, 0x02, 0x80,
  0xA0, 0x28, 0x11, 0xF8, 0x00, 0x40, 0x20, 0x18, 0x0A, 0x04, 0x82, 0x20,
  0x88, 0x44, 0x21, 0x10, 0x48, 0x13, 0xFF, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x1F, 0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x17, 0x83, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x48, 0x09, 0x02, 0x10, 0xC3, 0xE0, 0x01, 0x81,
  0x80, 0x80, 0x40, 0x20, 0x08, 0x05, 0xF1, 0x82, 0x40, 0x50, 0x18, 0x06,
  0x01, 0x80, 0x90, 0x24, 0x10, 0xF8, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x07, 0x81, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x44, 0x10,
  0xFC, 0x19, 0x84, 0x09, 0x01, 0x40, 0x28, 0x05, 0x01, 0x90, 0x61, 0xF8,
  0x0E, 0x0C, 0x66, 0x09, 0x02, 0x80, 0x60, 0x18, 0x06, 0x02, 0x41, 0x90,
  0xA3, 0xC8, 0x04, 0x01, 0x00, 0x80, 0xC1, 0xC0, 0x13, 0x00, 0x00, 0x00,
  0x04, 0xC0, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x08, 0x84, 0x40, 0x00,
  0x40, 0x60, 0x60, 0xE0, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x70, 0x60, 0xE0, 0xC0, 0x00, 0x1E, 0x10, 0x90, 0x58,
  0x10, 0x10, 0x08, 0x08, 0x0C, 0x08, 0x08, 0x04, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x03, 0x80, 0xC6, 0x10, 0x22, 0x31, 0x44, 0x94, 0x89, 0x91,
  0x19, 0x11, 0x91, 0x2A, 0x12, 0xA2, 0x2A, 0x64, 0x99, 0x88, 0x00, 0x40,
  0x03, 0xF0, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10,
  0x42, 0x08, 0x42, 0x08, 0x41, 0x17, 0xE2, 0x04, 0x80, 0x50, 0x0C, 0x01,
  0x1F, 0x04, 0x18, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x13, 0xFC, 0x41,
  0x88, 0x09, 0x01, 0x20, 0x24, 0x05, 0x01, 0x20, 0x67, 0xF0, 0x07, 0x81,
  0x08, 0x40, 0x90, 0x12, 0x02, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x28, 0x04, 0x81, 0x10, 0x41, 0xF0, 0x1F, 0x04, 0x10, 0x81,
  0x10, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20,
  0x28, 0x09, 0x01, 0x20, 0xC7, 0xE0, 0x1F, 0xF1, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x07, 0xF8, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x7F, 0x84, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x07, 0x81, 0x08, 0x40, 0x90, 0x14,
  0x02, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x7A, 0x01, 0x40, 0x28, 0x04,
  0x80, 0x90, 0x21, 0xF8, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x27, 0xFC, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x48,
  0x08, 0x80, 0x88, 0x08, 0x1F, 0xE0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x07, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x48, 0x09, 0x02, 0x10, 0xC3, 0xE0,
  0x10, 0x11, 0x02, 0x20, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24, 0x02, 0x80,
  0x54, 0x06, 0x40, 0x42, 0x04, 0x10, 0x41, 0x04, 0x08, 0x80, 0x88, 0x04,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0xFF, 0x30, 0x33, 0x03, 0x30, 0x53, 0x06,
  0x30, 0xA4, 0x8A, 0x49, 0x24, 0x92, 0x4A, 0x44, 0x44, 0x44, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x20, 0x13, 0x02, 0x30, 0x23, 0x02,
  0x28, 0x24, 0x82, 0x44, 0x24, 0x44, 0x44, 0x44, 0x24, 0x42, 0x48, 0x24,
  0x81, 0x48, 0x18, 0x80, 0x88, 0x08, 0x07, 0x81, 0x08, 0x41, 0x10, 0x12,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x08,
  0x81, 0x10, 0x41, 0xF0, 0x1F, 0x81, 0x06, 0x10, 0x22, 0x01, 0x20, 0x12,
  0x02, 0x20, 0x22, 0x04, 0x21, 0x85, 0xE0, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x14, 0x02, 0x80,
  0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x04, 0x81, 0x10,
  0x41, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x1F, 0x02, 0x18, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x7F, 0x88, 0x41, 0x04, 0x20, 0x84,
  0x10, 0x81, 0x20, 0x24, 0x06, 0x07, 0x83, 0x08, 0xC0, 0x90, 0x12, 0x02,
  0x40, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x28, 0x05, 0x00,
  0x90, 0x21, 0xF8, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x24, 0x04, 0x40,
  0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x84, 0x08, 0x41, 0x03, 0xE0, 0x80,
  0x28, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x04,
  0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x06, 0x00, 0x80, 0x82, 0x18, 0x42,
  0x86, 0x28, 0xA2, 0x8A, 0x28, 0xA4, 0x92, 0x49, 0x24, 0x92, 0x8A, 0x28,
  0xA2, 0x8A, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x08, 0x20, 0x10, 0x08, 0x80,
  0x82, 0x04, 0x10, 0x40, 0x44, 0x02, 0x40, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x28, 0x02, 0x40, 0x11, 0x01, 0x08, 0x10, 0x21, 0x01, 0x18, 0x04, 0xC0,
  0x28, 0x09, 0x01, 0x20, 0x42, 0x10, 0x42, 0x08, 0x80, 0xA0, 0x14, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xF0, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFC, 0x0E, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x0F, 0x00, 0x82, 0x10, 0x84, 0x20, 0x84, 0x21, 0x08, 0x21,
  0x08, 0x42, 0x08, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x8F, 0x00, 0x08, 0x18,
  0x50, 0xA2, 0x44, 0x50, 0xC1, 0x82, 0xFF, 0x80, 0xC8, 0x80, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x00, 0x43, 0xF3, 0x05, 0x02, 0x80, 0xA0, 0x2C, 0x39,
  0xF2, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x09, 0xC3, 0x88, 0x81, 0x20,
  0x50, 0x14, 0x05, 0x01, 0x40, 0x50, 0x24, 0x0B, 0x04, 0xBE, 0x00, 0x1E,
  0x10, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x81, 0x40, 0xA0, 0x8F,
  0x80, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0xA2, 0x19, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x7D, 0x00, 0x07,
  0x06, 0x22, 0x05, 0x01, 0x40, 0x5F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x06,
  0x08, 0xFC, 0x03, 0xC1, 0x00, 0x80, 0x40, 0x10, 0x3F, 0xC1, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x00,
  0x0F, 0x22, 0x18, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x24, 0x04, 0x40,
  0x88, 0x11, 0x06, 0x1F, 0x40, 0x10, 0x02, 0x20, 0x82, 0x30, 0x38, 0x00,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE2, 0x8C, 0xC1, 0x60, 0x50,
  0x14, 0x05, 0x01, 0x40, 0x50, 0x28, 0x0A, 0x02, 0x80, 0x80, 0x01, 0x01,
  0x80, 0x00, 0x03, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x11, 0xFF, 0x00, 0x40, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x20, 0xF0, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0xC8, 0x31, 0x08, 0x22, 0x05, 0x81, 0x60, 0x36, 0x04,
  0x40, 0x84, 0x10, 0xC2, 0x08, 0x80, 0x80, 0x1F, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0xFF, 0x80, 0x2C, 0x63, 0x39, 0x63, 0x14, 0x21, 0x42, 0x14, 0x21,
  0x42, 0x14, 0x21, 0x84, 0x28, 0x42, 0x84, 0x28, 0x42, 0x27, 0x0A, 0x33,
  0x05, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x0A, 0x02,
  0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50,
  0x24, 0x10, 0xF8, 0x13, 0x83, 0x88, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x4C, 0x09, 0x82, 0x2F, 0x84, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x1E, 0x48, 0x64, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x31, 0xF4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x27, 0x94, 0x1C,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x0F,
  0x04, 0x32, 0x04, 0x81, 0x20, 0x06, 0x00, 0x70, 0x02, 0x00, 0x50, 0x24,
  0x08, 0xFC, 0x18, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x20, 0x3E, 0x40, 0x50, 0x24, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x31, 0xF4, 0x80, 0x60, 0x18, 0x09,
  0x02, 0x41, 0x10, 0x42, 0x20, 0x90, 0x24, 0x0A, 0x01, 0x80, 0x40, 0x84,
  0x30, 0x86, 0x31, 0x46, 0x29, 0x45, 0x29, 0x29, 0x25, 0x28, 0xA5, 0x18,
  0xA3, 0x08, 0x41, 0x00, 0x30, 0x11, 0x02, 0x08, 0x40, 0x88, 0x05, 0x00,
  0x30, 0x06, 0x00, 0x50, 0x09, 0x01, 0x08, 0x20, 0x4C, 0x06, 0x20, 0x09,
  0x00, 0x88, 0x0C, 0x20, 0x41, 0x04, 0x08, 0x20, 0x42, 0x01, 0x30, 0x09,
  0x00, 0x50, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x00, 0x1F, 0xF2, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0F, 0xFE, 0x01, 0x81, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x38, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x11, 0x11, 0x11,
  0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0xC0, 0x18, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0x06, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x80, 0x3C, 0x14, 0x21, 0x81, 0xE0,
};

const GFXglyph RobotoMono_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 16, 13, 4, -16 },
  { 9, 5, 5, 13, 5, -17 },
  { 13, 13, 16, 13, 0, -16 },
  { 39, 11, 20, 13, 1, -18 },
  { 67, 11, 16, 13, 1, -16 },
  { 89, 11, 16, 13, 1, -16 },
  { 111, 2, 5, 13, 6, -17 },
  { 113, 7, 22, 13, 4, -17 },
  { 133, 7, 22, 13, 2, -17 },
  { 153, 9, 9, 13, 3, -16 },
  { 164, 11, 11, 13, 1, -13 },
  { 180, 2, 5, 13, 3, -2 },
  { 182, 8, 1, 13, 2, -8 },
  { 183, 2, 2, 13, 5, -2 },
  { 184, 10, 17, 13, 2, -16 },
  { 206, 10, 16, 13, 2, -16 },
  { 226, 6, 16, 13, 3, -16 },
  { 238, 11, 16, 13, 0, -16 },
  { 260, 10, 16, 13, 1, -16 },
  { 280, 10, 16, 13, 1, -16 },
  { 300, 11, 16, 13, 2, -16 },
  { 322, 10, 16, 13, 1, -16 },
  { 342, 10, 16, 13, 3, -16 },
  { 362, 11, 16, 13, 1, -16 },
  { 384, 10, 16, 13, 2, -16 },
  { 404, 4, 11, 13, 5, -11 },
  { 410, 5, 14, 13, 4, -11 },
  { 419, 10, 9, 13, 2, -12 },
  { 431, 11, 6, 13, 1, -10 },
  { 440, 10, 9, 13, 1, -12 },
  { 452, 9, 16, 13, 3, -16 },
  { 470, 12, 16, 13, 1, -16 },
  { 494, 11, 16, 13, 0, -16 },
  { 516, 11, 16, 13, 1, -16 },
  { 538, 11, 16, 13, 1, -16 },
  { 560, 11, 16, 13, 1, -16 },
  { 582, 12, 16, 13, 1, -16 },
  { 606, 12, 16, 13, 1, -16 },
  { 630, 11, 16, 13, 1, -16 },
  { 652, 12, 16, 13, 1, -16 },
  { 676, 11, 16, 13, 1, -16 },
  { 698, 11, 16, 13, 1, -16 },
  { 720, 12, 16, 13, 1, -16 },
  { 744, 9, 16, 13, 1, -16 },
  { 762, 12, 16, 13, 1, -16 },
  { 786, 12, 16, 13, 1, -16 },
  { 810, 11, 16, 13, 1, -16 },
  { 832, 12, 16, 13, 1, -16 },
  { 856, 11, 19, 13, 1, -16 },
  { 883, 11, 16, 13, 1, -16 },
  { 905, 11, 16, 13, 1, -16 },
  { 927, 10, 16, 13, 3, -16 },
  { 947, 12, 16, 13, 1, -16 },
  { 971, 11, 16, 13, 2, -16 },
  { 993, 12, 16, 13, 2, -16 },
  { 1017, 13, 16, 13, 0, -16 },
  { 1043, 11, 16, 13, 2, -16 },
  { 1065, 12, 16, 13, 0, -16 },
  { 1089, 7, 21, 13, 3, -18 },
  { 1108, 5, 17, 13, 4, -16 },
  { 1119, 7, 21, 13, 3, -18 },
  { 1138, 7, 9, 13, 3, -16 },
  { 1146, 9, 1, 13, 1, 0 },
  { 1148, 3, 3, 13, 6, -16 },
  { 1150, 10, 12, 13, 1, -12 },
  { 1165, 10, 17, 13, 1, -17 },
  { 1187, 9, 12, 13, 2, -12 },
  { 1201, 10, 17, 13, 2, -17 },
  { 1223, 10, 12, 13, 1, -12 },
  { 1238, 10, 17, 13, 3, -17 },
  { 1260, 11, 17, 13, 1, -12 },
  { 1284, 10, 17, 13, 1, -17 },
  { 1306, 9, 16, 13, 1, -16 },
  { 1324, 10, 21, 13, 0, -16 },
  { 1351, 11, 17, 13, 1, -17 },
  { 1375, 9, 17, 13, 1, -17 },
  { 1395, 12, 12, 13, 0, -12 },
  { 1413, 10, 12, 13, 1, -12 },
  { 1428, 10, 12, 13, 1, -12 },
  { 1443, 11, 16, 13, 0, -12 },
  { 1465, 10, 16, 13, 2, -12 },
  { 1485, 9, 12, 13, 3, -12 },
  { 1499, 10, 12, 13, 1, -12 },
  { 1514, 8, 15, 13, 3, -15 },
  { 1529, 10, 12, 13, 2, -12 },
  { 1544, 10, 12, 13, 2, -12 },
  { 1559, 11, 12, 13, 2, -12 },
  { 1576, 12, 12, 13, 0, -12 },
  { 1594, 13, 17, 13, 0, -12 },
  { 1622, 12, 12, 13, 0, -12 },
  { 1640, 9, 22, 13, 3, -17 },
  { 1665, 4, 19, 13, 4, -16 },
  { 1675, 8, 22, 13, 2, -17 },
  { 1697, 12, 3, 13, 0, -8 },
};

const GFXfont RobotoMono_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC22PT7B_H_
