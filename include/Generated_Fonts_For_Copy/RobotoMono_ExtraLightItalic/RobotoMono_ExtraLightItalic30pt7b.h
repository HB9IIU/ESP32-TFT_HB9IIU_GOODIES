#ifndef _ROBOTOMONO_EXTRALIGHTITALIC30PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x31, 0x08, 0x42, 0x31, 0x88, 0x42, 0x11, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x45, 0x14, 0x51, 0x47, 0x28, 0x80, 0x00, 0x61, 0x80,
  0x10, 0x40, 0x04, 0x30, 0x02, 0x08, 0x00, 0x82, 0x00, 0x61, 0x81, 0xFF,
  0xFC, 0x04, 0x10, 0x03, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x10, 0x40,
  0x04, 0x10, 0x01, 0x04, 0x0F, 0xFF, 0xE0, 0x20, 0x80, 0x08, 0x60, 0x04,
  0x10, 0x01, 0x04, 0x00, 0x43, 0x00, 0x20, 0x80, 0x00, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x01, 0xFE, 0x0C, 0x08, 0x60, 0x31, 0x00, 0x44, 0x01, 0x30,
  0x04, 0x40, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x68, 0x01, 0xA0, 0x06, 0xC0, 0x11, 0x00, 0xC6,
  0x06, 0x07, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x00, 0x18, 0x00, 0xF0,
  0x04, 0x20, 0x30, 0x82, 0x82, 0x1A, 0x08, 0x48, 0x22, 0x21, 0x10, 0xCC,
  0xC1, 0xE2, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x10, 0x11, 0xE0, 0x88, 0x46,
  0x61, 0x11, 0x04, 0x84, 0x16, 0x10, 0x50, 0x43, 0x01, 0x08, 0x03, 0xC0,
  0x00, 0xC0, 0x07, 0xE0, 0x18, 0x40, 0x20, 0xC0, 0xC1, 0x81, 0x02, 0x02,
  0x0C, 0x06, 0x30, 0x04, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x78, 0x01, 0x90,
  0x06, 0x10, 0x58, 0x31, 0xA0, 0x22, 0x40, 0x6D, 0x80, 0x71, 0x00, 0x62,
  0x01, 0xC2, 0x0E, 0x83, 0xF0, 0x80, 0x5E, 0xA8, 0x00, 0x80, 0xC0, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x06, 0x06, 0x06, 0x02, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x1E, 0x27, 0x9F, 0xE0, 0x18, 0x01, 0xC0, 0x19, 0x01, 0x8C, 0x18, 0x30,
  0x80, 0x80, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x24, 0xB5, 0xA0, 0xFF, 0xE0, 0xF0,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xC1, 0x86, 0x02,
  0x10, 0x04, 0x80, 0x12, 0x00, 0xD8, 0x07, 0x40, 0x25, 0x01, 0x14, 0x18,
  0xD0, 0xC2, 0xC6, 0x0B, 0x20, 0x29, 0x00, 0xB8, 0x06, 0xC0, 0x13, 0x00,
  0x44, 0x02, 0x10, 0x18, 0x60, 0xC0, 0x7C, 0x00, 0x06, 0x3F, 0x8C, 0x10,
  0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20,
  0x40, 0x81, 0x00, 0x01, 0x80, 0x1F, 0xC0, 0x81, 0x84, 0x02, 0x30, 0x0C,
  0x80, 0x32, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x1F, 0xC0, 0xC0, 0x86,
  0x01, 0x10, 0x04, 0x80, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0xC0,
  0x1E, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x80, 0x1A,
  0x00, 0x48, 0x01, 0x10, 0x08, 0x60, 0xE0, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x60, 0x02, 0x80, 0x12, 0x00, 0xD8, 0x06, 0x60, 0x31, 0x00, 0x84, 0x04,
  0x10, 0x20, 0x41, 0x83, 0x0C, 0x0C, 0x20, 0x21, 0x00, 0x8F, 0xFF, 0xC0,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x0F, 0xFC,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x40,
  0x3F, 0xC1, 0x81, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x20, 0x0C, 0x80, 0x22, 0x00, 0x8C, 0x04, 0x18, 0x60, 0x3F, 0x00, 0x00,
  0x10, 0x0F, 0x80, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x67, 0xC2, 0xC3, 0x18, 0x0D, 0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x14, 0x00, 0xB0, 0x08, 0x80, 0xC6, 0x0C, 0x0F, 0xC0, 0xFF,
  0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x46, 0x00, 0x8C, 0x01, 0x18,
  0x02, 0x10, 0x08, 0x30, 0x30, 0x3F, 0x80, 0x7F, 0x03, 0x03, 0x0C, 0x03,
  0x10, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x46, 0x01, 0x86,
  0x06, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x7F, 0x04, 0x0C, 0x40, 0x26, 0x01,
  0xA0, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x05, 0x80, 0x64,
  0x05, 0x18, 0xC8, 0x7C, 0x80, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x06,
  0x00, 0xE0, 0x3C, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x80, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x82, 0x18, 0x43, 0x08, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x60, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x01, 0x80, 0x00, 0x06,
  0x07, 0xF1, 0x81, 0x20, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x01, 0x80,
  0x81, 0x80, 0x61, 0x80, 0x10, 0x87, 0x88, 0x84, 0x44, 0xC4, 0x22, 0x44,
  0x11, 0x22, 0x08, 0xA3, 0x08, 0x51, 0x04, 0x28, 0x82, 0x14, 0x43, 0x12,
  0x21, 0x09, 0x11, 0x8C, 0x8D, 0x2C, 0x43, 0x18, 0x30, 0x00, 0x08, 0x00,
  0x03, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02,
  0x80, 0x09, 0x00, 0x13, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x80, 0xC1, 0x01, 0x87, 0xFF, 0x08, 0x02, 0x30,
  0x04, 0x40, 0x09, 0x80, 0x12, 0x00, 0x3C, 0x00, 0x60, 0x0F, 0xF8, 0x10,
  0x18, 0x20, 0x18, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x88, 0x02,
  0x10, 0x18, 0x7F, 0xE0, 0xFF, 0xC1, 0x00, 0x42, 0x00, 0xC4, 0x00, 0x88,
  0x01, 0x30, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x62, 0x03, 0x0F, 0xFC,
  0x00, 0x00, 0xC0, 0x0F, 0xE0, 0x30, 0x20, 0xC0, 0x63, 0x00, 0x44, 0x00,
  0x98, 0x01, 0xA0, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x06, 0x80, 0x19, 0x00, 0x23, 0x00,
  0xC2, 0x03, 0x06, 0x0C, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x08, 0x18, 0x18,
  0x04, 0x10, 0x06, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x03, 0x30,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x04, 0x60,
  0x04, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x10, 0x40, 0x60, 0xC1, 0xC0, 0xFF,
  0x00, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0xFF, 0xC2, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x0F, 0xE0, 0x30, 0x20, 0xC0, 0x63, 0x00, 0x44, 0x00, 0xD8, 0x01,
  0xA0, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xD0,
  0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x33, 0x00, 0x62, 0x00,
  0x82, 0x06, 0x03, 0xF8, 0x00, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x03, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x3F,
  0xFE, 0x3F, 0xFC, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x18, 0x0F,
  0xFF, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x80,
  0x18, 0x80, 0x10, 0xC0, 0x30, 0x40, 0x20, 0x60, 0xC0, 0x1F, 0x80, 0x10,
  0x03, 0x10, 0x04, 0x10, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x20,
  0x80, 0x21, 0x00, 0x26, 0x00, 0x2E, 0x00, 0x7A, 0x00, 0x73, 0x00, 0x61,
  0x00, 0x41, 0x80, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0x60, 0x80, 0x20, 0x80,
  0x30, 0x80, 0x10, 0x80, 0x18, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xF0, 0x08, 0x03, 0x1C, 0x03, 0x14, 0x07, 0x14, 0x05, 0x14, 0x0B, 0x14,
  0x1A, 0x36, 0x12, 0x32, 0x32, 0x22, 0x22, 0x22, 0x62, 0x22, 0x46, 0x23,
  0x84, 0x61, 0x84, 0x61, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0x40,
  0x08, 0xC0, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x18, 0x01, 0x18, 0x01, 0x14,
  0x01, 0x14, 0x03, 0x16, 0x02, 0x12, 0x02, 0x32, 0x02, 0x23, 0x02, 0x21,
  0x06, 0x21, 0x06, 0x20, 0x84, 0x20, 0x84, 0x60, 0x84, 0x40, 0x44, 0x40,
  0x4C, 0x40, 0x6C, 0x40, 0x28, 0x40, 0x28, 0xC0, 0x38, 0x80, 0x18, 0x80,
  0x18, 0x01, 0x80, 0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x04, 0x80, 0x16,
  0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x4C, 0x02, 0x10, 0x18,
  0x60, 0xC0, 0x7C, 0x00, 0x1F, 0xF8, 0x20, 0x18, 0x40, 0x18, 0x80, 0x11,
  0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40, 0x18, 0x80,
  0xE3, 0xFF, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xE0,
  0x30, 0x20, 0x80, 0x63, 0x00, 0x44, 0x00, 0x90, 0x01, 0xA0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x03,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0xC2, 0x03, 0x06, 0x0C, 0x07,
  0xF0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x40, 0x1F, 0xF0, 0x20,
  0x30, 0x40, 0x30, 0x80, 0x23, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02,
  0x20, 0x08, 0x40, 0x31, 0x81, 0x83, 0xFE, 0x04, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x20, 0x30, 0xC0, 0x21, 0x00, 0x42, 0x00, 0xC4, 0x00, 0x88, 0x01,
  0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x20, 0x30, 0x80, 0x23, 0x00, 0x44, 0x00,
  0xC8, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x66, 0x01, 0x86, 0x06, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x30,
  0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x00, 0x98, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0x4C, 0x00, 0x90,
  0x01, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x80, 0x61, 0x01, 0x83, 0x06,
  0x03, 0xF8, 0x00, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x01,
  0x8C, 0x02, 0x18, 0x0C, 0x10, 0x10, 0x20, 0x60, 0x40, 0x80, 0x81, 0x01,
  0x04, 0x03, 0x08, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x12, 0x00, 0x2C,
  0x00, 0x50, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x81, 0x83, 0x81, 0x82, 0x83,
  0x82, 0x82, 0x86, 0x82, 0x84, 0x86, 0x84, 0x84, 0x8C, 0x84, 0x88, 0x8C,
  0x88, 0x88, 0x88, 0x88, 0x90, 0x98, 0x90, 0x90, 0x90, 0x90, 0xB0, 0xA0,
  0xA0, 0xA0, 0xA0, 0xA0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x0C, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x30, 0x08, 0x08, 0x02, 0x04,
  0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0x40, 0x00, 0xA0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x01, 0x20, 0x00, 0x8C, 0x00, 0x61, 0x00, 0x30,
  0x40, 0x08, 0x08, 0x04, 0x02, 0x03, 0x00, 0xC1, 0x80, 0x10, 0xC0, 0x06,
  0x00, 0xC0, 0x06, 0x80, 0x19, 0x80, 0x21, 0x00, 0x82, 0x03, 0x06, 0x04,
  0x04, 0x10, 0x08, 0x60, 0x18, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x50, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x0F,
  0x84, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x1E, 0x0F, 0x00, 0x83, 0x04, 0x10, 0x41,
  0x06, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08,
  0x30, 0x40, 0x07, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x1F, 0x0F, 0x80, 0x03,
  0x01, 0xC0, 0x50, 0x24, 0x09, 0x04, 0x23, 0x08, 0x82, 0x60, 0x90, 0x38,
  0x04, 0xFF, 0xF0, 0xC9, 0x90, 0x07, 0xE0, 0xC1, 0x8C, 0x06, 0x40, 0x16,
  0x00, 0x80, 0x04, 0x00, 0x61, 0xFF, 0x38, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x03, 0x40, 0x3B, 0x06, 0xCF, 0xE6, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x7C, 0x16, 0x18, 0x60,
  0x21, 0x00, 0xCC, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x0D, 0x80, 0x26, 0x00, 0x98, 0x04, 0x60, 0x31, 0x41, 0x8C, 0xFC, 0x00,
  0x07, 0xE0, 0x61, 0x84, 0x06, 0x40, 0x16, 0x00, 0xA0, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x2C, 0x03, 0x20, 0x10, 0x83,
  0x03, 0xF0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x03, 0xE6, 0x1C, 0x28, 0x60, 0x30, 0x80, 0x63, 0x00,
  0x44, 0x00, 0x88, 0x03, 0x30, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0xC6, 0x01, 0x84, 0x06, 0x0C, 0x1C, 0x0F, 0xC8, 0x00, 0x07, 0xE0,
  0x61, 0x84, 0x06, 0x40, 0x16, 0x00, 0xA0, 0x07, 0x00, 0x3F, 0xFF, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x18, 0xC1, 0x83, 0xF0,
  0x00, 0x7C, 0x07, 0x10, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x3F, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xE6, 0x1C, 0x28, 0x60, 0x30, 0x80,
  0x63, 0x00, 0x44, 0x00, 0x88, 0x03, 0x30, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x22, 0x00, 0xC6, 0x01, 0x84, 0x06, 0x0C, 0x1C, 0x0F, 0xC8, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x84, 0x02, 0x06, 0x0C, 0x07, 0xE0, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x7C, 0x12, 0x18, 0x50, 0x31, 0x80, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0xC8, 0x03, 0x60, 0x09, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x19,
  0x00, 0x6C, 0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F,
  0xFF, 0x00, 0x08, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x3F, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x03, 0x30, 0x18, 0x80, 0x82, 0x0C, 0x08, 0x60, 0x23,
  0x01, 0x90, 0x07, 0xC0, 0x1D, 0x80, 0x63, 0x01, 0x04, 0x04, 0x18, 0x30,
  0x30, 0xC0, 0x42, 0x00, 0x88, 0x03, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x37, 0x8F, 0x14, 0x78, 0xCC, 0x18,
  0x24, 0x08, 0x12, 0x04, 0x09, 0x06, 0x0D, 0x82, 0x04, 0x81, 0x02, 0x40,
  0x81, 0x20, 0x40, 0x90, 0x20, 0xD8, 0x30, 0x6C, 0x10, 0x24, 0x08, 0x12,
  0x04, 0x09, 0x02, 0x04, 0x11, 0xF0, 0x58, 0x61, 0xC0, 0xC6, 0x01, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x0D, 0x80, 0x26, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x64, 0x01, 0x30, 0x04, 0x07, 0xE0, 0x70, 0xC3,
  0x01, 0x88, 0x02, 0x40, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x31, 0x01, 0x86, 0x0C, 0x0F, 0xE0,
  0x09, 0xF8, 0x16, 0x18, 0x30, 0x10, 0x40, 0x31, 0x80, 0x23, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x0C, 0xC0, 0x11, 0x00, 0x22, 0x00,
  0x86, 0x03, 0x0A, 0x0C, 0x13, 0xF0, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x07, 0xCC, 0x70, 0xA3, 0x01, 0x88,
  0x06, 0x60, 0x09, 0x00, 0x24, 0x01, 0xB0, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x01, 0x20, 0x0C, 0xC0, 0x31, 0x01, 0x86, 0x0E, 0x0F, 0xC8, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x31, 0xF9, 0xB8,
  0x0A, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x07,
  0xE0, 0x60, 0xC3, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x13, 0x00, 0xC6,
  0x06, 0x0F, 0xF0, 0x04, 0x00, 0x80, 0x10, 0x06, 0x0F, 0xFE, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x06, 0x00, 0x40, 0x07, 0xC0, 0x20, 0x0C, 0x80, 0x32, 0x00,
  0x88, 0x02, 0x60, 0x09, 0x00, 0x24, 0x01, 0x90, 0x06, 0x40, 0x11, 0x00,
  0x4C, 0x01, 0x30, 0x04, 0xC0, 0x31, 0x01, 0xC6, 0x0A, 0x0F, 0xC8, 0x80,
  0x0E, 0x00, 0x2C, 0x01, 0x90, 0x04, 0x40, 0x21, 0x00, 0x86, 0x04, 0x08,
  0x30, 0x20, 0x80, 0x86, 0x03, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01,
  0xC0, 0x02, 0x00, 0x81, 0x81, 0x81, 0x82, 0xC1, 0x82, 0xC2, 0x86, 0xC2,
  0x84, 0xC4, 0x84, 0xC4, 0x88, 0x4C, 0x88, 0x48, 0x98, 0x48, 0x90, 0x50,
  0x90, 0x50, 0xB0, 0x70, 0xA0, 0x60, 0xA0, 0x60, 0x40, 0x40, 0x40, 0x30,
  0x03, 0x18, 0x04, 0x08, 0x0C, 0x0C, 0x18, 0x04, 0x30, 0x02, 0x60, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x04, 0x40, 0x08, 0x60, 0x10,
  0x20, 0x30, 0x30, 0x60, 0x18, 0xC0, 0x08, 0x30, 0x00, 0xC4, 0x00, 0x61,
  0x00, 0x10, 0x60, 0x0C, 0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x30,
  0x20, 0x04, 0x10, 0x01, 0x0C, 0x00, 0x62, 0x00, 0x09, 0x80, 0x02, 0x40,
  0x00, 0xA0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x7F, 0xFC, 0x00, 0x60, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0xE0, 0x30, 0x03,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x60, 0x08, 0x42, 0x11, 0x88, 0x42,
  0x10, 0x8C, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0x18, 0x80, 0x0C,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x30, 0x0C, 0x00, 0x3E, 0x01, 0x43, 0x02, 0x81, 0x82, 0x80, 0xFC, 0x00,
  0x38,
};

const GFXglyph RobotoMono_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 21, 18, 6, -21 },
  { 15, 6, 7, 18, 7, -23 },
  { 21, 18, 21, 18, 0, -21 },
  { 69, 14, 27, 18, 2, -24 },
  { 117, 14, 22, 18, 2, -22 },
  { 156, 15, 22, 18, 1, -22 },
  { 198, 2, 7, 18, 9, -23 },
  { 200, 9, 31, 18, 5, -24 },
  { 235, 9, 31, 18, 3, -24 },
  { 270, 13, 12, 18, 4, -21 },
  { 290, 14, 16, 18, 2, -18 },
  { 318, 3, 7, 18, 4, -3 },
  { 321, 11, 1, 18, 3, -10 },
  { 323, 2, 2, 18, 7, -2 },
  { 324, 14, 23, 18, 2, -21 },
  { 365, 14, 22, 18, 2, -22 },
  { 404, 7, 21, 18, 5, -21 },
  { 423, 14, 22, 18, 1, -22 },
  { 462, 14, 22, 18, 1, -22 },
  { 501, 14, 21, 18, 1, -21 },
  { 538, 14, 21, 18, 3, -21 },
  { 575, 13, 22, 18, 2, -22 },
  { 611, 13, 21, 18, 4, -21 },
  { 646, 15, 22, 18, 2, -22 },
  { 688, 13, 22, 18, 3, -22 },
  { 724, 5, 15, 18, 7, -15 },
  { 734, 6, 19, 18, 6, -15 },
  { 749, 14, 12, 18, 2, -16 },
  { 770, 14, 7, 18, 2, -13 },
  { 783, 13, 12, 18, 2, -16 },
  { 803, 11, 22, 18, 5, -22 },
  { 834, 17, 22, 18, 1, -22 },
  { 881, 15, 21, 18, 0, -21 },
  { 921, 15, 21, 18, 1, -21 },
  { 961, 15, 22, 18, 2, -22 },
  { 1003, 16, 21, 18, 1, -21 },
  { 1045, 16, 21, 18, 1, -21 },
  { 1087, 15, 21, 18, 2, -21 },
  { 1127, 15, 22, 18, 2, -22 },
  { 1169, 16, 21, 18, 1, -21 },
  { 1211, 16, 21, 18, 1, -21 },
  { 1253, 16, 21, 18, 1, -21 },
  { 1295, 16, 21, 18, 2, -21 },
  { 1337, 12, 21, 18, 2, -21 },
  { 1369, 16, 21, 18, 1, -21 },
  { 1411, 16, 21, 18, 1, -21 },
  { 1453, 14, 22, 18, 2, -22 },
  { 1492, 15, 21, 18, 2, -21 },
  { 1532, 15, 26, 18, 2, -22 },
  { 1581, 15, 21, 18, 2, -21 },
  { 1621, 15, 22, 18, 2, -22 },
  { 1663, 15, 21, 18, 3, -21 },
  { 1703, 15, 21, 18, 2, -21 },
  { 1743, 15, 21, 18, 3, -21 },
  { 1783, 16, 21, 18, 3, -21 },
  { 1825, 18, 21, 18, 0, -21 },
  { 1873, 15, 21, 18, 3, -21 },
  { 1913, 16, 21, 18, 1, -21 },
  { 1955, 9, 29, 18, 5, -24 },
  { 1988, 6, 23, 18, 6, -21 },
  { 2006, 9, 29, 18, 4, -24 },
  { 2039, 10, 11, 18, 4, -21 },
  { 2053, 12, 1, 18, 1, 0 },
  { 2055, 3, 4, 18, 9, -22 },
  { 2057, 13, 16, 18, 2, -16 },
  { 2083, 14, 23, 18, 1, -23 },
  { 2124, 13, 16, 18, 2, -16 },
  { 2150, 15, 23, 18, 2, -23 },
  { 2194, 13, 16, 18, 2, -16 },
  { 2220, 14, 23, 18, 4, -23 },
  { 2261, 15, 22, 18, 1, -16 },
  { 2303, 14, 23, 18, 1, -23 },
  { 2344, 12, 22, 18, 2, -22 },
  { 2377, 14, 28, 18, 0, -22 },
  { 2426, 14, 23, 18, 2, -23 },
  { 2467, 12, 23, 18, 2, -23 },
  { 2502, 17, 16, 18, 0, -16 },
  { 2536, 14, 16, 18, 1, -16 },
  { 2564, 14, 16, 18, 2, -16 },
  { 2592, 15, 22, 18, 0, -16 },
  { 2634, 14, 22, 18, 2, -16 },
  { 2673, 13, 16, 18, 4, -16 },
  { 2699, 14, 16, 18, 2, -16 },
  { 2727, 11, 20, 18, 4, -20 },
  { 2755, 14, 16, 18, 2, -16 },
  { 2783, 14, 16, 18, 3, -16 },
  { 2811, 16, 16, 18, 2, -16 },
  { 2843, 16, 16, 18, 1, -16 },
  { 2875, 18, 22, 18, 0, -16 },
  { 2925, 15, 16, 18, 1, -16 },
  { 2955, 11, 29, 18, 5, -23 },
  { 2995, 5, 25, 18, 6, -21 },
  { 3011, 11, 29, 18, 3, -23 },
  { 3051, 16, 5, 18, 1, -11 },
};

const GFXfont RobotoMono_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC30PT7B_H_
