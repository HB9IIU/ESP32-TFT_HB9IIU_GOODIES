#ifndef _ROBOTOMONO_EXTRALIGHTITALIC52PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0xE0, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0C, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x13, 0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x9C,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x21, 0x80,
  0x60, 0x18, 0xC0, 0x30, 0x18, 0x40, 0x18, 0x1C, 0x60, 0x0C, 0x0C, 0x30,
  0x0C, 0x0C, 0x18, 0x06, 0x0C, 0x0C, 0x03, 0x06, 0x02, 0x03, 0x06, 0x01,
  0x83, 0x86, 0x00, 0xE3, 0x87, 0x00, 0x3F, 0x83, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC1, 0xF8, 0x00, 0xC3, 0xCE, 0x00, 0xC1, 0x83, 0x00, 0xE1,
  0x80, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0xC0, 0x30, 0x60, 0x60, 0x18, 0x30,
  0x30, 0x0C, 0x30, 0x18, 0x06, 0x30, 0x18, 0x03, 0x38, 0x0C, 0x03, 0x18,
  0x02, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x38,
  0x07, 0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0x30, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xE0, 0x0C, 0x70, 0x1C, 0x07,
  0x38, 0x03, 0x01, 0x8C, 0x00, 0xE0, 0x67, 0x00, 0x18, 0x39, 0x80, 0x03,
  0x0C, 0x60, 0x00, 0xE7, 0x18, 0x00, 0x19, 0x86, 0x00, 0x07, 0xE1, 0x80,
  0x00, 0xF0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0x03, 0x00, 0x0E, 0xC0,
  0xF0, 0x0F, 0x18, 0x0F, 0xBF, 0x07, 0x01, 0xFF, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x33, 0x76, 0x66, 0x66, 0xCC, 0xC0, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x38, 0x0C,
  0x07, 0xF8, 0x30, 0xFC, 0xFC, 0xCF, 0xC0, 0x7F, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x39, 0x80, 0x01, 0xC3, 0x00, 0x06,
  0x0E, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x30, 0x1E, 0x00, 0xE0, 0x30, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0xC7, 0x1C, 0x63, 0x8C, 0x73, 0x84, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x0E,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x1F, 0x30, 0x00, 0x33,
  0x70, 0x00, 0x67, 0x60, 0x01, 0xC7, 0x60, 0x03, 0x86, 0x60, 0x07, 0x06,
  0x60, 0x0E, 0x06, 0x60, 0x18, 0x06, 0xE0, 0x70, 0x06, 0xC0, 0xE0, 0x0E,
  0xC1, 0xC0, 0x0C, 0xC3, 0x80, 0x0C, 0xC6, 0x00, 0x0C, 0xDC, 0x00, 0x0C,
  0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0,
  0x70, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x1F, 0x81, 0xF6, 0x3E, 0x1B,
  0xE0, 0x6E, 0x03, 0xA0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x38, 0x07, 0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0,
  0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x01, 0xC0,
  0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xCF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x0F, 0xF0, 0x0E, 0x7F, 0xF8, 0x19,
  0xC0, 0x38, 0x36, 0x00, 0x38, 0x78, 0x00, 0x31, 0xE0, 0x00, 0x73, 0x80,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x37, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0x30, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x70, 0x0F, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x8E,
  0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0x70,
  0x00, 0x78, 0xC0, 0x03, 0x63, 0x80, 0x39, 0x87, 0x83, 0xCE, 0x0F, 0xFE,
  0x30, 0x0F, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xF0, 0xE0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFE,
  0x0F, 0x00, 0xE1, 0xC0, 0x0C, 0x60, 0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x70, 0x00,
  0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x0C, 0x03, 0x06, 0x03, 0xF8, 0x18, 0x30, 0x38, 0xE0,
  0xC3, 0x03, 0x03, 0x06, 0x38, 0x30, 0x18, 0x31, 0x83, 0x80, 0xC1, 0x8C,
  0x18, 0x04, 0x0C, 0xC1, 0x80, 0x60, 0x66, 0x0C, 0x03, 0x03, 0x20, 0x60,
  0x18, 0x1B, 0x06, 0x00, 0x80, 0xD8, 0x30, 0x0C, 0x04, 0xC1, 0x80, 0x60,
  0x64, 0x08, 0x02, 0x03, 0x60, 0xC0, 0x30, 0x1B, 0x06, 0x01, 0x80, 0x98,
  0x30, 0x1C, 0x0C, 0xC1, 0x80, 0xE0, 0x46, 0x0C, 0x0F, 0x06, 0x30, 0x60,
  0xD8, 0x61, 0x81, 0x9C, 0xC7, 0x04, 0x0F, 0xC3, 0xF0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x38,
  0x01, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x78, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0xF0, 0x18, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x1C, 0x18, 0x00, 0x1E, 0x06, 0x00, 0x1E, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x07, 0x00, 0x30,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0xF0,
  0x0C, 0x00, 0x38, 0x03, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xC0,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xCC,
  0x00, 0x7F, 0xF3, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x78, 0x18,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x70, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC7, 0x80, 0x00,
  0x06, 0x7E, 0x00, 0x00, 0x37, 0x30, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x06, 0xC0, 0x01, 0xB0, 0x6C, 0x00, 0x3E, 0x06, 0xC0, 0x03,
  0x60, 0x6C, 0x00, 0x66, 0x06, 0x60, 0x06, 0x60, 0xE6, 0x00, 0xC6, 0x0C,
  0x60, 0x1C, 0xC0, 0xC6, 0x01, 0x8C, 0x0C, 0x60, 0x38, 0xC0, 0xC6, 0x03,
  0x0C, 0x0C, 0x30, 0x60, 0xC1, 0xC3, 0x06, 0x1C, 0x18, 0x30, 0xC1, 0x81,
  0x83, 0x0C, 0x18, 0x18, 0x31, 0x81, 0x81, 0x81, 0xB8, 0x18, 0x18, 0x1B,
  0x01, 0x83, 0x81, 0xF0, 0x38, 0x30, 0x1E, 0x03, 0x03, 0x01, 0xC0, 0x30,
  0x30, 0x0C, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x78, 0x00, 0x06,
  0x06, 0xC0, 0x00, 0x60, 0x6C, 0x00, 0x06, 0x06, 0xC0, 0x00, 0x60, 0x66,
  0x00, 0x0E, 0x0E, 0x60, 0x00, 0xC0, 0xC6, 0x00, 0x0C, 0x0C, 0x30, 0x00,
  0xC0, 0xC3, 0x00, 0x0C, 0x0C, 0x38, 0x00, 0xC0, 0xC1, 0x80, 0x1C, 0x1C,
  0x18, 0x01, 0x81, 0x80, 0xC0, 0x18, 0x18, 0x0C, 0x01, 0x81, 0x80, 0xC0,
  0x18, 0x18, 0x06, 0x01, 0x81, 0x80, 0x60, 0x38, 0x38, 0x07, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x30, 0x03, 0x03, 0x03, 0x00, 0x18, 0x30, 0x30, 0x01,
  0x87, 0x03, 0x00, 0x18, 0x70, 0x70, 0x00, 0xC6, 0x06, 0x00, 0x0C, 0x60,
  0x60, 0x00, 0xC6, 0x06, 0x00, 0x06, 0x60, 0x60, 0x00, 0x6E, 0x06, 0x00,
  0x07, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x70,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0C, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x01, 0xE0, 0x60,
  0x00, 0x70, 0x0C, 0x00, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x0F, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x30, 0x03, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x07, 0x01, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x06, 0x00,
  0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x6C,
  0x00, 0xC0, 0x0D, 0x80, 0x38, 0x01, 0xB0, 0x07, 0x00, 0x66, 0x01, 0xE0,
  0x0C, 0xC0, 0x3C, 0x01, 0x98, 0x07, 0x80, 0x63, 0x01, 0xB0, 0x0C, 0x60,
  0x36, 0x01, 0x8C, 0x06, 0xC0, 0x31, 0x81, 0x98, 0x0C, 0x30, 0x33, 0x01,
  0x86, 0x06, 0x60, 0x30, 0x81, 0x8C, 0x0C, 0x30, 0x30, 0x81, 0x86, 0x06,
  0x10, 0x30, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x30,
  0x61, 0x81, 0x86, 0x0C, 0x30, 0x31, 0x81, 0x86, 0x06, 0x30, 0x31, 0x80,
  0xC6, 0x06, 0x30, 0x19, 0x80, 0xC6, 0x03, 0x30, 0x19, 0x80, 0x66, 0x03,
  0x30, 0x0D, 0x80, 0x66, 0x01, 0xB0, 0x0D, 0x80, 0x36, 0x01, 0xB0, 0x07,
  0xC0, 0x36, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCC, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x19, 0x80,
  0x0C, 0x60, 0x03, 0x18, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x1C,
  0x0C, 0x06, 0x03, 0x83, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01,
  0xCC, 0x00, 0x37, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE1, 0xC3, 0x0E, 0x18, 0x30, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0x81, 0xE0, 0x3C, 0x00, 0xE0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0xC7,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xF8,
  0x03, 0x0F, 0x00, 0x06, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0x80, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30, 0x00, 0x1E,
  0x60, 0x00, 0x78, 0xE0, 0x01, 0xB0, 0xE0, 0x0E, 0x60, 0xFF, 0xF8, 0xC0,
  0xFF, 0xC1, 0xC0, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x7E, 0x00, 0xC7, 0xFF, 0x01, 0x9E, 0x0F, 0x03, 0x60,
  0x06, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xCE, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0xC0, 0x01, 0x86, 0xC0,
  0x0F, 0x0D, 0xC0, 0x3C, 0x19, 0xFF, 0xE0, 0x30, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x0E,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0x71, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x02, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCE, 0x00, 0x06, 0x18, 0x00, 0x38, 0x70, 0x01, 0xC0, 0xE0, 0x0E,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0xC0, 0x1F,
  0xF8, 0x60, 0x1E, 0x0F, 0x30, 0x1C, 0x01, 0xB8, 0x1C, 0x00, 0x7C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0E, 0x00,
  0x7C, 0x03, 0x80, 0x76, 0x00, 0xFF, 0xE3, 0x00, 0x3F, 0xE3, 0x80, 0x03,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x78, 0x03,
  0xC0, 0x1C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x38, 0x00, 0x07, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x18, 0x18, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x07, 0xCF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF8, 0xC0, 0x3C, 0x1E, 0x60, 0x38, 0x03, 0xB0, 0x38,
  0x00, 0xF8, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x30, 0x00,
  0x70, 0x1C, 0x00, 0xF8, 0x07, 0x00, 0xEC, 0x01, 0xFF, 0xE6, 0x00, 0x7F,
  0xC7, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x60, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x03, 0xF0,
  0x06, 0x1F, 0xF8, 0x06, 0x3C, 0x1C, 0x06, 0x60, 0x0E, 0x0C, 0xC0, 0x07,
  0x0D, 0x80, 0x03, 0x0F, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x70, 0x30, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x01, 0xE0, 0x01, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33,
  0xC0, 0x00, 0x1B, 0xF0, 0x00, 0x0F, 0x98, 0x00, 0x0F, 0x8E, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x67, 0xF8, 0x7F, 0x83, 0x60, 0xEE, 0x0E, 0x1E, 0x03, 0xE0, 0x30, 0xE0,
  0x1E, 0x01, 0x8E, 0x00, 0xE0, 0x0C, 0x70, 0x06, 0x00, 0x63, 0x00, 0x30,
  0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0xE0, 0x0E,
  0x60, 0x06, 0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x18, 0xC0,
  0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x70, 0x07, 0x00, 0x73, 0x00, 0x30,
  0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06,
  0x30, 0x03, 0x00, 0x33, 0x80, 0x30, 0x03, 0x18, 0x01, 0x80, 0x18, 0xC0,
  0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x30, 0x03, 0x00, 0x31, 0x80, 0x38,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x06, 0x1F, 0xF8, 0x06, 0x38, 0x1C, 0x06,
  0x60, 0x0E, 0x0C, 0xC0, 0x07, 0x0D, 0x80, 0x03, 0x0F, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x78, 0x07,
  0x80, 0x38, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38,
  0x00, 0x06, 0x30, 0x00, 0x07, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x70,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0x9F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x8F, 0xFC, 0x00,
  0xCE, 0x07, 0x80, 0x6C, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x18,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x70, 0x3E, 0x00, 0x70, 0x1B,
  0x80, 0x78, 0x0C, 0xFF, 0xF0, 0x06, 0x1F, 0xF0, 0x07, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x8C, 0x0F, 0x03, 0x98, 0x38, 0x03, 0xB0, 0xE0, 0x03, 0xE3, 0x80, 0x03,
  0x86, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x38, 0x00,
  0x18, 0x30, 0x00, 0x70, 0x70, 0x03, 0xE0, 0x70, 0x0E, 0xC0, 0x7D, 0xF9,
  0x80, 0x7F, 0xC7, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x30, 0x7F, 0xE0, 0xC7, 0xE0, 0x83, 0x38, 0x00, 0x0D,
  0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0xE0, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x70,
  0x00, 0x18, 0x60, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0xFE, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0xE6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x1C,
  0x00, 0x1E, 0x18, 0x00, 0x7C, 0x38, 0x01, 0xF0, 0x38, 0x0F, 0x60, 0x7F,
  0xF8, 0xC0, 0x3F, 0xE1, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30,
  0x00, 0x60, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x07, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x78,
  0x01, 0x80, 0x1B, 0x00, 0x70, 0x03, 0x60, 0x0F, 0x00, 0xEC, 0x03, 0x60,
  0x19, 0x80, 0x6C, 0x03, 0x30, 0x0D, 0x80, 0xC6, 0x03, 0x30, 0x18, 0xC0,
  0x66, 0x07, 0x18, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x18, 0x60, 0x63, 0x06,
  0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x10, 0xC1, 0x86, 0x03, 0x18,
  0x10, 0xC0, 0x66, 0x02, 0x30, 0x0C, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0xC0,
  0x36, 0x01, 0xB0, 0x06, 0xC0, 0x36, 0x00, 0xF0, 0x06, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x10, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x1C, 0x38, 0x00, 0x33, 0x81, 0xE0, 0x06, 0x70,
  0x07, 0x00, 0x66, 0x00, 0x38, 0x0C, 0xE0, 0x01, 0xC3, 0xCC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 37, 31, 11, -37 },
  { 38, 11, 11, 31, 12, -39 },
  { 54, 30, 37, 31, 1, -37 },
  { 193, 25, 47, 31, 3, -42 },
  { 340, 25, 39, 31, 3, -38 },
  { 462, 26, 39, 31, 2, -38 },
  { 589, 4, 11, 31, 15, -39 },
  { 595, 16, 53, 31, 9, -41 },
  { 701, 16, 53, 31, 5, -41 },
  { 807, 22, 21, 31, 7, -37 },
  { 865, 25, 27, 31, 3, -31 },
  { 950, 6, 11, 31, 6, -4 },
  { 959, 18, 2, 31, 6, -18 },
  { 964, 4, 4, 31, 12, -4 },
  { 966, 24, 40, 31, 4, -37 },
  { 1086, 24, 39, 31, 4, -38 },
  { 1203, 14, 37, 31, 8, -37 },
  { 1268, 25, 37, 31, 1, -37 },
  { 1384, 26, 39, 31, 1, -38 },
  { 1511, 26, 37, 31, 1, -37 },
  { 1632, 26, 38, 31, 4, -37 },
  { 1756, 23, 38, 31, 3, -37 },
  { 1866, 24, 37, 31, 6, -37 },
  { 1977, 26, 39, 31, 3, -38 },
  { 2104, 22, 38, 31, 5, -38 },
  { 2209, 8, 26, 31, 13, -26 },
  { 2235, 11, 33, 31, 10, -26 },
  { 2281, 23, 21, 31, 4, -27 },
  { 2342, 25, 12, 31, 3, -23 },
  { 2380, 23, 21, 31, 3, -27 },
  { 2441, 19, 38, 31, 8, -38 },
  { 2532, 29, 37, 31, 1, -37 },
  { 2667, 26, 37, 31, 0, -37 },
  { 2788, 26, 37, 31, 2, -37 },
  { 2909, 26, 38, 31, 3, -37 },
  { 3033, 27, 37, 31, 2, -37 },
  { 3158, 27, 37, 31, 3, -37 },
  { 3283, 27, 37, 31, 3, -37 },
  { 3408, 26, 39, 31, 3, -38 },
  { 3535, 28, 37, 31, 2, -37 },
  { 3665, 27, 37, 31, 2, -37 },
  { 3790, 27, 38, 31, 2, -37 },
  { 3919, 29, 37, 31, 3, -37 },
  { 4054, 21, 37, 31, 3, -37 },
  { 4152, 28, 37, 31, 2, -37 },
  { 4282, 28, 37, 31, 2, -37 },
  { 4412, 25, 39, 31, 3, -38 },
  { 4534, 27, 37, 31, 3, -37 },
  { 4659, 26, 45, 31, 3, -38 },
  { 4806, 26, 37, 31, 3, -37 },
  { 4927, 26, 39, 31, 3, -38 },
  { 5054, 26, 37, 31, 6, -37 },
  { 5175, 27, 38, 31, 3, -37 },
  { 5304, 25, 37, 31, 6, -37 },
  { 5420, 27, 37, 31, 5, -37 },
  { 5545, 31, 37, 31, 0, -37 },
  { 5689, 25, 37, 31, 6, -37 },
  { 5805, 28, 37, 31, 1, -37 },
  { 5935, 16, 50, 31, 8, -42 },
  { 6035, 11, 40, 31, 10, -37 },
  { 6090, 16, 50, 31, 7, -42 },
  { 6190, 18, 20, 31, 6, -37 },
  { 6235, 21, 2, 31, 2, 0 },
  { 6241, 6, 6, 31, 15, -38 },
  { 6246, 23, 29, 31, 3, -28 },
  { 6330, 23, 40, 31, 3, -39 },
  { 6445, 22, 29, 31, 4, -28 },
  { 6525, 25, 40, 31, 4, -39 },
  { 6650, 24, 29, 31, 3, -28 },
  { 6737, 25, 40, 31, 7, -40 },
  { 6862, 25, 39, 31, 2, -28 },
  { 6984, 24, 39, 31, 2, -39 },
  { 7101, 21, 37, 31, 3, -37 },
  { 7199, 24, 48, 31, 0, -37 },
  { 7343, 25, 39, 31, 3, -39 },
  { 7465, 21, 39, 31, 3, -39 },
  { 7568, 29, 28, 31, 0, -28 },
  { 7670, 24, 28, 31, 2, -28 },
  { 7754, 24, 29, 31, 3, -28 },
  { 7841, 25, 39, 31, 1, -28 },
  { 7963, 23, 39, 31, 4, -28 },
  { 8076, 22, 28, 31, 7, -28 },
  { 8153, 23, 29, 31, 4, -28 },
  { 8237, 20, 36, 31, 6, -35 },
  { 8327, 23, 28, 31, 4, -27 },
  { 8408, 24, 28, 31, 5, -28 },
  { 8492, 27, 27, 31, 4, -27 },
  { 8584, 28, 28, 31, 1, -28 },
  { 8682, 31, 39, 31, -1, -28 },
  { 8834, 27, 27, 31, 1, -27 },
  { 8926, 20, 52, 31, 8, -41 },
  { 9056, 9, 45, 31, 11, -37 },
  { 9107, 20, 52, 31, 4, -41 },
  { 9237, 28, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC52PT7B_H_
