#ifndef _ROBOTOMONO_EXTRALIGHTITALIC15PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x92, 0x02, 0x00, 0xB7, 0x00, 0x09, 0x04, 0x82, 0x4F,
  0xF1, 0x20, 0x90, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x08, 0x38, 0x8A,
  0x14, 0x08, 0x0E, 0x02, 0x05, 0x06, 0x12, 0xC2, 0x04, 0x00, 0x61, 0x26,
  0x54, 0xAE, 0x82, 0x09, 0x15, 0x53, 0x24, 0x30, 0x18, 0x49, 0x12, 0x43,
  0x04, 0x14, 0xC5, 0x8D, 0x09, 0xE8, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x40, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x44, 0x22, 0x13,
  0x00, 0x10, 0x49, 0x5E, 0x33, 0x20, 0x08, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x10, 0x68, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0xF2, 0x68, 0xE1, 0x85, 0x09,
  0xE0, 0x17, 0x91, 0x11, 0x22, 0x22, 0x20, 0x1C, 0x45, 0x08, 0x10, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF8, 0x1C, 0x22, 0x41, 0x01, 0x02, 0x1C, 0x02,
  0x02, 0x82, 0x82, 0x7C, 0x02, 0x02, 0x06, 0x0A, 0x12, 0x22, 0x44, 0xFF,
  0x04, 0x04, 0x04, 0x3F, 0x20, 0x20, 0x40, 0x78, 0x44, 0x02, 0x02, 0x84,
  0x84, 0x78, 0x0C, 0xC4, 0x10, 0xBB, 0x18, 0x61, 0x86, 0x17, 0x80, 0xFE,
  0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x1C, 0x45, 0x0A,
  0x14, 0x67, 0x11, 0x41, 0x83, 0x09, 0xE0, 0x1C, 0xC5, 0x0C, 0x18, 0x30,
  0x53, 0x1A, 0x04, 0x11, 0xC0, 0x40, 0x08, 0x20, 0x00, 0x14, 0x80, 0x02,
  0x39, 0x86, 0x03, 0x01, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x40, 0x60, 0x30,
  0x73, 0x18, 0x00, 0x39, 0x18, 0x41, 0x08, 0x42, 0x08, 0x00, 0x04, 0x00,
  0x0E, 0x08, 0x89, 0x2B, 0x55, 0x2D, 0x26, 0x93, 0x4A, 0x9E, 0x20, 0x0F,
  0x00, 0x04, 0x08, 0x30, 0x51, 0x22, 0x48, 0x9F, 0x42, 0x86, 0x08, 0x3C,
  0x85, 0x0A, 0x14, 0x4F, 0x21, 0x41, 0x83, 0x0B, 0xE0, 0x1C, 0x45, 0x0C,
  0x18, 0x10, 0x20, 0x41, 0x85, 0x09, 0xE0, 0x78, 0x89, 0x0A, 0x14, 0x30,
  0x60, 0xC1, 0x85, 0x13, 0xC0, 0x3F, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x80,
  0x80, 0x80, 0x80, 0xFC, 0x3F, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C, 0x08, 0x10, 0x27, 0xC1, 0x83, 0x09,
  0xE0, 0x20, 0x90, 0x48, 0x44, 0x24, 0x13, 0xF9, 0x04, 0x82, 0x42, 0x41,
  0x20, 0x80, 0x7E, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x43, 0xF0,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x85, 0x13, 0xC0, 0x41, 0x42,
  0x44, 0x48, 0x50, 0x60, 0x50, 0x88, 0x88, 0x84, 0x86, 0x21, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x20, 0x90, 0xCC, 0xA6, 0x65, 0x52,
  0xA9, 0x24, 0x92, 0x41, 0x21, 0x20, 0x80, 0x20, 0x90, 0x4C, 0x46, 0x24,
  0x92, 0x49, 0x24, 0x8A, 0x46, 0x21, 0x20, 0x80, 0x1C, 0x45, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x3C, 0x42, 0x41, 0x41, 0x42, 0x46,
  0x70, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0x09, 0xE0, 0x40, 0x40, 0x3C, 0x85, 0x0A, 0x14, 0x28, 0xAE, 0x44,
  0x85, 0x0A, 0x10, 0x1C, 0xC5, 0x0A, 0x04, 0x07, 0x01, 0x01, 0x83, 0x09,
  0xE0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x00, 0x41,
  0x41, 0x42, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x83, 0x06,
  0x14, 0x28, 0x91, 0x24, 0x28, 0x60, 0xC1, 0x00, 0x93, 0x26, 0xCD, 0x9B,
  0x5A, 0xB5, 0x4C, 0x99, 0x32, 0x40, 0x20, 0x90, 0x84, 0x42, 0x40, 0xC0,
  0x40, 0x50, 0x28, 0x24, 0x21, 0x20, 0x80, 0x83, 0x0A, 0x12, 0x45, 0x0A,
  0x08, 0x10, 0x40, 0x81, 0x00, 0x3F, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0xFE, 0x39, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08,
  0x70, 0x92, 0x44, 0x92, 0x44, 0x90, 0x38, 0x44, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x70, 0x10, 0x8C, 0x94, 0xC4, 0xFE, 0xD0, 0x3C, 0x84, 0x09,
  0x64, 0x50, 0xA1, 0x7E, 0x40, 0x81, 0x03, 0xE4, 0x50, 0x60, 0xC1, 0x85,
  0x0B, 0xE0, 0x3C, 0x86, 0x0C, 0x08, 0x10, 0x21, 0x3C, 0x02, 0x04, 0x09,
  0xF4, 0x30, 0x61, 0x42, 0x85, 0x09, 0xF0, 0x3C, 0x86, 0x0F, 0xF8, 0x10,
  0x21, 0x3C, 0x1E, 0x40, 0x87, 0xE2, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00,
  0x3E, 0x86, 0x0C, 0x28, 0x50, 0xA1, 0x3E, 0x05, 0x13, 0xC0, 0x40, 0x81,
  0x03, 0xE4, 0x30, 0x60, 0xC2, 0x85, 0x0A, 0x10, 0x08, 0x00, 0x1E, 0x08,
  0x41, 0x04, 0x10, 0x4F, 0xC0, 0x02, 0x00, 0x00, 0xE0, 0x40, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x9E, 0x00, 0x20, 0x81, 0x02, 0x14, 0xCA, 0x18,
  0x28, 0x91, 0x12, 0x10, 0x38, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x4F,
  0xC0, 0x7F, 0x49, 0x49, 0x89, 0x89, 0x89, 0x91, 0x91, 0x7C, 0x86, 0x0C,
  0x18, 0x50, 0xA1, 0x42, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x3C, 0x3E,
  0x22, 0x41, 0x41, 0x41, 0x42, 0x42, 0x7C, 0x80, 0x80, 0x80, 0x3E, 0x86,
  0x0C, 0x28, 0x50, 0xA1, 0x3E, 0x04, 0x10, 0x20, 0x5D, 0x84, 0x10, 0x82,
  0x08, 0x20, 0x3C, 0x85, 0x01, 0x80, 0xC0, 0xA1, 0x3C, 0x20, 0x8F, 0xC8,
  0x21, 0x04, 0x10, 0x41, 0xE0, 0x42, 0x86, 0x0C, 0x18, 0x50, 0xA1, 0x3E,
  0x82, 0x85, 0x12, 0x24, 0x85, 0x0C, 0x10, 0x91, 0x91, 0x92, 0xAA, 0xAC,
  0xCC, 0xC8, 0x88, 0x21, 0x22, 0x14, 0x08, 0x18, 0x24, 0x24, 0xC2, 0x40,
  0xA0, 0x88, 0x84, 0x42, 0x40, 0xA0, 0x60, 0x20, 0x10, 0x10, 0x30, 0x00,
  0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x04, 0x21, 0x04, 0x10,
  0x82, 0x30, 0x40, 0x82, 0x08, 0x20, 0x81, 0x00, 0x25, 0x24, 0x92, 0x52,
  0x48, 0x20, 0x40, 0x82, 0x08, 0x20, 0x81, 0x08, 0x41, 0x04, 0x20, 0x8C,
  0x00, 0x31, 0x49, 0x86,
};

const GFXglyph RobotoMono_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 3, 3, 9, 4, -11 },
  { 8, 9, 11, 9, 0, -11 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 7, 11, 9, 1, -11 },
  { 44, 7, 11, 9, 1, -11 },
  { 54, 1, 3, 9, 4, -11 },
  { 55, 4, 15, 9, 3, -12 },
  { 63, 5, 15, 9, 1, -12 },
  { 73, 6, 6, 9, 2, -11 },
  { 78, 7, 8, 9, 1, -9 },
  { 85, 2, 3, 9, 2, -1 },
  { 86, 5, 1, 9, 2, -5 },
  { 87, 2, 1, 9, 3, -1 },
  { 88, 7, 12, 9, 1, -11 },
  { 99, 7, 11, 9, 1, -11 },
  { 109, 4, 11, 9, 2, -11 },
  { 115, 7, 11, 9, 0, -11 },
  { 125, 8, 11, 9, 0, -11 },
  { 136, 8, 11, 9, 0, -11 },
  { 147, 8, 11, 9, 1, -11 },
  { 158, 6, 11, 9, 1, -11 },
  { 167, 7, 11, 9, 2, -11 },
  { 177, 7, 11, 9, 1, -11 },
  { 187, 7, 11, 9, 1, -11 },
  { 197, 2, 7, 9, 4, -7 },
  { 199, 3, 9, 9, 3, -7 },
  { 203, 7, 6, 9, 1, -8 },
  { 209, 7, 4, 9, 1, -7 },
  { 213, 7, 6, 9, 1, -8 },
  { 219, 6, 11, 9, 2, -11 },
  { 228, 9, 11, 9, 0, -11 },
  { 241, 7, 11, 9, 0, -11 },
  { 251, 7, 11, 9, 1, -11 },
  { 261, 7, 11, 9, 1, -11 },
  { 271, 7, 11, 9, 1, -11 },
  { 281, 8, 11, 9, 1, -11 },
  { 292, 8, 11, 9, 1, -11 },
  { 303, 7, 11, 9, 1, -11 },
  { 313, 9, 11, 9, 0, -11 },
  { 326, 7, 11, 9, 1, -11 },
  { 336, 7, 11, 9, 1, -11 },
  { 346, 8, 11, 9, 1, -11 },
  { 357, 6, 11, 9, 1, -11 },
  { 366, 9, 11, 9, 0, -11 },
  { 379, 9, 11, 9, 0, -11 },
  { 392, 7, 11, 9, 1, -11 },
  { 402, 8, 11, 9, 1, -11 },
  { 413, 7, 13, 9, 1, -11 },
  { 425, 7, 11, 9, 1, -11 },
  { 435, 7, 11, 9, 1, -11 },
  { 445, 7, 11, 9, 2, -11 },
  { 455, 8, 11, 9, 1, -11 },
  { 466, 7, 11, 9, 2, -11 },
  { 476, 7, 11, 9, 2, -11 },
  { 486, 9, 11, 9, 0, -11 },
  { 499, 7, 11, 9, 2, -11 },
  { 509, 8, 11, 9, 0, -11 },
  { 520, 5, 14, 9, 2, -12 },
  { 529, 3, 12, 9, 3, -11 },
  { 534, 5, 14, 9, 2, -12 },
  { 543, 5, 6, 9, 2, -11 },
  { 547, 7, 1, 9, 0, 0 },
  { 548, 2, 2, 9, 4, -11 },
  { 549, 7, 8, 9, 1, -8 },
  { 556, 7, 11, 9, 1, -11 },
  { 566, 7, 8, 9, 1, -8 },
  { 573, 7, 11, 9, 1, -11 },
  { 583, 7, 8, 9, 1, -8 },
  { 590, 7, 11, 9, 2, -11 },
  { 600, 7, 11, 9, 1, -8 },
  { 610, 7, 11, 9, 1, -11 },
  { 620, 6, 11, 9, 1, -11 },
  { 629, 7, 14, 9, 0, -11 },
  { 642, 7, 11, 9, 1, -11 },
  { 652, 6, 11, 9, 1, -11 },
  { 661, 8, 8, 9, 0, -8 },
  { 669, 7, 8, 9, 1, -8 },
  { 676, 7, 8, 9, 1, -8 },
  { 683, 8, 11, 9, 0, -8 },
  { 694, 7, 11, 9, 1, -8 },
  { 704, 6, 8, 9, 2, -8 },
  { 710, 7, 8, 9, 1, -8 },
  { 717, 6, 10, 9, 2, -10 },
  { 725, 7, 8, 9, 1, -8 },
  { 732, 7, 8, 9, 1, -8 },
  { 739, 8, 8, 9, 1, -8 },
  { 747, 8, 8, 9, 0, -8 },
  { 755, 9, 11, 9, 0, -8 },
  { 768, 8, 8, 9, 0, -8 },
  { 776, 6, 15, 9, 2, -12 },
  { 788, 3, 13, 9, 3, -11 },
  { 793, 6, 15, 9, 1, -12 },
  { 805, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC15PT7B_H_
