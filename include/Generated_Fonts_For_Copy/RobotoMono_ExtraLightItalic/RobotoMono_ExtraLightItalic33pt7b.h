#ifndef _ROBOTOMONO_EXTRALIGHTITALIC33PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x31, 0x88, 0x42, 0x31, 0x88, 0x42, 0x11, 0x8C, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x46, 0x8D, 0x12, 0x2C, 0x50, 0xA3, 0x00, 0x00,
  0x30, 0x40, 0x02, 0x0C, 0x00, 0x60, 0x80, 0x04, 0x08, 0x00, 0x41, 0x80,
  0x0C, 0x10, 0x1F, 0xFF, 0xF0, 0x08, 0x20, 0x01, 0x82, 0x00, 0x10, 0x60,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x04, 0x08,
  0x07, 0xFF, 0xF8, 0x8C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x30, 0x01, 0x82,
  0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0xF0, 0x03, 0xFC, 0x06, 0x06, 0x0C, 0x02, 0x18,
  0x03, 0x10, 0x03, 0x10, 0x03, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x0C, 0x60, 0x18, 0x30,
  0x70, 0x1F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x36,
  0x00, 0x61, 0x00, 0x41, 0x06, 0xC1, 0x04, 0x81, 0x08, 0x81, 0x18, 0x83,
  0x10, 0xC2, 0x20, 0x44, 0x60, 0x38, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x3E, 0x04, 0x62, 0x0C, 0x41, 0x08, 0x81, 0x10, 0x81, 0x30,
  0x83, 0x60, 0x82, 0x40, 0x82, 0x00, 0xC4, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0xC3, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20,
  0x08, 0x30, 0x06, 0x30, 0x03, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xD8,
  0x00, 0xC4, 0x00, 0xC3, 0x06, 0x40, 0xC2, 0x60, 0x21, 0x20, 0x19, 0x90,
  0x04, 0x88, 0x03, 0x84, 0x00, 0xC3, 0x00, 0xE0, 0xC1, 0x98, 0x3F, 0x86,
  0x25, 0xA4, 0xB0, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0xE1, 0x0C, 0xE5, 0xE0, 0x7C, 0x00, 0xC0, 0x05, 0x80, 0x23, 0x01, 0x84,
  0x0C, 0x18, 0x60, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x33, 0x32, 0x64, 0xC0, 0xFF, 0xE0, 0xFC, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xFC,
  0x06, 0x04, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20, 0x07,
  0x20, 0x0F, 0x60, 0x13, 0x60, 0x62, 0x40, 0xC2, 0x41, 0x82, 0x43, 0x06,
  0x44, 0x06, 0xD8, 0x06, 0xF0, 0x04, 0xE0, 0x04, 0xC0, 0x0C, 0x40, 0x08,
  0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0x80, 0x03, 0x87, 0x9C, 0x58,
  0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x01, 0xE0,
  0x0F, 0x70, 0x30, 0x30, 0xC0, 0x31, 0x00, 0x26, 0x00, 0x48, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x0E,
  0x06, 0x08, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x18, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0,
  0x08, 0x60, 0x10, 0x30, 0x60, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x34, 0x00, 0x64, 0x00, 0x44, 0x00, 0x8C, 0x01, 0x0C, 0x03,
  0x08, 0x06, 0x08, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x18, 0x30, 0x18, 0x60,
  0x10, 0xC0, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x0F, 0xFF, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x37, 0xC0, 0x3E,
  0xF0, 0x30, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x10, 0x40, 0x20, 0x60,
  0xE0, 0x1F, 0x80, 0x00, 0x1C, 0x03, 0xF0, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x9F, 0xC7, 0xC1, 0x9C, 0x02,
  0x60, 0x0D, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00,
  0xF0, 0x02, 0x40, 0x19, 0x80, 0xC3, 0x06, 0x07, 0xF0, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x06, 0x06, 0x0C,
  0x03, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x18,
  0x06, 0x0C, 0x0C, 0x07, 0xF0, 0x0F, 0xF0, 0x18, 0x18, 0x20, 0x0C, 0x60,
  0x04, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x60,
  0x18, 0x30, 0x70, 0x1F, 0xC0, 0x01, 0xC0, 0x3D, 0xC1, 0x81, 0x8C, 0x03,
  0x20, 0x05, 0x80, 0x14, 0x00, 0x50, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x40, 0x1D, 0x80, 0xF3, 0x06, 0x87, 0xE2, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x06, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x18, 0x30,
  0x41, 0x86, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x10, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x08, 0x00, 0x00, 0x07, 0x81, 0xFE, 0x30, 0x36,
  0x01, 0x40, 0x1C, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0,
  0x30, 0x18, 0x18, 0x02, 0x0C, 0x00, 0xC6, 0x0C, 0x11, 0x0C, 0xC4, 0x84,
  0x11, 0x23, 0x08, 0x50, 0x82, 0x14, 0x60, 0x87, 0x10, 0x61, 0x84, 0x10,
  0xE3, 0x04, 0x28, 0x83, 0x0A, 0x20, 0xC2, 0x88, 0x61, 0x23, 0x3C, 0xC8,
  0x79, 0xE3, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x03, 0x00, 0x3F,
  0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x28, 0x00, 0x28, 0x00, 0x6C, 0x00,
  0x4C, 0x00, 0xC4, 0x00, 0x84, 0x01, 0x84, 0x01, 0x04, 0x03, 0x04, 0x02,
  0x06, 0x06, 0x06, 0x04, 0x02, 0x0C, 0x02, 0x0F, 0xFE, 0x18, 0x02, 0x10,
  0x02, 0x30, 0x03, 0x20, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x1F,
  0xF8, 0x18, 0x0C, 0x10, 0x02, 0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30,
  0x02, 0x30, 0x06, 0x20, 0x04, 0x20, 0x18, 0x3F, 0xF0, 0x3F, 0xF0, 0x60,
  0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0,
  0x0C, 0xC0, 0x08, 0x80, 0x18, 0x80, 0xF0, 0xFF, 0xC0, 0x00, 0xF0, 0x03,
  0xFC, 0x06, 0x06, 0x08, 0x02, 0x18, 0x03, 0x30, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0xC0, 0x04, 0xC0,
  0x0C, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0, 0x0F, 0xF8, 0x04,
  0x07, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x32, 0x00,
  0x19, 0x00, 0x08, 0x80, 0x04, 0x40, 0x06, 0x60, 0x02, 0x30, 0x03, 0x10,
  0x03, 0x08, 0x03, 0x04, 0x03, 0x02, 0x0F, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x8C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0xFC, 0x06, 0x06, 0x08, 0x02, 0x18, 0x03, 0x30, 0x01,
  0x20, 0x01, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0xFE, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04,
  0xC0, 0x04, 0xC0, 0x04, 0x40, 0x04, 0x60, 0x0C, 0x30, 0x38, 0x1F, 0xE0,
  0x08, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0x84,
  0x00, 0x21, 0x00, 0x18, 0x40, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x43, 0xFF,
  0xF0, 0xFF, 0xFC, 0x20, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x04, 0x30,
  0x01, 0x08, 0x00, 0x40, 0x0F, 0xFF, 0x80, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0xC0, 0x04, 0x60, 0x06, 0x30, 0x03, 0x08, 0x03, 0x06,
  0x03, 0x01, 0x83, 0x00, 0x7F, 0x00, 0x08, 0x01, 0xC6, 0x00, 0xC1, 0x80,
  0x60, 0x40, 0x30, 0x10, 0x18, 0x04, 0x0C, 0x01, 0x06, 0x00, 0xC3, 0x00,
  0x31, 0x80, 0x08, 0xC0, 0x02, 0x70, 0x00, 0xB4, 0x00, 0x79, 0x80, 0x1C,
  0x20, 0x06, 0x0C, 0x01, 0x01, 0x00, 0x40, 0x60, 0x10, 0x0C, 0x0C, 0x01,
  0x03, 0x00, 0x60, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x60, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xE0,
  0x0C, 0x00, 0xC3, 0x00, 0x70, 0xE0, 0x1C, 0x78, 0x0F, 0x1A, 0x02, 0x84,
  0x81, 0x21, 0x20, 0xC8, 0x48, 0x22, 0x13, 0x19, 0x8C, 0x44, 0x63, 0x13,
  0x10, 0x84, 0x84, 0x21, 0x61, 0x08, 0x70, 0xC2, 0x18, 0x31, 0x82, 0x08,
  0x60, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18, 0x40, 0x06, 0x30,
  0x01, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08, 0x78,
  0x02, 0x1A, 0x00, 0x84, 0xC0, 0x21, 0x10, 0x18, 0x44, 0x06, 0x31, 0x81,
  0x0C, 0x20, 0x43, 0x08, 0x10, 0x83, 0x04, 0x20, 0x43, 0x08, 0x10, 0xC6,
  0x06, 0x21, 0x80, 0x88, 0x40, 0x32, 0x10, 0x05, 0x84, 0x01, 0x61, 0x00,
  0x78, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xFC,
  0x06, 0x04, 0x08, 0x06, 0x18, 0x02, 0x30, 0x03, 0x20, 0x03, 0x20, 0x01,
  0x60, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x0C, 0xC0, 0x08,
  0x40, 0x18, 0x60, 0x30, 0x30, 0xE0, 0x1F, 0x80, 0x0F, 0xFC, 0x04, 0x03,
  0x86, 0x00, 0x43, 0x00, 0x31, 0x00, 0x18, 0x80, 0x04, 0x40, 0x06, 0x20,
  0x03, 0x30, 0x01, 0x18, 0x01, 0x88, 0x01, 0x84, 0x03, 0x83, 0xFF, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0xFC, 0x0E, 0x06, 0x08, 0x02, 0x10, 0x03, 0x30, 0x01, 0x20, 0x01, 0x60,
  0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0xC0,
  0x0C, 0xC0, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x0F, 0xF8, 0x18, 0x0E, 0x18, 0x02, 0x10,
  0x03, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x03, 0x30, 0x02, 0x20,
  0x06, 0x20, 0x0C, 0x20, 0x38, 0x3F, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x40,
  0x20, 0x40, 0x30, 0x40, 0x10, 0xC0, 0x10, 0xC0, 0x18, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x01, 0x30, 0x01, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x0C, 0x60, 0x18, 0x30,
  0x30, 0x1F, 0xE0, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x60, 0x02, 0x30, 0x01, 0x10, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x62, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08, 0xC0,
  0x04, 0x60, 0x06, 0x30, 0x02, 0x08, 0x03, 0x06, 0x03, 0x01, 0x83, 0x00,
  0x7E, 0x00, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08,
  0x40, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x30, 0x60, 0x20, 0x60, 0x60,
  0x20, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x21, 0x80, 0x31, 0x00, 0x33, 0x00,
  0x12, 0x00, 0x16, 0x00, 0x14, 0x00, 0x14, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x40, 0xC0, 0xD0, 0x30, 0x24, 0x1C, 0x19, 0x05, 0x04, 0x41, 0x41, 0x10,
  0xD0, 0xC4, 0x24, 0x23, 0x09, 0x08, 0xC6, 0x42, 0x31, 0x11, 0x8C, 0x44,
  0x43, 0x31, 0x10, 0xC8, 0x4C, 0x32, 0x12, 0x0D, 0x84, 0x83, 0x41, 0x60,
  0xD0, 0x50, 0x3C, 0x14, 0x0E, 0x05, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x60, 0x04, 0x02, 0x00, 0xC0,
  0x30, 0x18, 0x03, 0x03, 0x00, 0x10, 0x20, 0x01, 0x86, 0x00, 0x08, 0xC0,
  0x00, 0xD8, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xF0,
  0x00, 0x09, 0x00, 0x01, 0x18, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0,
  0xC0, 0x08, 0x04, 0x01, 0x80, 0x60, 0x30, 0x02, 0x06, 0x00, 0x30, 0xC0,
  0x01, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x40, 0x0C, 0x60, 0x08, 0x60, 0x18,
  0x20, 0x30, 0x20, 0x20, 0x30, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x19, 0x00,
  0x0B, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xC1, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0xE0, 0x82, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x60,
  0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x04,
  0x07, 0xC2, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x83, 0xE0, 0x01, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x4C, 0x10,
  0x86, 0x10, 0x82, 0x30, 0x64, 0x0D, 0x80, 0xE0, 0x10, 0xFF, 0xFC, 0xC9,
  0x90, 0x01, 0xE0, 0x1F, 0xF0, 0x60, 0x31, 0x80, 0x22, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x07, 0xFC, 0x38, 0x19, 0x80, 0x32, 0x00, 0x6C,
  0x00, 0x90, 0x01, 0x20, 0x06, 0x60, 0x14, 0x60, 0xD8, 0x7E, 0x30, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0xF0, 0x37, 0xF8, 0x78, 0x18, 0xE0, 0x31, 0x80, 0x22, 0x00, 0x64,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00,
  0x6C, 0x00, 0x98, 0x03, 0x38, 0x0C, 0x58, 0x30, 0x9F, 0xC0, 0x01, 0xC0,
  0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x23, 0x00, 0x64, 0x00, 0xD8, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x48, 0x01,
  0x10, 0x06, 0x30, 0x18, 0x30, 0x60, 0x3F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x03,
  0x84, 0x07, 0xF2, 0x0E, 0x0F, 0x04, 0x03, 0x86, 0x00, 0xC2, 0x00, 0x43,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02,
  0x18, 0x01, 0x0C, 0x00, 0x82, 0x00, 0xC1, 0x80, 0xE0, 0x61, 0xB0, 0x1F,
  0x90, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x23, 0x00, 0x6C,
  0x00, 0x58, 0x00, 0xA0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x0C, 0x30, 0x30, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x03, 0xF9, 0x0E, 0x0D, 0x08, 0x07, 0x18, 0x03,
  0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x60, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x1C, 0x18, 0x7C,
  0x0F, 0xC8, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x40, 0x30, 0xC0, 0x60,
  0x31, 0xC0, 0x1F, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x78, 0x19, 0xFC, 0x12, 0x06,
  0x14, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x04,
  0x40, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0x00, 0x20, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x1F, 0xFF, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x01,
  0x10, 0x06, 0x10, 0x1C, 0x10, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x23, 0x80,
  0x26, 0x00, 0x2E, 0x00, 0x7B, 0x00, 0x61, 0x00, 0x61, 0x80, 0x40, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0x0F, 0xF0,
  0x7F, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0xFF, 0xF8, 0x03, 0x83, 0x02, 0xF9, 0xF8, 0xE1, 0xC1, 0x18, 0x10,
  0x32, 0x02, 0x04, 0x40, 0xC0, 0x88, 0x18, 0x11, 0x02, 0x02, 0x60, 0x40,
  0x48, 0x08, 0x19, 0x01, 0x03, 0x20, 0x60, 0x44, 0x0C, 0x09, 0x81, 0x01,
  0x30, 0x20, 0x64, 0x04, 0x0C, 0x80, 0x81, 0x10, 0x30, 0x20, 0x00, 0x78,
  0x19, 0xFC, 0x12, 0x06, 0x14, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03,
  0x30, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0x01, 0xC0,
  0x0F, 0xF0, 0x60, 0x31, 0x80, 0x22, 0x00, 0x6C, 0x00, 0xD0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x58, 0x01,
  0xB0, 0x06, 0x30, 0x18, 0x30, 0x60, 0x3F, 0x80, 0x00, 0x78, 0x06, 0xFF,
  0x03, 0xC0, 0x81, 0xC0, 0x60, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x06, 0x30,
  0x03, 0x18, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x61, 0x00, 0x31,
  0x80, 0x10, 0xC0, 0x18, 0x70, 0x18, 0x2C, 0x18, 0x13, 0xF8, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x0F, 0xE4, 0x70, 0x28, 0x80, 0x73, 0x00, 0x64,
  0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x05, 0x80, 0x1B, 0x00, 0x36, 0x00,
  0x4C, 0x00, 0x98, 0x01, 0x10, 0x06, 0x30, 0x1C, 0x30, 0xD8, 0x3F, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x08, 0x3C, 0x47, 0xF1, 0x30, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0xF0, 0x60, 0x30, 0x80, 0x33, 0x00, 0x26, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x20, 0x0C, 0x70, 0x30, 0x3F, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x07, 0xE0, 0x60, 0x05, 0x80, 0x14, 0x00,
  0x50, 0x03, 0x40, 0x0D, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0x80, 0x1A, 0x00,
  0x68, 0x01, 0xA0, 0x04, 0x80, 0x12, 0x00, 0xCC, 0x05, 0x18, 0x6C, 0x3F,
  0x30, 0xC0, 0x03, 0xC0, 0x06, 0x40, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x20,
  0x10, 0x20, 0x30, 0x20, 0x20, 0x30, 0x60, 0x10, 0x40, 0x10, 0x80, 0x11,
  0x80, 0x19, 0x00, 0x0B, 0x00, 0x0A, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xC0,
  0xC0, 0xD0, 0x30, 0x24, 0x14, 0x19, 0x05, 0x04, 0x43, 0x43, 0x10, 0x90,
  0x84, 0x24, 0x21, 0x11, 0x18, 0x44, 0x44, 0x13, 0x11, 0x04, 0x84, 0x81,
  0x21, 0x20, 0x50, 0x58, 0x14, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x00, 0x18, 0x01, 0x86, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x80, 0x21,
  0x80, 0x19, 0x80, 0x07, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00,
  0x98, 0x00, 0xC6, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0xC0, 0x18,
  0xC0, 0x06, 0x00, 0x08, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x40,
  0x0C, 0x04, 0x00, 0x80, 0x60, 0x18, 0x02, 0x03, 0x00, 0x20, 0x20, 0x03,
  0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x11, 0x80, 0x01, 0x90, 0x00,
  0x0B, 0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x42,
  0x11, 0x88, 0x42, 0x10, 0x8C, 0x62, 0x10, 0x84, 0x23, 0x10, 0x84, 0x21,
  0x18, 0x84, 0x21, 0x00, 0x04, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x0F, 0xC0, 0x36, 0x18, 0x0B, 0x03, 0x06, 0x80, 0x63, 0x20, 0x0F, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 7, 7, 19, 8, -25 },
  { 23, 20, 23, 19, 0, -23 },
  { 81, 16, 30, 19, 2, -27 },
  { 141, 16, 24, 19, 2, -24 },
  { 189, 17, 24, 19, 1, -24 },
  { 240, 3, 7, 19, 9, -25 },
  { 243, 10, 34, 19, 6, -26 },
  { 286, 10, 34, 19, 3, -26 },
  { 329, 14, 13, 19, 4, -23 },
  { 352, 16, 17, 19, 2, -19 },
  { 386, 4, 7, 19, 4, -3 },
  { 390, 11, 1, 19, 4, -11 },
  { 392, 3, 2, 19, 7, -2 },
  { 393, 15, 25, 19, 3, -23 },
  { 440, 16, 24, 19, 2, -24 },
  { 488, 9, 23, 19, 5, -23 },
  { 514, 15, 24, 19, 1, -24 },
  { 559, 16, 24, 19, 1, -24 },
  { 607, 16, 23, 19, 1, -23 },
  { 653, 16, 23, 19, 3, -23 },
  { 699, 14, 24, 19, 2, -24 },
  { 741, 15, 23, 19, 4, -23 },
  { 785, 16, 24, 19, 2, -24 },
  { 833, 14, 24, 19, 3, -24 },
  { 875, 5, 16, 19, 8, -16 },
  { 885, 7, 20, 19, 6, -16 },
  { 903, 14, 13, 19, 3, -17 },
  { 926, 16, 8, 19, 2, -15 },
  { 942, 15, 13, 19, 2, -17 },
  { 967, 12, 24, 19, 5, -24 },
  { 1003, 18, 24, 19, 1, -24 },
  { 1057, 16, 23, 19, 0, -23 },
  { 1103, 16, 23, 19, 2, -23 },
  { 1149, 16, 24, 19, 2, -24 },
  { 1197, 17, 23, 19, 1, -23 },
  { 1246, 17, 23, 19, 2, -23 },
  { 1295, 17, 23, 19, 2, -23 },
  { 1344, 16, 24, 19, 2, -24 },
  { 1392, 18, 23, 19, 1, -23 },
  { 1444, 17, 23, 19, 1, -23 },
  { 1493, 17, 23, 19, 1, -23 },
  { 1542, 18, 23, 19, 2, -23 },
  { 1594, 13, 23, 19, 2, -23 },
  { 1632, 18, 23, 19, 1, -23 },
  { 1684, 18, 23, 19, 1, -23 },
  { 1736, 16, 24, 19, 2, -24 },
  { 1784, 17, 23, 19, 2, -23 },
  { 1833, 16, 28, 19, 2, -24 },
  { 1889, 16, 23, 19, 2, -23 },
  { 1935, 16, 24, 19, 2, -24 },
  { 1983, 16, 23, 19, 4, -23 },
  { 2029, 17, 23, 19, 2, -23 },
  { 2078, 16, 23, 19, 4, -23 },
  { 2124, 18, 23, 19, 3, -23 },
  { 2176, 20, 23, 19, 0, -23 },
  { 2234, 16, 23, 19, 4, -23 },
  { 2280, 17, 23, 19, 1, -23 },
  { 2329, 10, 32, 19, 5, -27 },
  { 2369, 6, 25, 19, 7, -23 },
  { 2388, 10, 32, 19, 5, -27 },
  { 2428, 11, 12, 19, 4, -23 },
  { 2445, 14, 1, 19, 1, 0 },
  { 2447, 3, 4, 19, 10, -24 },
  { 2449, 15, 18, 19, 2, -18 },
  { 2483, 15, 25, 19, 2, -25 },
  { 2530, 15, 18, 19, 2, -18 },
  { 2564, 17, 25, 19, 2, -25 },
  { 2618, 15, 18, 19, 2, -18 },
  { 2652, 16, 25, 19, 4, -25 },
  { 2702, 16, 25, 19, 1, -18 },
  { 2752, 16, 25, 19, 1, -25 },
  { 2802, 13, 24, 19, 2, -24 },
  { 2841, 15, 31, 19, 0, -24 },
  { 2900, 16, 25, 19, 2, -25 },
  { 2950, 13, 25, 19, 2, -25 },
  { 2991, 19, 18, 19, 0, -18 },
  { 3034, 16, 18, 19, 1, -18 },
  { 3070, 15, 18, 19, 2, -18 },
  { 3104, 17, 25, 19, 0, -18 },
  { 3158, 15, 25, 19, 2, -18 },
  { 3205, 14, 18, 19, 4, -18 },
  { 3237, 15, 18, 19, 2, -18 },
  { 3271, 13, 22, 19, 4, -22 },
  { 3307, 14, 17, 19, 3, -17 },
  { 3337, 16, 17, 19, 3, -17 },
  { 3371, 18, 17, 19, 2, -17 },
  { 3410, 17, 17, 19, 1, -17 },
  { 3447, 20, 24, 19, -1, -17 },
  { 3507, 17, 17, 19, 1, -17 },
  { 3544, 13, 33, 19, 5, -26 },
  { 3598, 5, 28, 19, 7, -23 },
  { 3616, 13, 33, 19, 3, -26 },
  { 3670, 18, 6, 19, 1, -13 },
};

const GFXfont RobotoMono_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC33PT7B_H_
