#ifndef _ROBOTOMONO_EXTRALIGHTITALIC50PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x3C, 0x1C, 0x00, 0x30, 0xCC, 0x36, 0x0D, 0x83, 0x60,
  0xD8, 0x26, 0x19, 0x06, 0xC1, 0xB0, 0x6C, 0x10, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x01, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x0F, 0x9F, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x30, 0x08, 0x60, 0x30, 0x0C, 0x40, 0x30, 0x18, 0xC0, 0x30,
  0x18, 0xC0, 0x30, 0x30, 0xC0, 0x30, 0x60, 0xC0, 0x30, 0xE0, 0xC0, 0x60,
  0xC0, 0xC0, 0x61, 0x80, 0x60, 0xC3, 0x00, 0x7F, 0x83, 0x00, 0x3F, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x61, 0xFC, 0x00, 0xC3, 0x86, 0x01, 0x83,
  0x03, 0x01, 0x86, 0x03, 0x03, 0x06, 0x03, 0x06, 0x0C, 0x03, 0x06, 0x0C,
  0x03, 0x0C, 0x0C, 0x03, 0x18, 0x0C, 0x03, 0x38, 0x0C, 0x06, 0x30, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x38, 0x00, 0x18, 0x38, 0x00, 0x06, 0x38, 0x00,
  0x03, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE0, 0xC0, 0x18, 0xE0, 0x60,
  0x0C, 0x60, 0x18, 0x0C, 0x60, 0x0E, 0x06, 0x70, 0x03, 0x03, 0x30, 0x00,
  0xC3, 0x18, 0x00, 0x71, 0x8C, 0x00, 0x19, 0x8E, 0x00, 0x07, 0xC3, 0x00,
  0x03, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xF0, 0x70, 0x01, 0xD8, 0x1C,
  0x01, 0xC6, 0x07, 0xCF, 0xC3, 0x80, 0xFF, 0x80, 0xE0, 0x33, 0x33, 0x36,
  0x66, 0x64, 0x40, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x04, 0x07,
  0xF8, 0x60, 0xFB, 0xF3, 0x3F, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00,
  0xE0, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x06, 0x02, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x0C, 0x63, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x70,
  0x01, 0x81, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x79, 0x80, 0x01, 0xF7, 0x00, 0x06,
  0x6C, 0x00, 0x18, 0xD8, 0x00, 0xE3, 0xB0, 0x03, 0x86, 0x60, 0x0E, 0x0C,
  0xC0, 0x38, 0x1B, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x6C, 0x1C, 0x01, 0x98,
  0x70, 0x03, 0x31, 0xC0, 0x06, 0x66, 0x00, 0x0C, 0xD8, 0x00, 0x19, 0xE0,
  0x00, 0x63, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x79, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7C,
  0x0F, 0xE1, 0xE3, 0x7C, 0x1B, 0x80, 0xD0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xF0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x03, 0xE7, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x87, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x70, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x37, 0xFE, 0x00, 0x1F, 0xCF, 0x80, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x07, 0xCF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x61, 0xFE, 0x03, 0x1F, 0xFC, 0x0D, 0xC0, 0x38, 0x3E, 0x00, 0x71, 0xE0,
  0x00, 0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x0E, 0xE0, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00,
  0x06, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x70, 0x18, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x01, 0xE1, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x07, 0xE7, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x01, 0xE0, 0x78, 0x1C, 0x00, 0xC1, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xE0,
  0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x01, 0xE3,
  0x00, 0x1B, 0x1C, 0x03, 0x98, 0x7D, 0xF9, 0x80, 0xFF, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x70, 0xF0, 0x70, 0x00, 0xC0, 0x3C, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xE0, 0x70,
  0xE0, 0x06, 0x30, 0x01, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x03,
  0x80, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x03, 0x06, 0x03, 0xF0, 0x30, 0xC0, 0xF3,
  0x83, 0x0C, 0x1C, 0x08, 0x31, 0x81, 0x81, 0x83, 0x18, 0x30, 0x18, 0x33,
  0x06, 0x01, 0x03, 0x30, 0x60, 0x10, 0x33, 0x04, 0x03, 0x03, 0x60, 0xC0,
  0x30, 0x36, 0x0C, 0x02, 0x02, 0x60, 0x80, 0x60, 0x24, 0x18, 0x06, 0x06,
  0x41, 0x80, 0x60, 0x6C, 0x18, 0x0C, 0x04, 0xC1, 0x80, 0xC0, 0xCC, 0x18,
  0x1C, 0x0C, 0xC1, 0x81, 0xC1, 0x8C, 0x18, 0x3C, 0x18, 0xC1, 0x86, 0xC3,
  0x0C, 0x0F, 0xC7, 0xE0, 0x60, 0x70, 0x38, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x0C,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x70, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xC0, 0x3F, 0x00, 0x60,
  0x01, 0xC0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x70, 0x0C, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x30, 0x01, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0x60, 0x38, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x30, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x30, 0x0F, 0x80,
  0x0C, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x60, 0x03,
  0xC0, 0x30, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x38,
  0x00, 0x60, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x01, 0xFF,
  0xCC, 0x00, 0xFF, 0xE6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x8E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x03, 0xE7, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x9F, 0x00, 0x00, 0x1B, 0xB0, 0x00,
  0x03, 0x73, 0x80, 0x00, 0x3E, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0D,
  0x00, 0x0F, 0x81, 0xB0, 0x01, 0xB0, 0x36, 0x00, 0x76, 0x0C, 0xC0, 0x0C,
  0xC1, 0x98, 0x03, 0x18, 0x33, 0x00, 0x66, 0x06, 0x30, 0x18, 0xC0, 0xC6,
  0x07, 0x18, 0x18, 0xC0, 0xC3, 0x06, 0x18, 0x38, 0x60, 0xC3, 0x06, 0x1C,
  0x18, 0x31, 0x83, 0x03, 0x06, 0x30, 0x60, 0x60, 0xCC, 0x0C, 0x1C, 0x19,
  0x81, 0x83, 0x03, 0x60, 0x30, 0x60, 0x3C, 0x0C, 0x0C, 0x07, 0x01, 0x81,
  0x80, 0xE0, 0x30, 0x30, 0x18, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00,
  0x0C, 0x0F, 0x00, 0x01, 0x81, 0xB0, 0x00, 0x30, 0x66, 0x00, 0x0E, 0x0C,
  0x60, 0x01, 0x81, 0x8C, 0x00, 0x30, 0x31, 0x80, 0x06, 0x06, 0x18, 0x00,
  0xC0, 0xC3, 0x00, 0x18, 0x30, 0x60, 0x06, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0xC0, 0x18, 0x18, 0x1C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x60, 0x30, 0x0C,
  0x18, 0x03, 0x03, 0x03, 0x00, 0x60, 0x60, 0x60, 0x0C, 0x0C, 0x0C, 0x00,
  0xC1, 0x81, 0x80, 0x18, 0x30, 0x70, 0x03, 0x0E, 0x0C, 0x00, 0x31, 0x81,
  0x80, 0x06, 0x30, 0x30, 0x00, 0xE6, 0x06, 0x00, 0x0C, 0xC0, 0xC0, 0x01,
  0x98, 0x38, 0x00, 0x1F, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x78, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x0C, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x1C, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x03, 0xE0, 0x0C, 0x00, 0x3C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x07,
  0x06, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x07, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0x87, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x30,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x0F, 0x00, 0x70, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x03,
  0x80, 0x30, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x70, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F,
  0x00, 0x70, 0x06, 0xC0, 0x1C, 0x01, 0xB0, 0x05, 0x00, 0x6C, 0x03, 0x40,
  0x33, 0x00, 0xD0, 0x0C, 0xC0, 0x34, 0x03, 0x30, 0x19, 0x01, 0x8C, 0x06,
  0x60, 0x63, 0x01, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x83, 0x0C,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x86,
  0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0x60, 0x63, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0x98, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x06, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x03, 0x0C, 0x01, 0x86, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xE0, 0x30, 0x60, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x30, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x30, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0x63, 0x0C, 0x60, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x18,
  0x70, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xF0, 0x01, 0x8E, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x03, 0xCC, 0x00,
  0x1F, 0x38, 0x00, 0xFC, 0x70, 0x0F, 0x70, 0xFB, 0xF1, 0xC1, 0xFF, 0x07,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x7E, 0x00, 0x63, 0xFF, 0x00, 0xDE, 0x0F, 0x01, 0xF0, 0x06, 0x07, 0x80,
  0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x70,
  0x00, 0x30, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0x83, 0x70, 0x1E, 0x06, 0x7D,
  0xF8, 0x1C, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x0E, 0x60, 0x00, 0x31, 0x80, 0x01, 0xC3, 0x00, 0x06, 0x0E,
  0x00, 0x30, 0x1C, 0x03, 0x80, 0x3E, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x07, 0xE0, 0xC0, 0x0F, 0xFC, 0x60, 0x1E, 0x07, 0x30, 0x1C, 0x01, 0xF8,
  0x1C, 0x00, 0x78, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x38, 0x00, 0x70, 0x0C,
  0x00, 0x78, 0x03, 0x00, 0xEC, 0x01, 0xFB, 0xE6, 0x00, 0x3F, 0xC3, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xC0,
  0x70, 0x01, 0x81, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x77, 0xFF,
  0xFF, 0xCC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x1C, 0x00, 0x38, 0x1C, 0x01, 0xC0,
  0x1F, 0x9F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE3, 0x01, 0xE0, 0x73, 0x03, 0xC0, 0x3B,
  0x07, 0x00, 0x1F, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x38, 0x38, 0x00, 0x70, 0x18, 0x00, 0xF0,
  0x0C, 0x03, 0xB0, 0x0F, 0xDF, 0x30, 0x03, 0xFC, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x3F, 0x00, 0x61, 0xFF, 0x80, 0xCF, 0x07, 0x83, 0x38,
  0x03, 0x06, 0xC0, 0x07, 0x0F, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x01, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x08, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x01, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x78, 0x0C, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x0C, 0x03, 0x80,
  0x1C, 0x0F, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x18, 0x70, 0x00,
  0x19, 0xE0, 0x00, 0x1B, 0xE0, 0x00, 0x3F, 0x60, 0x00, 0x3E, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x30, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x07, 0x80, 0xDF, 0xE1, 0xFE, 0x0F, 0x87, 0x30, 0x60, 0xA0, 0x36,
  0x03, 0x1C, 0x03, 0xC0, 0x31, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x80, 0x31,
  0x80, 0x30, 0x03, 0x18, 0x03, 0x00, 0x31, 0x80, 0x30, 0x03, 0x30, 0x03,
  0x00, 0x63, 0x00, 0x30, 0x06, 0x30, 0x07, 0x00, 0x63, 0x00, 0x60, 0x06,
  0x30, 0x06, 0x00, 0x63, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0xC6, 0x00,
  0x60, 0x0C, 0x60, 0x0C, 0x00, 0xC6, 0x00, 0xC0, 0x0C, 0x60, 0x0C, 0x00,
  0xCC, 0x00, 0xC0, 0x08, 0xC0, 0x0C, 0x01, 0x8C, 0x00, 0xC0, 0x18, 0xC0,
  0x18, 0x01, 0x8C, 0x01, 0x80, 0x18, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x07,
  0xE0, 0x0C, 0x3F, 0xE0, 0x31, 0xE0, 0xF0, 0x67, 0x00, 0x60, 0xD8, 0x00,
  0xE1, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3,
  0x00, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0x03,
  0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x18, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0x3F, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0x1F, 0xF8, 0x03, 0x78, 0x3C, 0x06, 0xE0,
  0x0C, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x07, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x3C, 0x00,
  0x70, 0x36, 0x01, 0xE0, 0x33, 0xEF, 0xC0, 0x71, 0xFF, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x8C, 0x0F, 0x03,
  0x98, 0x3C, 0x03, 0xB0, 0xE0, 0x03, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0xF0, 0x18, 0x07, 0x60, 0x3E, 0x7C, 0xC0, 0x1F, 0xE1, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x30, 0xFF, 0xC1, 0x8F, 0x82, 0x19,
  0xE0, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x38,
  0x00, 0xE0, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xCE,
  0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x38,
  0x01, 0xE0, 0x3F, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x38,
  0x01, 0xFF, 0x00, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x98,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38,
  0xC0, 0x00, 0xE3, 0x80, 0x07, 0x86, 0x00, 0x3C, 0x1C, 0x03, 0xB0, 0x3E,
  0xFC, 0xC0, 0x7F, 0xC3, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x01, 0xF0, 0x07, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x00, 0xF0, 0x0C,
  0xC0, 0x3C, 0x03, 0x30, 0x1B, 0x00, 0xCC, 0x06, 0xC0, 0x63, 0x01, 0xB0,
  0x18, 0xC0, 0xCC, 0x0C, 0x30, 0x33, 0x03, 0x0C, 0x18, 0x40, 0xC3, 0x06,
  0x10, 0x60, 0xC1, 0x04, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x30, 0x63, 0x03,
  0x18, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x13, 0x01, 0x98, 0x04, 0xC0, 0x66,
  0x01, 0x20, 0x1B, 0x00, 0x58, 0x06, 0xC0, 0x16, 0x01, 0xE0, 0x07, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x38,
  0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0xC0,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0xE0, 0xE0, 0x01, 0x98,
  0x0E, 0x00, 0x66, 0x00, 0xE0, 0x0C, 0xC0, 0x0F, 0x07, 0x30, 0x00, 0x7F,
  0xC6, 0x00, 0x07, 0xF0,
};

const GFXglyph RobotoMono_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 36, 29, 10, -36 },
  { 42, 10, 11, 29, 12, -38 },
  { 56, 29, 36, 29, 1, -36 },
  { 187, 24, 46, 29, 3, -41 },
  { 325, 24, 37, 29, 3, -36 },
  { 436, 25, 36, 29, 2, -36 },
  { 549, 4, 11, 29, 14, -38 },
  { 555, 15, 51, 29, 9, -40 },
  { 651, 15, 51, 29, 5, -40 },
  { 747, 21, 21, 29, 7, -36 },
  { 803, 24, 25, 29, 3, -29 },
  { 878, 6, 11, 29, 6, -4 },
  { 887, 17, 2, 29, 6, -17 },
  { 892, 4, 4, 29, 11, -4 },
  { 894, 23, 39, 29, 4, -36 },
  { 1007, 23, 36, 29, 4, -36 },
  { 1111, 13, 36, 29, 8, -36 },
  { 1170, 24, 36, 29, 1, -36 },
  { 1278, 25, 36, 29, 1, -36 },
  { 1391, 25, 36, 29, 1, -36 },
  { 1504, 25, 37, 29, 4, -36 },
  { 1620, 22, 37, 29, 3, -36 },
  { 1722, 23, 36, 29, 6, -36 },
  { 1826, 25, 36, 29, 3, -36 },
  { 1939, 21, 36, 29, 5, -36 },
  { 2034, 8, 25, 29, 12, -25 },
  { 2059, 11, 32, 29, 9, -25 },
  { 2103, 22, 20, 29, 4, -26 },
  { 2158, 24, 12, 29, 3, -22 },
  { 2194, 22, 20, 29, 3, -26 },
  { 2249, 18, 36, 29, 8, -36 },
  { 2330, 28, 36, 29, 1, -36 },
  { 2456, 25, 36, 29, 0, -36 },
  { 2569, 25, 36, 29, 2, -36 },
  { 2682, 25, 37, 29, 3, -36 },
  { 2798, 26, 36, 29, 2, -36 },
  { 2915, 27, 36, 29, 2, -36 },
  { 3037, 26, 36, 29, 3, -36 },
  { 3154, 25, 37, 29, 3, -36 },
  { 3270, 28, 36, 29, 1, -36 },
  { 3396, 26, 36, 29, 2, -36 },
  { 3513, 26, 36, 29, 2, -36 },
  { 3630, 28, 36, 29, 3, -36 },
  { 3756, 20, 36, 29, 3, -36 },
  { 3846, 27, 36, 29, 2, -36 },
  { 3968, 27, 36, 29, 2, -36 },
  { 4090, 24, 36, 29, 3, -36 },
  { 4198, 26, 36, 29, 3, -36 },
  { 4315, 25, 42, 29, 3, -36 },
  { 4447, 25, 36, 29, 3, -36 },
  { 4560, 25, 36, 29, 3, -36 },
  { 4673, 24, 36, 29, 6, -36 },
  { 4781, 26, 36, 29, 3, -36 },
  { 4898, 24, 36, 29, 6, -36 },
  { 5006, 26, 36, 29, 5, -36 },
  { 5123, 30, 36, 29, 0, -36 },
  { 5258, 24, 36, 29, 6, -36 },
  { 5366, 26, 36, 29, 1, -36 },
  { 5483, 15, 49, 29, 8, -41 },
  { 5575, 10, 39, 29, 10, -36 },
  { 5624, 15, 49, 29, 7, -41 },
  { 5716, 17, 20, 29, 6, -36 },
  { 5759, 21, 2, 29, 1, 0 },
  { 5765, 5, 7, 29, 15, -37 },
  { 5770, 22, 28, 29, 3, -27 },
  { 5847, 23, 39, 29, 2, -38 },
  { 5960, 22, 28, 29, 3, -27 },
  { 6037, 25, 38, 29, 3, -38 },
  { 6156, 23, 27, 29, 3, -27 },
  { 6234, 24, 38, 29, 6, -38 },
  { 6348, 24, 38, 29, 2, -27 },
  { 6462, 23, 38, 29, 2, -38 },
  { 6572, 20, 36, 29, 3, -36 },
  { 6662, 23, 47, 29, 0, -36 },
  { 6798, 24, 38, 29, 3, -38 },
  { 6912, 20, 38, 29, 3, -38 },
  { 7007, 28, 27, 29, 0, -27 },
  { 7102, 23, 27, 29, 2, -27 },
  { 7180, 23, 28, 29, 3, -27 },
  { 7261, 24, 37, 29, 1, -27 },
  { 7372, 23, 37, 29, 3, -27 },
  { 7479, 21, 27, 29, 6, -27 },
  { 7550, 23, 27, 29, 3, -27 },
  { 7628, 19, 34, 29, 6, -33 },
  { 7709, 22, 26, 29, 4, -26 },
  { 7781, 24, 26, 29, 4, -26 },
  { 7859, 26, 26, 29, 4, -26 },
  { 7944, 27, 26, 29, 1, -26 },
  { 8032, 30, 37, 29, -1, -26 },
  { 8171, 26, 26, 29, 1, -26 },
  { 8256, 19, 49, 29, 8, -39 },
  { 8373, 9, 43, 29, 10, -36 },
  { 8422, 20, 49, 29, 4, -39 },
  { 8545, 27, 8, 29, 1, -19 },
};

const GFXfont RobotoMono_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC50PT7B_H_
