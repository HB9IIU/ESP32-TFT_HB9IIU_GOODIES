#ifndef _ROBOTOMONO_EXTRALIGHTITALIC44PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x41,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x1C, 0x38, 0x00, 0x61, 0xB0, 0x90, 0x48, 0x6C, 0x36, 0x1B,
  0x09, 0x04, 0x86, 0x00, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x0F, 0xFF, 0xFF, 0xC0,
  0x18, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00,
  0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x20, 0x00, 0x20, 0x30, 0x47, 0xFF, 0xFF,
  0xC0, 0x18, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0x03, 0x80,
  0x70, 0x0E, 0x06, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x03, 0x81, 0x80, 0x38, 0x07, 0x8F,
  0x80, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80,
  0x04, 0x04, 0x02, 0x60, 0x20, 0x33, 0x01, 0x03, 0x18, 0x08, 0x10, 0x80,
  0xC1, 0x84, 0x06, 0x18, 0x20, 0x21, 0x81, 0x83, 0x0C, 0x0C, 0x30, 0xC0,
  0x3F, 0x0C, 0x00, 0x60, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0xF0, 0x03, 0x0F, 0xE0, 0x30, 0xC3, 0x01, 0x8C, 0x0C,
  0x18, 0x60, 0x61, 0x82, 0x03, 0x08, 0x30, 0x18, 0xC1, 0x80, 0xCC, 0x0C,
  0x04, 0xC0, 0x60, 0x62, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x63, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x18, 0x00, 0x60,
  0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x30,
  0x02, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC3, 0x00, 0x01,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x60,
  0x00, 0x39, 0x80, 0x01, 0xC3, 0x00, 0xCE, 0x06, 0x02, 0x30, 0x18, 0x19,
  0x80, 0x30, 0x66, 0x00, 0xE1, 0xB0, 0x01, 0x8C, 0xC0, 0x03, 0x73, 0x00,
  0x0D, 0x8C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x60, 0x03, 0xC1, 0xC0, 0x39,
  0x83, 0xC3, 0xC3, 0x03, 0xFC, 0x0E, 0x6D, 0xA5, 0xB6, 0x80, 0x00, 0x08,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x20, 0x10, 0x1E, 0x04, 0x1D, 0xF3, 0x3E, 0x0F, 0xFC, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x81, 0x80,
  0xC0, 0x30, 0x60, 0x0E, 0x08, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x61, 0x86, 0x18,
  0xC3, 0x18, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x70,
  0x06, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00,
  0x02, 0x18, 0x00, 0x11, 0x80, 0x03, 0xCC, 0x00, 0x3E, 0x60, 0x03, 0x22,
  0x00, 0x31, 0x30, 0x03, 0x19, 0x80, 0x30, 0xCC, 0x07, 0x06, 0x60, 0x60,
  0x33, 0x06, 0x01, 0x90, 0x60, 0x09, 0x86, 0x00, 0xCC, 0xE0, 0x06, 0x6E,
  0x00, 0x33, 0xC0, 0x01, 0x9C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x18, 0x07, 0x00, 0x71,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x3C, 0x3D, 0x9E, 0x3F, 0x05, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x38, 0x06, 0x00, 0xE0, 0x60, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xFE, 0x00, 0x78, 0x38, 0x07, 0x00, 0x60, 0x70, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0x87, 0x00, 0x18, 0x1C, 0x03, 0x80, 0x78, 0x78, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x03,
  0x30, 0x00, 0x1C, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60,
  0x00, 0xC1, 0x80, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0xC0, 0xC0, 0x06,
  0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x31, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0x03, 0x80, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC0,
  0xC0, 0x0C, 0x07, 0x00, 0xE0, 0x1E, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x08, 0x03, 0x1F, 0xE0, 0xCF, 0x0E, 0x1B, 0x00, 0x63, 0xC0,
  0x0E, 0x70, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x33, 0x00, 0x06, 0x30, 0x01, 0x86, 0x00, 0x70, 0x60, 0x1C, 0x07, 0x0F,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFE, 0x00, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x60, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x07, 0x00, 0x60, 0x1C, 0x0E,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x70, 0x1C, 0x06, 0x00, 0x30, 0x60,
  0x01, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00,
  0x18, 0x38, 0x03, 0x80, 0xF8, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xC1, 0xC0, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x07, 0x60,
  0x01, 0xCC, 0x00, 0x78, 0xC0, 0x1B, 0x0C, 0x0E, 0x60, 0xFF, 0x88, 0x0F,
  0x83, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x0C, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x00, 0x01, 0x80, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x18, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x1C, 0x0E, 0x38, 0x06, 0x70, 0x03,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x1E, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x18, 0x0F, 0x02, 0x0C, 0x1F, 0xC1, 0x0C, 0x18,
  0x30, 0x86, 0x18, 0x10, 0x46, 0x08, 0x08, 0x23, 0x0C, 0x0C, 0x11, 0x04,
  0x06, 0x09, 0x86, 0x02, 0x04, 0xC3, 0x01, 0x02, 0x41, 0x01, 0x83, 0x61,
  0x80, 0x81, 0xB0, 0xC0, 0x40, 0x98, 0x60, 0x60, 0x4C, 0x20, 0x30, 0x66,
  0x10, 0x38, 0x23, 0x0C, 0x3C, 0x31, 0x86, 0x36, 0x30, 0xC1, 0xF1, 0xF0,
  0x20, 0x70, 0x70, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00,
  0x41, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xC0,
  0x01, 0x03, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0x80, 0x18, 0x0F, 0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x04,
  0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0xE0,
  0x60, 0x0F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x10, 0x01, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86,
  0x00, 0x0E, 0x10, 0x00, 0x70, 0xC0, 0x07, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x38, 0x06, 0x00,
  0xC0, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x18, 0x07, 0x00, 0x70, 0xF0, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x18, 0x1F, 0x00, 0x40, 0x0E, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x83, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x00,
  0x07, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0, 0x1E, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x0E, 0x07,
  0x00, 0x60, 0x0E, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x7F, 0xE6, 0x01, 0xFF, 0x90, 0x00, 0x06, 0x40,
  0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x70, 0x07, 0x00, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x18, 0x00, 0x08, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x10, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00,
  0x38, 0x18, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xF1, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x03, 0x83, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x07, 0x00, 0x20, 0x07, 0x00, 0x30, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x03, 0x07, 0x00, 0x01,
  0x07, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x67, 0x80, 0x00,
  0x37, 0xC0, 0x00, 0x1E, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xB0,
  0x34, 0x00, 0xD8, 0x13, 0x00, 0xC8, 0x09, 0x80, 0x64, 0x0C, 0xC0, 0x66,
  0x06, 0x60, 0x33, 0x03, 0x10, 0x31, 0x81, 0x88, 0x30, 0xC0, 0x86, 0x18,
  0x40, 0xC3, 0x18, 0x60, 0x61, 0x8C, 0x30, 0x30, 0x4C, 0x18, 0x18, 0x26,
  0x0C, 0x0C, 0x1E, 0x06, 0x04, 0x0F, 0x02, 0x06, 0x07, 0x03, 0x03, 0x03,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x07, 0x80, 0x03, 0x07, 0x80, 0x03, 0x07, 0x80, 0x02,
  0x06, 0xC0, 0x06, 0x04, 0xC0, 0x06, 0x0C, 0x40, 0x06, 0x0C, 0x60, 0x06,
  0x0C, 0x60, 0x06, 0x0C, 0x20, 0x04, 0x0C, 0x30, 0x0C, 0x08, 0x30, 0x0C,
  0x18, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x08,
  0x10, 0x0C, 0x18, 0x30, 0x04, 0x18, 0x30, 0x06, 0x18, 0x30, 0x06, 0x18,
  0x30, 0x02, 0x18, 0x30, 0x03, 0x10, 0x20, 0x03, 0x30, 0x60, 0x01, 0xB0,
  0x60, 0x01, 0xB0, 0x60, 0x01, 0xB0, 0x60, 0x00, 0xF0, 0x60, 0x00, 0xE0,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00,
  0x70, 0x70, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x02,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00,
  0x03, 0x40, 0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x18, 0x07,
  0x00, 0x71, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x18, 0x07, 0x80,
  0xC0, 0x03, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x40, 0x00, 0xC3, 0x00, 0x06, 0x0C,
  0x00, 0x70, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0x83, 0x80, 0x1C, 0x01, 0x80, 0x70, 0x01, 0x80, 0xC0,
  0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x00,
  0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x04, 0x60, 0x00, 0x18, 0x40, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0xE0, 0x03, 0x87,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0xC0, 0x18, 0x07, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00,
  0xC1, 0x80, 0x0E, 0x06, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0x81, 0xC0, 0x1C, 0x01, 0xC0,
  0x70, 0x01, 0x81, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x07,
  0x00, 0x38, 0x07, 0xC7, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x40, 0x00, 0x21, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x21, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x06, 0x00, 0x30,
  0x18, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x70, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x08, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x10, 0x08, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x01, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x18,
  0x06, 0x80, 0x30, 0x0D, 0x00, 0xE0, 0x1A, 0x01, 0xC0, 0x24, 0x03, 0x80,
  0xC8, 0x0F, 0x01, 0x90, 0x1A, 0x02, 0x20, 0x24, 0x0C, 0x40, 0xC8, 0x18,
  0x81, 0x90, 0x21, 0x02, 0x20, 0xC2, 0x0C, 0x41, 0x84, 0x18, 0x83, 0x08,
  0x61, 0x04, 0x10, 0xC2, 0x18, 0x21, 0x84, 0x30, 0x46, 0x08, 0x40, 0x8C,
  0x11, 0x81, 0x18, 0x33, 0x02, 0x60, 0x64, 0x04, 0xC0, 0xD8, 0x09, 0x81,
  0xB0, 0x16, 0x03, 0x60, 0x2C, 0x06, 0x80, 0x58, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x38,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1B,
  0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00,
  0xE0, 0xC0, 0x06, 0x02, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x02,
  0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0xC0,
  0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06,
  0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0xFC, 0x07,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x50, 0x00, 0xD8, 0x01, 0x98, 0x01,
  0x98, 0x03, 0x08, 0x03, 0x08, 0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x04, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC3, 0x0C, 0x61, 0x80, 0x00, 0x1E, 0x00, 0x0F,
  0xF8, 0x03, 0xC1, 0xC0, 0x70, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x1F, 0xFE, 0x0F, 0xC0, 0x61, 0xC0, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0x60, 0x03,
  0xC7, 0x00, 0xEC, 0x3C, 0x78, 0xC1, 0xFF, 0x0C, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x0C, 0x7F, 0x80,
  0xDC, 0x1C, 0x0B, 0x00, 0xE0, 0xE0, 0x06, 0x1C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x02, 0x20, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x87, 0x00, 0x38, 0x58,
  0x07, 0x0C, 0xF1, 0xE0, 0xC7, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0,
  0x0E, 0x0E, 0x07, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x19, 0x00, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x1C, 0x07,
  0x8F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x01, 0xC0, 0xC0, 0x1F, 0xE3, 0x01, 0xE0,
  0xCC, 0x0E, 0x01, 0xB0, 0x70, 0x03, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x03, 0x81,
  0x80, 0x1E, 0x03, 0x00, 0xD0, 0x0F, 0x9E, 0x40, 0x0F, 0xE3, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xF0, 0x03, 0x83, 0x80, 0xE0, 0x0C, 0x0C, 0x00, 0x61,
  0x80, 0x06, 0x30, 0x00, 0x23, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x01, 0x83, 0x80, 0x70, 0x1E, 0x1E, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0x02, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0xC0, 0xF0,
  0x66, 0x0E, 0x01, 0xB0, 0xE0, 0x07, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x3C,
  0x0C, 0x03, 0x40, 0x3C, 0xF2, 0x00, 0xFE, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x60, 0x60, 0x07, 0x01,
  0x80, 0x70, 0x07, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x0C, 0x7F, 0xC0,
  0x8E, 0x0E, 0x09, 0x80, 0x61, 0xA0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x04, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x08, 0x3C, 0x00, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x42, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80, 0x1C,
  0x0C, 0x01, 0x80, 0x60, 0x38, 0x03, 0x03, 0x80, 0x10, 0x38, 0x01, 0x83,
  0x00, 0x0C, 0x70, 0x00, 0x67, 0x00, 0x03, 0x78, 0x00, 0x1E, 0x60, 0x00,
  0xE3, 0x00, 0x0E, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x70, 0xC0, 0x01, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x1C, 0x0C,
  0xFE, 0x3F, 0x06, 0xC3, 0x70, 0xC3, 0x81, 0xA0, 0x31, 0x80, 0x60, 0x18,
  0xC0, 0x30, 0x0C, 0x40, 0x18, 0x06, 0x60, 0x08, 0x02, 0x30, 0x0C, 0x01,
  0x18, 0x06, 0x01, 0x8C, 0x03, 0x00, 0xC6, 0x01, 0x80, 0x62, 0x00, 0x80,
  0x33, 0x00, 0xC0, 0x11, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x0C, 0x60, 0x18,
  0x06, 0x20, 0x0C, 0x03, 0x10, 0x04, 0x01, 0x98, 0x06, 0x00, 0x8C, 0x03,
  0x00, 0xC6, 0x01, 0x80, 0x63, 0x00, 0xC0, 0x31, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x00, 0xC7, 0xFC, 0x08, 0xE0, 0xE0, 0x98, 0x06, 0x1A, 0x00, 0x31,
  0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x20, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00,
  0x0C, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x70, 0x0E, 0x01, 0xC0, 0xC0, 0x07,
  0x0E, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x83, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x78, 0x78, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x33, 0xFE, 0x01, 0xB8, 0x38, 0x0B, 0x00,
  0xE0, 0xF0, 0x03, 0x07, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x42, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x16, 0x01, 0xC1,
  0x9C, 0x7C, 0x0C, 0x7F, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xE3, 0x07, 0x83,
  0x30, 0xE0, 0x1B, 0x1C, 0x00, 0xE1, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x38, 0x60, 0x07, 0x83, 0x00, 0xD0,
  0x3C, 0x79, 0x00, 0xFE, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x07, 0x86, 0x1F, 0xF1, 0x8F, 0x04, 0x66,
  0x00, 0x1A, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xF8, 0x07, 0x81, 0xC0, 0xC0, 0x0E, 0x18, 0x00, 0x61, 0x80,
  0x03, 0x10, 0x00, 0x31, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0x60, 0x01, 0x87, 0x00, 0x30, 0x3C, 0x1E, 0x00, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0xFF,
  0xFE, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x80, 0x3F, 0xC0,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00,
  0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x60, 0x03, 0x86,
  0x00, 0x78, 0x70, 0x0D, 0x83, 0x87, 0x98, 0x1F, 0xE3, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30,
  0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x0C, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x23, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x36, 0x03, 0xC0, 0x6C, 0x07,
  0x80, 0x88, 0x0B, 0x03, 0x10, 0x36, 0x06, 0x20, 0x4C, 0x08, 0x41, 0x98,
  0x30, 0x83, 0x10, 0x41, 0x04, 0x21, 0x82, 0x18, 0x43, 0x04, 0x20, 0x84,
  0x0C, 0xC1, 0x18, 0x19, 0x03, 0x30, 0x36, 0x06, 0xC0, 0x6C, 0x0D, 0x80,
  0xD0, 0x1A, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x38,
  0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x31,
  0x80, 0x00, 0xC3, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x27, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0x30, 0x70, 0x02, 0x60, 0x38, 0x06, 0x40, 0x1C,
  0x0C, 0xC0, 0x0E, 0x1C, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoMono_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 9, -31 },
  { 29, 9, 9, 26, 11, -33 },
  { 40, 25, 31, 26, 1, -31 },
  { 137, 21, 40, 26, 3, -36 },
  { 242, 21, 32, 26, 3, -32 },
  { 326, 22, 32, 26, 2, -32 },
  { 414, 3, 9, 26, 13, -33 },
  { 418, 13, 45, 26, 8, -35 },
  { 492, 13, 45, 26, 4, -35 },
  { 566, 18, 18, 26, 6, -31 },
  { 607, 21, 23, 26, 3, -26 },
  { 668, 6, 10, 26, 5, -4 },
  { 676, 15, 2, 26, 5, -15 },
  { 680, 3, 3, 26, 10, -3 },
  { 682, 21, 34, 26, 3, -31 },
  { 772, 21, 32, 26, 3, -32 },
  { 856, 11, 31, 26, 7, -31 },
  { 899, 21, 32, 26, 1, -32 },
  { 983, 21, 32, 26, 1, -32 },
  { 1067, 22, 31, 26, 1, -31 },
  { 1153, 21, 31, 26, 4, -31 },
  { 1235, 19, 32, 26, 3, -32 },
  { 1311, 20, 31, 26, 5, -31 },
  { 1389, 21, 32, 26, 3, -32 },
  { 1473, 19, 32, 26, 4, -32 },
  { 1549, 7, 22, 26, 11, -22 },
  { 1569, 10, 28, 26, 8, -22 },
  { 1604, 19, 18, 26, 4, -23 },
  { 1647, 20, 11, 26, 3, -20 },
  { 1675, 19, 18, 26, 3, -23 },
  { 1718, 16, 32, 26, 7, -32 },
  { 1782, 25, 32, 26, 1, -32 },
  { 1882, 22, 31, 26, 0, -31 },
  { 1968, 22, 31, 26, 2, -31 },
  { 2054, 21, 32, 26, 3, -32 },
  { 2138, 22, 31, 26, 2, -31 },
  { 2224, 23, 31, 26, 2, -31 },
  { 2314, 23, 31, 26, 2, -31 },
  { 2404, 22, 32, 26, 2, -32 },
  { 2492, 24, 31, 26, 1, -31 },
  { 2585, 23, 31, 26, 2, -31 },
  { 2675, 22, 31, 26, 2, -31 },
  { 2761, 25, 31, 26, 2, -31 },
  { 2858, 17, 31, 26, 3, -31 },
  { 2924, 25, 31, 26, 1, -31 },
  { 3021, 24, 31, 26, 1, -31 },
  { 3114, 21, 32, 26, 3, -32 },
  { 3198, 22, 31, 26, 3, -31 },
  { 3284, 23, 38, 26, 2, -32 },
  { 3394, 22, 31, 26, 2, -31 },
  { 3480, 23, 32, 26, 2, -32 },
  { 3572, 22, 31, 26, 5, -31 },
  { 3658, 22, 31, 26, 3, -31 },
  { 3744, 21, 31, 26, 5, -31 },
  { 3826, 23, 31, 26, 4, -31 },
  { 3916, 26, 31, 26, 0, -31 },
  { 4017, 21, 31, 26, 5, -31 },
  { 4099, 23, 31, 26, 1, -31 },
  { 4189, 13, 43, 26, 7, -36 },
  { 4259, 8, 34, 26, 9, -31 },
  { 4293, 14, 43, 26, 6, -36 },
  { 4369, 16, 17, 26, 5, -31 },
  { 4403, 19, 2, 26, 1, 0 },
  { 4408, 5, 5, 26, 13, -32 },
  { 4412, 20, 24, 26, 2, -24 },
  { 4472, 20, 33, 26, 2, -33 },
  { 4555, 19, 24, 26, 3, -24 },
  { 4612, 22, 33, 26, 3, -33 },
  { 4703, 20, 24, 26, 3, -24 },
  { 4763, 21, 34, 26, 6, -34 },
  { 4853, 21, 33, 26, 2, -24 },
  { 4940, 20, 33, 26, 2, -33 },
  { 5023, 18, 32, 26, 3, -32 },
  { 5095, 20, 41, 26, 0, -32 },
  { 5198, 21, 33, 26, 3, -33 },
  { 5285, 18, 33, 26, 3, -33 },
  { 5360, 25, 24, 26, 0, -24 },
  { 5435, 20, 24, 26, 2, -24 },
  { 5495, 21, 24, 26, 2, -24 },
  { 5558, 21, 33, 26, 1, -24 },
  { 5645, 20, 33, 26, 3, -24 },
  { 5728, 18, 24, 26, 6, -24 },
  { 5782, 20, 24, 26, 3, -24 },
  { 5842, 17, 29, 26, 5, -29 },
  { 5904, 20, 23, 26, 3, -23 },
  { 5962, 21, 23, 26, 4, -23 },
  { 6023, 23, 23, 26, 3, -23 },
  { 6090, 23, 23, 26, 1, -23 },
  { 6157, 27, 32, 26, -1, -23 },
  { 6265, 22, 23, 26, 1, -23 },
  { 6329, 17, 43, 26, 7, -34 },
  { 6421, 8, 37, 26, 9, -31 },
  { 6458, 17, 43, 26, 4, -34 },
  { 6550, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC44PT7B_H_
