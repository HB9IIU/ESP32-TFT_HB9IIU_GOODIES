#ifndef _ROBOTOMONO_EXTRALIGHTITALIC14PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x68, 0x20, 0x76, 0x80, 0x09, 0x0A, 0x12, 0x7F, 0x14, 0x24,
  0xF6, 0x28, 0x48, 0x48, 0x08, 0x69, 0x0A, 0x14, 0x04, 0x06, 0x02, 0x85,
  0x09, 0x61, 0x00, 0x61, 0x2A, 0xA5, 0x45, 0x04, 0x8E, 0xA9, 0x92, 0x38,
  0x38, 0x89, 0x22, 0x82, 0x0A, 0x24, 0xC6, 0x89, 0xE8, 0xE0, 0x08, 0x88,
  0x84, 0x22, 0x10, 0x84, 0x21, 0x04, 0x30, 0x20, 0x84, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x44, 0x60, 0x10, 0x8F, 0xC8, 0x52, 0x20, 0x10, 0x20, 0x47,
  0xF2, 0x04, 0x08, 0x00, 0xE0, 0xF8, 0x80, 0x02, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x00, 0x3C, 0x89, 0x0C, 0x29, 0xB4, 0xB1, 0x42,
  0x88, 0xE0, 0x3D, 0x12, 0x22, 0x22, 0x24, 0x1C, 0x45, 0x08, 0x10, 0x41,
  0x04, 0x10, 0x41, 0xF8, 0x1C, 0x45, 0x08, 0x11, 0xC0, 0x80, 0xC1, 0x84,
  0xF0, 0x02, 0x0C, 0x28, 0xA2, 0x48, 0x91, 0x5F, 0x04, 0x10, 0x3E, 0x41,
  0x02, 0x86, 0xC0, 0x81, 0x42, 0x84, 0xF0, 0x1C, 0x84, 0x2C, 0xCE, 0x18,
  0x61, 0x89, 0xC0, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10, 0x82, 0x00, 0x3C,
  0x85, 0x0A, 0x23, 0x88, 0xA1, 0x42, 0x84, 0xF0, 0x39, 0x18, 0x61, 0x85,
  0x33, 0x42, 0x09, 0xC0, 0x20, 0x00, 0x30, 0x20, 0x00, 0x24, 0x80, 0x0D,
  0xC8, 0x18, 0x1C, 0xFC, 0x0F, 0xC0, 0x60, 0x60, 0x4E, 0xC0, 0x7C, 0x42,
  0x11, 0x11, 0x00, 0x02, 0x00, 0x1E, 0x21, 0x4D, 0x55, 0xA5, 0xA5, 0xA9,
  0xB6, 0x80, 0x78, 0x04, 0x18, 0x50, 0xA1, 0x44, 0x8F, 0xA1, 0x43, 0x04,
  0x7C, 0x85, 0x0A, 0x2F, 0x90, 0xA1, 0x42, 0x85, 0xF0, 0x3C, 0x85, 0x0C,
  0x08, 0x10, 0x20, 0x42, 0x88, 0xE0, 0x78, 0x89, 0x0C, 0x18, 0x30, 0x61,
  0x42, 0x89, 0xE0, 0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40, 0x81, 0xF0,
  0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x86, 0x0C,
  0x08, 0x13, 0xA1, 0x42, 0x84, 0xF0, 0x21, 0x21, 0x41, 0x41, 0x7E, 0x42,
  0x42, 0x42, 0x82, 0x82, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x21,
  0xF0, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x42, 0x89, 0xE0, 0x43, 0x44,
  0x48, 0x50, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x83, 0xF0, 0x21, 0x21, 0x23, 0x55, 0x55, 0x5A, 0x52, 0x42,
  0x42, 0x82, 0x21, 0x21, 0x51, 0x51, 0x4A, 0x4A, 0x4A, 0x46, 0x86, 0x84,
  0x3C, 0x89, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x7C, 0x85, 0x0A,
  0x14, 0x4F, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xC2, 0x88, 0xE0, 0x20, 0x40, 0x7C, 0x85, 0x0A, 0x18, 0x5F, 0x22, 0x44,
  0x89, 0x08, 0x3C, 0x85, 0x0A, 0x03, 0x01, 0x01, 0x42, 0x84, 0xF0, 0xFE,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x80, 0x42, 0x86, 0x0C, 0x18,
  0x30, 0xA1, 0x42, 0x88, 0xE0, 0x86, 0x18, 0xA2, 0x92, 0x49, 0x18, 0x41,
  0x00, 0x89, 0x91, 0x92, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0xC8, 0x88, 0x21,
  0x22, 0x12, 0x14, 0x08, 0x08, 0x14, 0x24, 0x44, 0x82, 0x86, 0x18, 0x94,
  0x51, 0x84, 0x10, 0x41, 0x00, 0x3F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20,
  0x20, 0x40, 0xFC, 0x32, 0x24, 0x44, 0x44, 0x48, 0x88, 0xC0, 0x92, 0x48,
  0x92, 0x48, 0x80, 0x31, 0x11, 0x12, 0x22, 0x22, 0x22, 0xC0, 0x21, 0x94,
  0xA8, 0x80, 0xFC, 0x90, 0x39, 0x18, 0x41, 0x7E, 0x18, 0xBE, 0x41, 0x04,
  0x16, 0x66, 0x18, 0x61, 0x86, 0x2F, 0x00, 0x39, 0x18, 0x60, 0x82, 0x08,
  0x5E, 0x02, 0x04, 0x09, 0xD4, 0x50, 0xA1, 0x42, 0x85, 0x11, 0xE0, 0x19,
  0x98, 0x7F, 0x82, 0x08, 0x1E, 0x0E, 0x60, 0x85, 0xC4, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18, 0x9E, 0x0A, 0x2F, 0x00,
  0x41, 0x04, 0x16, 0x66, 0x18, 0x61, 0x86, 0x18, 0x80, 0x08, 0x06, 0x04,
  0x10, 0x41, 0x04, 0x23, 0xF0, 0x04, 0x01, 0x89, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x84, 0xE0, 0x40, 0x81, 0x02, 0x14, 0xCA, 0x28, 0x70, 0x91, 0x12,
  0x30, 0x38, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x8F, 0xC0, 0x36, 0x49,
  0x49, 0x89, 0x91, 0x91, 0x92, 0x92, 0x19, 0x98, 0x61, 0x86, 0x18, 0x62,
  0x39, 0x18, 0x61, 0x86, 0x18, 0x9C, 0x0C, 0x65, 0x0A, 0x14, 0x28, 0x51,
  0x3C, 0x81, 0x02, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18, 0x9E, 0x08, 0x20,
  0x80, 0x1D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x39, 0x14, 0x50, 0x38, 0x18,
  0x5E, 0x25, 0xD0, 0x84, 0x21, 0x08, 0x78, 0x46, 0x18, 0x61, 0x86, 0x27,
  0x80, 0x82, 0x89, 0x22, 0x45, 0x06, 0x08, 0x00, 0x93, 0x66, 0xD5, 0xAC,
  0x99, 0x22, 0x00, 0x23, 0x14, 0x18, 0x18, 0x28, 0x24, 0xC2, 0x41, 0x42,
  0x22, 0x24, 0x28, 0x18, 0x10, 0x10, 0x20, 0xC0, 0x3E, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0x80, 0x0C, 0x41, 0x08, 0x20, 0x84, 0x30, 0x41, 0x04, 0x10,
  0x20, 0x40, 0x55, 0x5A, 0xAA, 0x20, 0x40, 0x84, 0x10, 0x40, 0xC2, 0x10,
  0x42, 0x08, 0x23, 0x00, 0x71, 0x8E,
};

const GFXglyph RobotoMono_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 3, 3, 8, 3, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 12, 8, 1, -11 },
  { 27, 7, 10, 8, 1, -10 },
  { 36, 7, 10, 8, 1, -10 },
  { 45, 1, 3, 8, 4, -11 },
  { 46, 5, 14, 8, 2, -11 },
  { 55, 5, 14, 8, 1, -11 },
  { 64, 6, 6, 8, 2, -10 },
  { 69, 7, 7, 8, 1, -8 },
  { 76, 1, 3, 8, 2, -1 },
  { 77, 5, 1, 8, 2, -5 },
  { 78, 1, 1, 8, 3, -1 },
  { 79, 7, 11, 8, 1, -10 },
  { 89, 7, 10, 8, 1, -10 },
  { 98, 4, 10, 8, 2, -10 },
  { 103, 7, 10, 8, 0, -10 },
  { 112, 7, 10, 8, 0, -10 },
  { 121, 7, 10, 8, 0, -10 },
  { 130, 7, 10, 8, 1, -10 },
  { 139, 6, 10, 8, 1, -10 },
  { 147, 6, 10, 8, 2, -10 },
  { 155, 7, 10, 8, 1, -10 },
  { 164, 6, 10, 8, 1, -10 },
  { 172, 3, 7, 8, 3, -7 },
  { 175, 3, 9, 8, 3, -7 },
  { 179, 6, 5, 8, 1, -7 },
  { 183, 6, 3, 8, 1, -6 },
  { 186, 6, 5, 8, 1, -7 },
  { 190, 5, 10, 8, 2, -10 },
  { 197, 8, 10, 8, 0, -10 },
  { 207, 7, 10, 8, 0, -10 },
  { 216, 7, 10, 8, 1, -10 },
  { 225, 7, 10, 8, 1, -10 },
  { 234, 7, 10, 8, 1, -10 },
  { 243, 7, 10, 8, 1, -10 },
  { 252, 7, 10, 8, 1, -10 },
  { 261, 7, 10, 8, 1, -10 },
  { 270, 8, 10, 8, 0, -10 },
  { 280, 7, 10, 8, 1, -10 },
  { 289, 7, 10, 8, 1, -10 },
  { 298, 8, 10, 8, 1, -10 },
  { 308, 6, 10, 8, 1, -10 },
  { 316, 8, 10, 8, 0, -10 },
  { 326, 8, 10, 8, 0, -10 },
  { 336, 7, 10, 8, 1, -10 },
  { 345, 7, 10, 8, 1, -10 },
  { 354, 7, 12, 8, 1, -10 },
  { 365, 7, 10, 8, 1, -10 },
  { 374, 7, 10, 8, 1, -10 },
  { 383, 7, 10, 8, 2, -10 },
  { 392, 7, 10, 8, 1, -10 },
  { 401, 6, 10, 8, 2, -10 },
  { 409, 8, 10, 8, 1, -10 },
  { 419, 8, 10, 8, 0, -10 },
  { 429, 6, 10, 8, 2, -10 },
  { 437, 8, 10, 8, 0, -10 },
  { 447, 4, 13, 8, 2, -11 },
  { 454, 3, 11, 8, 3, -10 },
  { 459, 4, 13, 8, 2, -11 },
  { 466, 5, 5, 8, 2, -10 },
  { 470, 6, 1, 8, 0, 0 },
  { 471, 2, 2, 8, 4, -10 },
  { 472, 6, 8, 8, 1, -8 },
  { 478, 6, 11, 8, 1, -11 },
  { 487, 6, 8, 8, 1, -8 },
  { 493, 7, 11, 8, 1, -11 },
  { 503, 6, 8, 8, 1, -8 },
  { 509, 7, 11, 8, 2, -11 },
  { 519, 6, 11, 8, 1, -8 },
  { 528, 6, 11, 8, 1, -11 },
  { 537, 6, 10, 8, 1, -10 },
  { 545, 6, 13, 8, 0, -10 },
  { 555, 7, 11, 8, 1, -11 },
  { 565, 6, 11, 8, 1, -11 },
  { 574, 8, 8, 8, 0, -8 },
  { 582, 6, 8, 8, 1, -8 },
  { 588, 6, 8, 8, 1, -8 },
  { 594, 7, 11, 8, 0, -8 },
  { 604, 6, 11, 8, 1, -8 },
  { 613, 6, 8, 8, 2, -8 },
  { 619, 6, 8, 8, 1, -8 },
  { 625, 5, 9, 8, 2, -9 },
  { 631, 6, 7, 8, 1, -7 },
  { 637, 7, 7, 8, 1, -7 },
  { 644, 7, 7, 8, 1, -7 },
  { 651, 8, 7, 8, 0, -7 },
  { 658, 8, 10, 8, 0, -7 },
  { 668, 7, 7, 8, 0, -7 },
  { 675, 6, 14, 8, 2, -11 },
  { 686, 2, 12, 8, 3, -10 },
  { 689, 6, 14, 8, 1, -11 },
  { 700, 8, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC14PT7B_H_
