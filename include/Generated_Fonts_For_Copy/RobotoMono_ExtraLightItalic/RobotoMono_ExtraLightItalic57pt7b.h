#ifndef _ROBOTOMONO_EXTRALIGHTITALIC57PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xE0, 0xE0, 0x00,
  0x30, 0x6E, 0x0D, 0xC1, 0xB0, 0x36, 0x06, 0xC1, 0x98, 0x33, 0x06, 0xC0,
  0xD8, 0x1B, 0x06, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x20, 0x30, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x78, 0x00, 0xF0,
  0x03, 0x80, 0x38, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x08,
  0x60, 0x0C, 0x01, 0xC6, 0x00, 0xC0, 0x38, 0x60, 0x0C, 0x03, 0x06, 0x00,
  0xC0, 0x60, 0x60, 0x0C, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x18,
  0x06, 0x01, 0x83, 0x00, 0x60, 0x30, 0x70, 0x07, 0x07, 0x06, 0x00, 0x3F,
  0xE0, 0xC0, 0x01, 0xFC, 0x1C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0xF8, 0x00, 0x38, 0x3F, 0xC0, 0x03, 0x07, 0x0E, 0x00, 0x60,
  0xE0, 0x60, 0x0E, 0x0C, 0x07, 0x00, 0xC1, 0x80, 0x30, 0x18, 0x18, 0x03,
  0x03, 0x83, 0x80, 0x30, 0x70, 0x30, 0x03, 0x06, 0x03, 0x00, 0x70, 0xC0,
  0x30, 0x06, 0x1C, 0x03, 0x00, 0x63, 0x80, 0x30, 0x06, 0x10, 0x03, 0x00,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80, 0x01, 0x80,
  0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x07, 0x0E, 0x03, 0x80,
  0x30, 0xE0, 0x0C, 0x01, 0x86, 0x00, 0x70, 0x1C, 0x70, 0x01, 0xC0, 0xE3,
  0x00, 0x06, 0x06, 0x38, 0x00, 0x38, 0x71, 0x80, 0x00, 0xE3, 0x0C, 0x00,
  0x03, 0x38, 0x60, 0x00, 0x1F, 0x83, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x3D, 0xC0,
  0x78, 0x07, 0x87, 0x01, 0xFF, 0xF8, 0x18, 0x03, 0xFF, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x39, 0xCC, 0x63, 0x19, 0xCC, 0x63, 0x19, 0xC0, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x0C, 0x03, 0x3E, 0x06, 0x0F, 0xEF, 0xC3, 0x3F,
  0x80, 0xFF, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x20, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0x86,
  0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0x78, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x3E, 0x70,
  0x00, 0x0F, 0x8E, 0x00, 0x07, 0x31, 0x80, 0x01, 0xC6, 0x30, 0x00, 0x70,
  0xC6, 0x00, 0x1C, 0x19, 0xC0, 0x07, 0x03, 0x38, 0x03, 0x80, 0xE7, 0x00,
  0xE0, 0x1C, 0xC0, 0x38, 0x03, 0x18, 0x0E, 0x00, 0x63, 0x03, 0x80, 0x0C,
  0xE0, 0xE0, 0x03, 0x9C, 0x70, 0x00, 0x73, 0x9C, 0x00, 0x0C, 0x77, 0x00,
  0x01, 0x8D, 0xC0, 0x00, 0x31, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x60, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0xE0, 0xFC, 0xC7, 0xE1,
  0xBE, 0x07, 0x70, 0x0E, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC1, 0xF0, 0x00,
  0x0C, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x78, 0x01, 0xE0,
  0x01, 0xC0, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x7F, 0xE0, 0x18, 0xFF, 0xF8,
  0x0C, 0xE0, 0x0E, 0x0E, 0xC0, 0x03, 0x86, 0xC0, 0x00, 0xE3, 0xC0, 0x00,
  0x71, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x38,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x06,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0x60, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x38, 0x00, 0xEC,
  0x3C, 0x03, 0xCC, 0x1F, 0x1F, 0x8C, 0x0F, 0xFE, 0x1C, 0x01, 0xF0, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x03, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x3E, 0x0E, 0x00, 0x00,
  0xE0, 0x0F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xE0, 0xF8, 0x3C,
  0x01, 0xC3, 0xC0, 0x07, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0xEC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x03, 0x00, 0xFE, 0x03, 0x07, 0x01, 0xFF, 0x03, 0x06,
  0x03, 0x83, 0x83, 0x0C, 0x06, 0x03, 0x03, 0x0C, 0x0C, 0x03, 0x03, 0x18,
  0x1C, 0x03, 0x03, 0x18, 0x18, 0x02, 0x03, 0x38, 0x30, 0x06, 0x03, 0x30,
  0x30, 0x06, 0x03, 0x30, 0x30, 0x06, 0x03, 0x30, 0x60, 0x0C, 0x02, 0x60,
  0x60, 0x0C, 0x06, 0x60, 0x60, 0x0C, 0x06, 0x60, 0x60, 0x0C, 0x06, 0x60,
  0xC0, 0x18, 0x06, 0x60, 0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x38, 0x0C, 0xC0,
  0xC0, 0x38, 0x08, 0xC0, 0xC0, 0x70, 0x18, 0xC0, 0xC0, 0xD0, 0x18, 0xC0,
  0xC1, 0x98, 0x30, 0x60, 0x63, 0x98, 0xE0, 0x60, 0x7F, 0x1F, 0xC0, 0x60,
  0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xC0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x78, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0xF0, 0x0C, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0x80, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0xC0,
  0xC0, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x78, 0x01, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0x8C, 0x00, 0x7F, 0xFC,
  0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x03, 0x00, 0x01, 0xE0, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x78, 0x00, 0x06,
  0x00, 0xF0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x1D,
  0xCE, 0x00, 0x00, 0x1B, 0x86, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x1E,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x01, 0xF0, 0x36, 0x00, 0x03, 0xE0, 0x6C, 0x00, 0x0F, 0x80, 0xD8, 0x00,
  0x3B, 0x01, 0xB0, 0x00, 0x76, 0x07, 0x70, 0x01, 0xCC, 0x0E, 0xE0, 0x03,
  0x38, 0x18, 0xC0, 0x0E, 0x60, 0x31, 0x80, 0x18, 0xC0, 0x63, 0x00, 0x71,
  0x80, 0xC6, 0x00, 0xC3, 0x03, 0x8E, 0x03, 0x8E, 0x07, 0x0C, 0x0E, 0x1C,
  0x0C, 0x18, 0x18, 0x30, 0x18, 0x30, 0x70, 0x60, 0x30, 0x60, 0xC0, 0xC0,
  0x60, 0xE3, 0x81, 0x81, 0xC0, 0xC6, 0x07, 0x03, 0x81, 0x9C, 0x0E, 0x06,
  0x03, 0x30, 0x18, 0x0C, 0x06, 0xE0, 0x30, 0x18, 0x0D, 0x80, 0x60, 0x30,
  0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x30, 0x07, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x30, 0x1E, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0xC0, 0x6C, 0x00, 0x01,
  0x80, 0xD8, 0x00, 0x07, 0x01, 0xB8, 0x00, 0x0E, 0x07, 0x30, 0x00, 0x18,
  0x0E, 0x60, 0x00, 0x30, 0x18, 0xE0, 0x00, 0x60, 0x30, 0xC0, 0x01, 0xC0,
  0x61, 0x80, 0x03, 0x81, 0xC3, 0x80, 0x07, 0x03, 0x83, 0x00, 0x0C, 0x06,
  0x06, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x0C, 0x00, 0xE0, 0x30,
  0x1C, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x01, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x70, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x0C, 0x00, 0xC0, 0x70, 0x18, 0x01,
  0xC0, 0xE0, 0x70, 0x01, 0x81, 0x80, 0xE0, 0x03, 0x83, 0x01, 0x80, 0x03,
  0x06, 0x03, 0x00, 0x06, 0x0C, 0x06, 0x00, 0x0E, 0x38, 0x0C, 0x00, 0x0C,
  0x70, 0x38, 0x00, 0x18, 0xC0, 0x70, 0x00, 0x39, 0x80, 0xC0, 0x00, 0x33,
  0x01, 0x80, 0x00, 0x66, 0x03, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0xF8,
  0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x78, 0x01, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x07, 0x80, 0x30, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x38,
  0x07, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x87,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1E,
  0x01, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x18,
  0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x07,
  0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x03,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x6C, 0x00, 0x70, 0x01, 0xB0, 0x01, 0xC0, 0x0E, 0xC0, 0x0F, 0x00, 0x33,
  0x00, 0x3C, 0x00, 0xCC, 0x00, 0xF0, 0x07, 0x30, 0x07, 0xC0, 0x18, 0xC0,
  0x1B, 0x00, 0x63, 0x00, 0x6C, 0x01, 0x8C, 0x03, 0xB0, 0x0E, 0x30, 0x0C,
  0xC0, 0x30, 0xC0, 0x33, 0x00, 0xC3, 0x01, 0xCC, 0x07, 0x0C, 0x06, 0x30,
  0x18, 0x30, 0x18, 0xC0, 0x60, 0xC0, 0xC3, 0x03, 0x83, 0x03, 0x0C, 0x0C,
  0x0C, 0x0C, 0x30, 0x30, 0x30, 0x60, 0xC0, 0xC0, 0xC1, 0x83, 0x86, 0x03,
  0x0E, 0x0E, 0x18, 0x0C, 0x30, 0x38, 0x60, 0x30, 0xC0, 0xE3, 0x80, 0xC7,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x33, 0x80,
  0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0D, 0xC0, 0x1B,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0x30, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x38,
  0x01, 0x81, 0x80, 0x38, 0x18, 0x03, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x00,
  0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00,
  0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0xC4, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0x03, 0x07, 0x80, 0x00, 0xC3, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x07,
  0xE1, 0xC0, 0x03, 0xB8, 0x38, 0x03, 0xCE, 0x07, 0xFF, 0xC3, 0x80, 0xFF,
  0xC0, 0xE0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x01,
  0x87, 0xFE, 0x00, 0x63, 0xFF, 0xC0, 0x1B, 0xC0, 0x38, 0x0F, 0xC0, 0x07,
  0x03, 0xE0, 0x00, 0xC0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x18,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x06,
  0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83,
  0xF0, 0x01, 0xC0, 0xEE, 0x01, 0xE0, 0x31, 0xFF, 0xF0, 0x0C, 0x1F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x38, 0x00,
  0x0C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0xFE, 0x1C, 0x01, 0xFF, 0xF1,
  0xC0, 0x3C, 0x03, 0x98, 0x07, 0x80, 0x0D, 0x80, 0xF0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x03, 0x80, 0x0F, 0x80, 0x1C, 0x03, 0x98, 0x00, 0xFF, 0xF1, 0x80, 0x07,
  0xFC, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x18, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x70, 0x0F, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0x00, 0x7F, 0xFC, 0x70, 0x0F,
  0x00, 0xE6, 0x01, 0xE0, 0x03, 0x60, 0x3C, 0x00, 0x3E, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x1C, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70,
  0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x00, 0xE0,
  0x03, 0xE0, 0x07, 0x00, 0xE6, 0x00, 0x3F, 0xFC, 0x60, 0x01, 0xFF, 0x0E,
  0x00, 0x01, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x00, 0x60, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x01,
  0xE0, 0x01, 0x83, 0xFF, 0x00, 0x61, 0xFF, 0xE0, 0x39, 0xE0, 0x1C, 0x0C,
  0xE0, 0x03, 0x83, 0x70, 0x00, 0x60, 0xD0, 0x00, 0x18, 0x38, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x60, 0x00,
  0x07, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x06, 0x00, 0x0F, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x0C,
  0x3C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1D, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0x9C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x30, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x38, 0x01, 0x9F, 0xE0, 0xFF, 0x01,
  0xDF, 0xF8, 0xFF, 0xC0, 0xD8, 0x0C, 0xC0, 0x60, 0x78, 0x07, 0xC0, 0x38,
  0x38, 0x03, 0xC0, 0x0C, 0x1C, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x03,
  0x0E, 0x00, 0x70, 0x01, 0x86, 0x00, 0x38, 0x01, 0xC3, 0x00, 0x18, 0x00,
  0xE1, 0x80, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x00,
  0x18, 0x70, 0x03, 0x80, 0x0C, 0x30, 0x01, 0xC0, 0x0E, 0x18, 0x00, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x00, 0x30, 0x01, 0x87, 0x00, 0x18,
  0x00, 0xC3, 0x80, 0x1C, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x70, 0xC0, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x38, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xE0, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x86, 0x00,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x01, 0xE0, 0x01, 0x83, 0xFF, 0x00, 0xE1, 0xFF, 0xE0, 0x39, 0xE0, 0x1C,
  0x0C, 0xE0, 0x03, 0x83, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x18, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x18, 0x7F, 0xE0, 0x01,
  0x9F, 0xFF, 0x00, 0x3B, 0xC0, 0x78, 0x03, 0xF0, 0x01, 0xC0, 0x3E, 0x00,
  0x0C, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x3E,
  0x00, 0x0E, 0x03, 0xF0, 0x01, 0xC0, 0x3B, 0x80, 0x78, 0x03, 0x1F, 0xFF,
  0x00, 0x30, 0x7F, 0xC0, 0x03, 0x00, 0x40, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x70, 0x1F, 0xFF, 0x1C, 0x0F, 0x00, 0xE6,
  0x07, 0x80, 0x0D, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x03, 0xE0, 0x1C, 0x03, 0xD8, 0x03, 0xFF, 0xC6,
  0x00, 0x7F, 0xC3, 0x80, 0x01, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x03,
  0xFF, 0x06, 0x0F, 0xFF, 0x06, 0x3E, 0x00, 0x06, 0x70, 0x00, 0x06, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x3C,
  0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x06,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x3C, 0x1C, 0x00, 0x1F,
  0x03, 0x00, 0x1D, 0xC0, 0xF0, 0x1E, 0x60, 0x1F, 0xFF, 0x18, 0x03, 0xFF,
  0x06, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x70, 0x06, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x6E, 0x00, 0x70, 0x01, 0xB8, 0x01,
  0xC0, 0x0E, 0xE0, 0x0D, 0x00, 0x33, 0x80, 0x34, 0x00, 0xC6, 0x01, 0x90,
  0x06, 0x18, 0x06, 0x60, 0x18, 0x60, 0x19, 0x80, 0xE1, 0x80, 0xC6, 0x03,
  0x06, 0x03, 0x18, 0x0C, 0x18, 0x18, 0x60, 0x70, 0x60, 0x61, 0x81, 0x81,
  0x83, 0x86, 0x0E, 0x06, 0x0C, 0x18, 0x30, 0x18, 0x30, 0x60, 0xC0, 0x61,
  0x81, 0x87, 0x01, 0x86, 0x06, 0x18, 0x06, 0x38, 0x18, 0x60, 0x18, 0xC0,
  0x63, 0x00, 0x63, 0x00, 0x8C, 0x01, 0x98, 0x03, 0x70, 0x06, 0x60, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xB0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0C, 0x7F, 0xF0, 0x00, 0x18, 0xE0, 0x78, 0x00, 0x63, 0x00, 0x78, 0x00,
  0xCE, 0x00, 0x78, 0x03, 0x18, 0x00, 0x78, 0x0E, 0x30, 0x00, 0x7C, 0x78,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 41, 33, 12, -41 },
  { 48, 11, 12, 33, 14, -43 },
  { 65, 33, 41, 33, 1, -41 },
  { 235, 27, 52, 33, 4, -46 },
  { 411, 28, 42, 33, 3, -41 },
  { 558, 29, 42, 33, 2, -41 },
  { 711, 5, 12, 33, 16, -43 },
  { 719, 17, 58, 33, 10, -45 },
  { 843, 18, 58, 33, 5, -45 },
  { 974, 25, 24, 33, 7, -41 },
  { 1049, 28, 30, 33, 3, -34 },
  { 1154, 7, 13, 33, 7, -5 },
  { 1166, 21, 2, 33, 6, -19 },
  { 1172, 4, 4, 33, 13, -4 },
  { 1174, 27, 44, 33, 4, -41 },
  { 1323, 27, 42, 33, 4, -41 },
  { 1465, 15, 41, 33, 9, -41 },
  { 1542, 27, 41, 33, 1, -41 },
  { 1681, 28, 42, 33, 1, -41 },
  { 1828, 28, 41, 33, 1, -41 },
  { 1972, 28, 42, 33, 5, -41 },
  { 2119, 25, 42, 33, 3, -41 },
  { 2251, 26, 41, 33, 7, -41 },
  { 2385, 28, 42, 33, 3, -41 },
  { 2532, 24, 41, 33, 6, -41 },
  { 2655, 9, 28, 33, 14, -28 },
  { 2687, 12, 36, 33, 11, -28 },
  { 2741, 25, 23, 33, 5, -30 },
  { 2813, 26, 13, 33, 4, -25 },
  { 2856, 26, 23, 33, 3, -30 },
  { 2931, 21, 41, 33, 9, -41 },
  { 3039, 32, 41, 33, 1, -41 },
  { 3203, 28, 41, 33, 0, -41 },
  { 3347, 28, 41, 33, 3, -41 },
  { 3491, 29, 42, 33, 3, -41 },
  { 3644, 29, 41, 33, 2, -41 },
  { 3793, 30, 41, 33, 3, -41 },
  { 3947, 30, 41, 33, 3, -41 },
  { 4101, 29, 42, 33, 3, -41 },
  { 4254, 31, 41, 33, 2, -41 },
  { 4413, 29, 41, 33, 3, -41 },
  { 4562, 29, 42, 33, 2, -41 },
  { 4715, 32, 41, 33, 3, -41 },
  { 4879, 24, 41, 33, 3, -41 },
  { 5002, 31, 41, 33, 2, -41 },
  { 5161, 31, 41, 33, 2, -41 },
  { 5320, 28, 42, 33, 3, -41 },
  { 5467, 30, 41, 33, 3, -41 },
  { 5621, 29, 48, 33, 3, -41 },
  { 5795, 28, 41, 33, 3, -41 },
  { 5939, 29, 42, 33, 3, -41 },
  { 6092, 28, 41, 33, 7, -41 },
  { 6236, 29, 42, 33, 4, -41 },
  { 6389, 28, 41, 33, 6, -41 },
  { 6533, 30, 41, 33, 6, -41 },
  { 6687, 33, 41, 33, 1, -41 },
  { 6857, 28, 41, 33, 6, -41 },
  { 7001, 30, 41, 33, 1, -41 },
  { 7155, 17, 55, 33, 9, -46 },
  { 7272, 11, 45, 33, 11, -41 },
  { 7334, 17, 55, 33, 8, -46 },
  { 7451, 20, 23, 33, 7, -41 },
  { 7509, 23, 2, 33, 2, 0 },
  { 7515, 6, 7, 33, 17, -42 },
  { 7521, 26, 32, 33, 3, -31 },
  { 7625, 26, 44, 33, 3, -43 },
  { 7768, 25, 32, 33, 4, -31 },
  { 7868, 28, 44, 33, 4, -43 },
  { 8022, 26, 32, 33, 3, -31 },
  { 8126, 28, 44, 33, 7, -44 },
  { 8280, 28, 43, 33, 2, -31 },
  { 8431, 26, 43, 33, 3, -43 },
  { 8571, 24, 41, 33, 3, -41 },
  { 8694, 26, 53, 33, 0, -41 },
  { 8867, 28, 43, 33, 3, -43 },
  { 9018, 24, 43, 33, 3, -43 },
  { 9147, 33, 31, 33, -1, -31 },
  { 9275, 26, 31, 33, 3, -31 },
  { 9376, 27, 32, 33, 3, -31 },
  { 9484, 28, 43, 33, 1, -31 },
  { 9635, 26, 43, 33, 4, -31 },
  { 9775, 24, 31, 33, 7, -31 },
  { 9868, 26, 32, 33, 4, -31 },
  { 9972, 22, 39, 33, 7, -38 },
  { 10080, 26, 31, 33, 4, -30 },
  { 10181, 27, 30, 33, 5, -30 },
  { 10283, 30, 30, 33, 4, -30 },
  { 10396, 31, 30, 33, 1, -30 },
  { 10513, 34, 42, 33, -1, -30 },
  { 10692, 29, 30, 33, 1, -30 },
  { 10801, 22, 56, 33, 9, -44 },
  { 10955, 9, 49, 33, 12, -41 },
  { 11011, 22, 56, 33, 5, -44 },
  { 11165, 31, 10, 33, 1, -22 },
};

const GFXfont RobotoMono_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC57PT7B_H_
