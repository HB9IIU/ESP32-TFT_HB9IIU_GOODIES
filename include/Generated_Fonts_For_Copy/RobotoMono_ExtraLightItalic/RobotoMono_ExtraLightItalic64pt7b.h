#ifndef _ROBOTOMONO_EXTRALIGHTITALIC64PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x00, 0x18, 0x1C, 0xE0, 0x63, 0x81, 0x8E, 0x0E,
  0x30, 0x38, 0xC0, 0xE3, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0x81, 0xC6, 0x07,
  0x18, 0x18, 0xE0, 0x60, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7C, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x04, 0x1C, 0x01, 0x80,
  0x0C, 0x30, 0x03, 0x80, 0x38, 0x60, 0x06, 0x00, 0xE1, 0xC0, 0x0C, 0x01,
  0x83, 0x80, 0x18, 0x07, 0x06, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0xE0, 0x30,
  0x18, 0x01, 0xC0, 0xE0, 0x30, 0x03, 0x03, 0x80, 0x70, 0x0E, 0x0E, 0x00,
  0x60, 0x38, 0x18, 0x00, 0xE0, 0xE0, 0x70, 0x00, 0xFF, 0xC1, 0xC0, 0x00,
  0xFE, 0x03, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x80, 0x00, 0xE0, 0xFF, 0xC0, 0x03,
  0x83, 0xC3, 0x80, 0x06, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x03, 0x00, 0x70,
  0x30, 0x06, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x01, 0x80, 0x1C, 0x0E, 0x03,
  0x00, 0x38, 0x38, 0x0E, 0x00, 0x60, 0x60, 0x1C, 0x00, 0xC1, 0xC0, 0x30,
  0x01, 0x87, 0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x0E, 0x38, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x30, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x70, 0x0E,
  0x00, 0x31, 0xC0, 0x0E, 0x00, 0xE7, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x1C,
  0x03, 0x38, 0x00, 0x1C, 0x0E, 0x70, 0x00, 0x38, 0x1C, 0xC0, 0x00, 0x38,
  0x73, 0x80, 0x00, 0x38, 0xE7, 0x00, 0x00, 0x73, 0x8E, 0x00, 0x00, 0x7F,
  0x1C, 0x00, 0x00, 0xFC, 0x38, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3D, 0xC0, 0xF0, 0x00, 0xF1, 0xC0,
  0xF8, 0x0F, 0x83, 0x80, 0xFF, 0xFE, 0x03, 0x80, 0x7F, 0xF0, 0x07, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0xCE, 0x73, 0x98, 0xC6, 0x73, 0x98, 0xCE,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x7C, 0x06,
  0x03, 0xEF, 0xF8, 0x61, 0xFF, 0x0F, 0xE6, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0E, 0x38, 0x71, 0xC7, 0x0C, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x7B, 0x38, 0x00,
  0x07, 0x39, 0x80, 0x00, 0x71, 0xDC, 0x00, 0x07, 0x0E, 0xE0, 0x00, 0xF0,
  0x77, 0x00, 0x0F, 0x03, 0xB8, 0x00, 0xE0, 0x19, 0xC0, 0x0E, 0x00, 0xCC,
  0x00, 0xE0, 0x0E, 0xE0, 0x1E, 0x00, 0x77, 0x01, 0xE0, 0x03, 0xB8, 0x1C,
  0x00, 0x1D, 0xC1, 0xC0, 0x00, 0xCC, 0x1C, 0x00, 0x06, 0x61, 0xC0, 0x00,
  0x73, 0x3C, 0x00, 0x03, 0x9B, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0xC7,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x3F, 0x70, 0x7E, 0x38, 0xFC, 0x1D, 0xF0, 0x0C, 0xE0, 0x06, 0x40, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x07, 0x3F, 0xFC, 0x00, 0x06, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x07,
  0xF0, 0x01, 0xC3, 0xFF, 0xC0, 0x18, 0xFF, 0xFE, 0x03, 0x9E, 0x00, 0xF0,
  0x3B, 0x80, 0x07, 0x83, 0x70, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3E, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xEC, 0x1C, 0x00, 0x1D, 0xC1,
  0xE0, 0x07, 0x9C, 0x0F, 0xC3, 0xF1, 0x80, 0x7F, 0xFC, 0x38, 0x01, 0xFF,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0x01, 0xE0, 0x7C, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x30,
  0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07,
  0xF1, 0xF8, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x3F, 0xC0,
  0x30, 0x38, 0x07, 0xFE, 0x03, 0x03, 0x00, 0xE0, 0xF0, 0x30, 0x70, 0x1C,
  0x06, 0x03, 0x06, 0x03, 0x80, 0x60, 0x30, 0xE0, 0x70, 0x06, 0x03, 0x0C,
  0x06, 0x00, 0x60, 0x31, 0xC0, 0xE0, 0x0C, 0x03, 0x18, 0x0C, 0x00, 0xC0,
  0x31, 0x81, 0xC0, 0x0C, 0x03, 0x38, 0x18, 0x01, 0xC0, 0x33, 0x01, 0x80,
  0x18, 0x06, 0x30, 0x38, 0x01, 0x80, 0x67, 0x03, 0x00, 0x18, 0x06, 0x60,
  0x30, 0x03, 0x00, 0x66, 0x03, 0x00, 0x30, 0x0E, 0x60, 0x70, 0x03, 0x00,
  0xC6, 0x06, 0x00, 0x70, 0x0C, 0x60, 0x60, 0x06, 0x00, 0xC6, 0x06, 0x00,
  0xE0, 0x18, 0x60, 0x60, 0x0E, 0x01, 0x86, 0x06, 0x01, 0xE0, 0x30, 0x60,
  0x70, 0x36, 0x03, 0x06, 0x07, 0x06, 0x60, 0x60, 0x60, 0x39, 0xE3, 0x1C,
  0x06, 0x03, 0xF8, 0x3F, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x07, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x07,
  0x80, 0x60, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0E, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0x1F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF3, 0x80, 0x07, 0xFF, 0xE7, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x60, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x30,
  0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x06, 0x0F, 0x00,
  0x00, 0x00, 0x61, 0xE0, 0x00, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x00, 0xE7,
  0x78, 0x00, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x00,
  0x0F, 0x81, 0xC0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x6E, 0x00, 0x03, 0xB0, 0x0D, 0xC0, 0x00, 0x66, 0x01,
  0x98, 0x00, 0x1D, 0xC0, 0x73, 0x00, 0x07, 0x38, 0x0E, 0x60, 0x00, 0xE7,
  0x01, 0xCE, 0x00, 0x38, 0xC0, 0x31, 0xC0, 0x07, 0x18, 0x06, 0x38, 0x01,
  0xC7, 0x00, 0xC3, 0x00, 0x38, 0xE0, 0x38, 0x60, 0x0E, 0x1C, 0x07, 0x0C,
  0x01, 0x83, 0x80, 0xE1, 0xC0, 0x70, 0x60, 0x18, 0x38, 0x0C, 0x0C, 0x03,
  0x03, 0x03, 0x83, 0x80, 0x60, 0x60, 0xE0, 0x70, 0x1C, 0x0C, 0x1C, 0x0E,
  0x03, 0x81, 0xC7, 0x01, 0x80, 0x70, 0x38, 0xE0, 0x30, 0x0C, 0x03, 0x38,
  0x0E, 0x01, 0x80, 0x66, 0x01, 0xC0, 0x70, 0x0D, 0xC0, 0x38, 0x0E, 0x01,
  0xF0, 0x07, 0x01, 0xC0, 0x3E, 0x00, 0xC0, 0x38, 0x07, 0x80, 0x18, 0x06,
  0x00, 0x70, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x00,
  0xF0, 0x00, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x6E, 0x00, 0x00, 0x70, 0x0D, 0xC0, 0x00, 0x0E, 0x03, 0x98, 0x00,
  0x01, 0x80, 0x73, 0x80, 0x00, 0x30, 0x0E, 0x70, 0x00, 0x0E, 0x01, 0xC6,
  0x00, 0x01, 0xC0, 0x30, 0xE0, 0x00, 0x38, 0x06, 0x1C, 0x00, 0x07, 0x01,
  0xC1, 0x80, 0x00, 0xC0, 0x38, 0x38, 0x00, 0x18, 0x07, 0x03, 0x00, 0x07,
  0x00, 0xC0, 0x70, 0x00, 0xE0, 0x18, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0xC0,
  0x03, 0x80, 0xE0, 0x1C, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x60, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x0E, 0x03,
  0x80, 0x0C, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x18, 0x0E,
  0x01, 0xC0, 0x03, 0x81, 0xC0, 0x30, 0x00, 0x70, 0x38, 0x06, 0x00, 0x06,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0xC0, 0x38, 0x00, 0x1C, 0x18, 0x07, 0x00,
  0x01, 0x87, 0x00, 0xE0, 0x00, 0x38, 0xE0, 0x18, 0x00, 0x03, 0x1C, 0x03,
  0x00, 0x00, 0x73, 0x80, 0xE0, 0x00, 0x0E, 0x60, 0x1C, 0x00, 0x00, 0xCC,
  0x03, 0x80, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x00,
  0x3E, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0xF0,
  0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x18, 0x00,
  0x07, 0xC0, 0x1C, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x3C,
  0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x3F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18, 0x00, 0x38, 0x00, 0x76,
  0x00, 0x1E, 0x00, 0x19, 0x80, 0x07, 0x80, 0x0E, 0x60, 0x01, 0xE0, 0x03,
  0x98, 0x00, 0xF8, 0x00, 0xC6, 0x00, 0x3E, 0x00, 0x31, 0x80, 0x0D, 0x80,
  0x1C, 0x60, 0x07, 0x60, 0x06, 0x18, 0x01, 0xD8, 0x01, 0x86, 0x00, 0x66,
  0x00, 0xE1, 0x80, 0x39, 0x80, 0x38, 0x60, 0x0E, 0x60, 0x0C, 0x18, 0x03,
  0x18, 0x07, 0x06, 0x01, 0xC6, 0x01, 0xC1, 0x80, 0x71, 0x80, 0x60, 0x60,
  0x18, 0x60, 0x18, 0x18, 0x0E, 0x18, 0x0E, 0x06, 0x03, 0x06, 0x03, 0x01,
  0x80, 0xC1, 0x80, 0xC0, 0x60, 0x70, 0x60, 0x70, 0x18, 0x18, 0x18, 0x1C,
  0x06, 0x06, 0x06, 0x06, 0x01, 0x83, 0x81, 0x83, 0x80, 0x60, 0xC0, 0x60,
  0xE0, 0x18, 0x30, 0x18, 0x30, 0x06, 0x1C, 0x06, 0x0C, 0x01, 0x86, 0x01,
  0x87, 0x00, 0x61, 0x80, 0x61, 0x80, 0x18, 0xE0, 0x1C, 0x60, 0x06, 0x30,
  0x07, 0x38, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x00, 0x19,
  0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x01, 0xB8, 0x01, 0xD8, 0x00,
  0x6C, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x04,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x3C, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x76, 0x00, 0x01, 0x9C,
  0x00, 0x0E, 0x70, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x01, 0x80, 0x38, 0x07, 0x00, 0xC0,
  0x1C, 0x07, 0x00, 0x70, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x0E,
  0x18, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x00, 0x01, 0x9C, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE1, 0xC1,
  0xC1, 0x83, 0x83, 0x07, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x03, 0x83, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F, 0x87, 0x00, 0x00,
  0xFC, 0x38, 0x00, 0x0E, 0xE0, 0xE0, 0x01, 0xE7, 0x07, 0xC0, 0x3E, 0x38,
  0x1F, 0xFF, 0xC1, 0xC0, 0x3F, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x61, 0xFF, 0xF0, 0x03, 0x1E, 0x07,
  0xC0, 0x3B, 0xC0, 0x0F, 0x01, 0xF8, 0x00, 0x38, 0x0F, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x1F, 0x00, 0x01, 0xC0, 0xF8,
  0x00, 0x1E, 0x06, 0xF0, 0x01, 0xE0, 0x33, 0xC0, 0x3E, 0x03, 0x87, 0xFF,
  0xC0, 0x1C, 0x1F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xF8, 0x18, 0x00, 0x3F, 0xFE, 0x38, 0x00, 0xFC, 0x0F, 0x38,
  0x01, 0xE0, 0x03, 0xB8, 0x03, 0xC0, 0x01, 0xB8, 0x07, 0x80, 0x00, 0xF8,
  0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1F, 0x00,
  0x1C, 0x00, 0x7B, 0x00, 0x0F, 0x01, 0xF3, 0x00, 0x07, 0xFF, 0xC7, 0x00,
  0x03, 0xFF, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3C,
  0x00, 0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x07, 0x00, 0x0F, 0xFF, 0x86, 0x00, 0x3F, 0x03,
  0xCE, 0x00, 0x78, 0x00, 0xEE, 0x00, 0xF0, 0x00, 0x6E, 0x01, 0xE0, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x07,
  0xC0, 0x07, 0x00, 0x1E, 0xC0, 0x03, 0xC0, 0x7C, 0xC0, 0x01, 0xFF, 0xF1,
  0xC0, 0x00, 0xFF, 0xC1, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x20, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x60, 0xFF, 0xF8, 0x07,
  0x0F, 0x03, 0xE0, 0x39, 0xE0, 0x07, 0x81, 0xDC, 0x00, 0x1C, 0x0C, 0xC0,
  0x00, 0x70, 0x6C, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x81, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x60, 0x01, 0xE0,
  0x00, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x7C,
  0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x8F, 0xF0,
  0x3F, 0xC0, 0x19, 0xFF, 0xC3, 0xFF, 0x00, 0xDE, 0x0F, 0x3C, 0x3C, 0x07,
  0xC0, 0x3B, 0x80, 0xE0, 0x3C, 0x01, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x80,
  0x1C, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0x07, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x00, 0x0C,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0xE0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0xE0, 0x01, 0xC1, 0x80, 0x07, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x38, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x60, 0x01, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x18, 0x38,
  0x00, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x60, 0x01, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x01, 0xFF, 0x00, 0x38, 0x3F, 0xFE, 0x01, 0xC3, 0xC0, 0xF8, 0x0E, 0x78,
  0x01, 0xE0, 0x67, 0x00, 0x07, 0x03, 0x70, 0x00, 0x1C, 0x1B, 0x00, 0x00,
  0xE1, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x01, 0x87, 0xFF, 0xC0, 0x03,
  0x3E, 0x07, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x03, 0x80, 0x3E,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x03, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x78, 0x06,
  0xE0, 0x01, 0xE0, 0x1C, 0xF0, 0x0F, 0x80, 0x38, 0xFF, 0xFC, 0x00, 0x70,
  0x7F, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x18, 0x01, 0xFF,
  0xF0, 0xC0, 0x3F, 0x03, 0xCE, 0x03, 0xC0, 0x07, 0x70, 0x3C, 0x00, 0x1B,
  0x83, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0xF8, 0x1C, 0x00, 0x0F, 0x80, 0x70, 0x01, 0xEC, 0x01, 0xE0,
  0x3E, 0x60, 0x07, 0xFF, 0xC7, 0x00, 0x1F, 0xF8, 0x38, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0xFF,
  0xE0, 0x60, 0x7F, 0xFC, 0x0C, 0x3F, 0x81, 0x83, 0x8F, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x1F, 0x80,
  0xE0, 0x03, 0xDC, 0x07, 0x80, 0x78, 0xC0, 0x1F, 0xFF, 0x86, 0x00, 0x3F,
  0xF0, 0x70, 0x00, 0x74, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x06,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0xEC, 0x00, 0x3C, 0x00, 0x76, 0x00,
  0x36, 0x00, 0x33, 0x80, 0x1B, 0x00, 0x39, 0xC0, 0x1D, 0x80, 0x18, 0xE0,
  0x0C, 0xC0, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0x38, 0x07, 0x30, 0x06, 0x1C,
  0x03, 0x18, 0x07, 0x0E, 0x03, 0x8C, 0x03, 0x07, 0x01, 0x86, 0x01, 0x83,
  0x81, 0xC3, 0x01, 0xC1, 0xC0, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0xE0, 0xE0,
  0x30, 0x70, 0x70, 0x60, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x38, 0x0C, 0x38,
  0x06, 0x18, 0x06, 0x18, 0x03, 0x1C, 0x03, 0x1C, 0x01, 0x8C, 0x01, 0x8E,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x67, 0x00, 0x33, 0x00, 0x33,
  0x00, 0x1B, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x1C,
  0x3C, 0x3E, 0x00, 0x03, 0x0E, 0x01, 0xE0, 0x00, 0x63, 0x80, 0x1E, 0x00,
  0x1C, 0x60, 0x01, 0xE0, 0x07, 0x1C, 0x00, 0x1E, 0x01, 0xE3, 0x00, 0x01,
  0xF0, 0x78, 0x60, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 11, 46, 38, 13, -46 },
  { 65, 14, 13, 38, 15, -48 },
  { 88, 37, 45, 38, 1, -45 },
  { 297, 31, 59, 38, 4, -52 },
  { 526, 31, 47, 38, 4, -46 },
  { 709, 31, 47, 38, 3, -46 },
  { 892, 5, 13, 38, 18, -48 },
  { 901, 20, 66, 38, 11, -51 },
  { 1066, 19, 66, 38, 6, -51 },
  { 1223, 28, 27, 38, 8, -46 },
  { 1318, 31, 33, 38, 4, -38 },
  { 1446, 7, 14, 38, 8, -5 },
  { 1459, 23, 3, 38, 7, -22 },
  { 1468, 5, 5, 38, 14, -5 },
  { 1472, 30, 49, 38, 5, -45 },
  { 1656, 29, 47, 38, 5, -46 },
  { 1827, 17, 46, 38, 10, -46 },
  { 1925, 31, 46, 38, 1, -46 },
  { 2104, 31, 47, 38, 2, -46 },
  { 2287, 31, 46, 38, 2, -46 },
  { 2466, 32, 47, 38, 5, -46 },
  { 2654, 28, 47, 38, 4, -46 },
  { 2819, 29, 46, 38, 8, -46 },
  { 2986, 31, 47, 38, 4, -46 },
  { 3169, 28, 46, 38, 6, -46 },
  { 3330, 10, 32, 38, 16, -32 },
  { 3370, 14, 41, 38, 12, -32 },
  { 3442, 29, 26, 38, 5, -34 },
  { 3537, 30, 15, 38, 4, -28 },
  { 3594, 29, 26, 38, 4, -34 },
  { 3689, 24, 46, 38, 10, -46 },
  { 3827, 36, 46, 38, 1, -46 },
  { 4034, 31, 46, 38, 0, -46 },
  { 4213, 32, 46, 38, 3, -46 },
  { 4397, 31, 47, 38, 4, -46 },
  { 4580, 33, 46, 38, 2, -46 },
  { 4770, 34, 46, 38, 3, -46 },
  { 4966, 34, 46, 38, 3, -46 },
  { 5162, 31, 47, 38, 4, -46 },
  { 5345, 35, 46, 38, 2, -46 },
  { 5547, 33, 46, 38, 3, -46 },
  { 5737, 33, 47, 38, 2, -46 },
  { 5931, 36, 46, 38, 3, -46 },
  { 6138, 26, 46, 38, 4, -46 },
  { 6288, 35, 46, 38, 2, -46 },
  { 6490, 35, 46, 38, 2, -46 },
  { 6692, 31, 47, 38, 4, -46 },
  { 6875, 33, 46, 38, 4, -46 },
  { 7065, 33, 54, 38, 3, -46 },
  { 7288, 32, 46, 38, 3, -46 },
  { 7472, 33, 47, 38, 3, -46 },
  { 7666, 32, 46, 38, 7, -46 },
  { 7850, 33, 47, 38, 4, -46 },
  { 8044, 31, 46, 38, 7, -46 },
  { 8223, 34, 46, 38, 6, -46 },
  { 8419, 38, 46, 38, 1, -46 },
  { 8638, 32, 46, 38, 7, -46 },
  { 8822, 34, 46, 38, 1, -46 },
  { 9018, 19, 62, 38, 10, -52 },
  { 9166, 12, 50, 38, 13, -46 },
  { 9241, 19, 62, 38, 9, -52 },
  { 9389, 22, 25, 38, 8, -46 },
  { 9458, 26, 2, 38, 2, 0 },
  { 9465, 7, 8, 38, 19, -47 },
  { 9472, 29, 35, 38, 3, -34 },
  { 9599, 29, 49, 38, 3, -48 },
  { 9777, 29, 35, 38, 4, -34 },
  { 9904, 32, 49, 38, 4, -48 },
  { 10100, 29, 35, 38, 4, -34 },
  { 10227, 31, 49, 38, 8, -49 },
  { 10417, 32, 48, 38, 2, -34 },
  { 10609, 29, 48, 38, 3, -48 },
  { 10783, 26, 46, 38, 4, -46 },
  { 10933, 29, 60, 38, 0, -46 },
  { 11151, 31, 48, 38, 4, -48 },
  { 11337, 26, 48, 38, 4, -48 },
  { 11493, 37, 34, 38, -1, -34 },
  { 11651, 29, 34, 38, 3, -34 },
  { 11775, 30, 35, 38, 3, -34 },
  { 11907, 31, 47, 38, 1, -34 },
  { 12090, 29, 47, 38, 4, -34 },
  { 12261, 27, 34, 38, 8, -34 },
  { 12376, 29, 35, 38, 4, -34 },
  { 12503, 24, 44, 38, 8, -43 },
  { 12635, 29, 35, 38, 5, -34 },
  { 12762, 30, 34, 38, 6, -34 },
  { 12890, 33, 34, 38, 5, -34 },
  { 13031, 35, 34, 38, 1, -34 },
  { 13180, 38, 48, 38, -1, -34 },
  { 13408, 33, 34, 38, 1, -34 },
  { 13549, 25, 63, 38, 10, -50 },
  { 13746, 11, 55, 38, 13, -46 },
  { 13822, 25, 63, 38, 5, -50 },
  { 14019, 35, 10, 38, 1, -24 },
};

const GFXfont RobotoMono_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC64PT7B_H_
