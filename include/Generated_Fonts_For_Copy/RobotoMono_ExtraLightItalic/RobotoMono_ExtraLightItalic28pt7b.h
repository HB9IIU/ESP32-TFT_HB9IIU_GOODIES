#ifndef _ROBOTOMONO_EXTRALIGHTITALIC28PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x13, 0x22, 0x22, 0x66, 0x44, 0x00, 0x00, 0x8C, 0x4E,
  0x63, 0x18, 0xC8, 0x00, 0x42, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x80,
  0x10, 0x40, 0x08, 0x60, 0x7F, 0xFE, 0x04, 0x10, 0x02, 0x18, 0x01, 0x08,
  0x01, 0x04, 0x00, 0x84, 0x00, 0xC2, 0x07, 0xFF, 0xE0, 0x21, 0x00, 0x30,
  0x80, 0x10, 0x40, 0x08, 0x40, 0x08, 0x20, 0x04, 0x30, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x0F, 0xC0, 0xC3, 0x0C, 0x0C, 0x40, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x04,
  0x00, 0x34, 0x00, 0xA0, 0x0D, 0x00, 0x4C, 0x06, 0x30, 0x60, 0xFE, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x00, 0x3C, 0x02, 0x20, 0x21, 0x85, 0x04, 0x68,
  0x42, 0x42, 0x22, 0x13, 0x11, 0x10, 0x71, 0x00, 0x10, 0x00, 0x80, 0x08,
  0xE0, 0x89, 0x8C, 0x84, 0x44, 0x24, 0x61, 0x62, 0x0A, 0x10, 0xC0, 0x44,
  0x03, 0xC0, 0x03, 0xE0, 0x18, 0x80, 0xC3, 0x02, 0x04, 0x08, 0x20, 0x20,
  0x80, 0x8C, 0x03, 0x60, 0x07, 0x00, 0x18, 0x01, 0xA0, 0x0C, 0x41, 0x21,
  0x85, 0x02, 0x24, 0x04, 0xB0, 0x1E, 0xC0, 0x31, 0x01, 0xC6, 0x0D, 0x0F,
  0xC2, 0x55, 0xA0, 0x01, 0x02, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x40, 0x80, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0xC4, 0x73, 0xF8, 0x0C, 0x00, 0xA0, 0x12,
  0x02, 0x10, 0xC1, 0x84, 0x08, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x32, 0x26, 0x4C, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x00, 0x07,
  0xE0, 0x61, 0x84, 0x04, 0x60, 0x12, 0x00, 0xB0, 0x0D, 0x00, 0xE8, 0x09,
  0x40, 0x8A, 0x18, 0xF1, 0x85, 0x18, 0x29, 0x01, 0x50, 0x0B, 0x00, 0xD0,
  0x04, 0x80, 0x62, 0x02, 0x18, 0x60, 0x7E, 0x00, 0x03, 0x0E, 0x32, 0xC2,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x07, 0xE0, 0x61, 0x84, 0x04, 0x40, 0x32, 0x00,
  0xB0, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0xFF,
  0xE0, 0x07, 0xE0, 0x60, 0x86, 0x02, 0x60, 0x12, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x60, 0x3E, 0x00, 0x70, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x50, 0x06, 0x80, 0x26, 0x03, 0x18, 0x30, 0x7E, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xA0, 0x09, 0x00, 0x88, 0x08, 0x80, 0xC4, 0x0C,
  0x20, 0xC1, 0x04, 0x08, 0x40, 0xC4, 0x04, 0x60, 0x23, 0xFF, 0xE0, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0xE0, 0x3F, 0xC0, 0xC0,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x30, 0x0C, 0x40,
  0x21, 0x01, 0x82, 0x0C, 0x07, 0xC0, 0x00, 0xE0, 0x30, 0x0C, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0xF8, 0x58, 0x4E, 0x02, 0xC0, 0x28, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x28, 0x02, 0x80, 0x64, 0x04, 0x61, 0x83, 0xF0,
  0xFF, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x60,
  0x86, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x26, 0x02, 0x10, 0x20,
  0x7E, 0x07, 0x30, 0x40, 0x44, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x36, 0x03, 0x18, 0x30, 0x7F, 0x00, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x02,
  0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0xC0, 0x64, 0x0A,
  0x3F, 0x60, 0x84, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x0C, 0x0F, 0x80,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x82, 0x18, 0x42, 0x00, 0x00, 0x08, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x40, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x40, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x08, 0x00, 0x1F, 0x86, 0x19,
  0x81, 0x20, 0x3C, 0x06, 0x00, 0x80, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x01, 0xF8, 0x0C, 0x18, 0x30, 0x18, 0x80, 0x13, 0x1E, 0x24, 0x66,
  0x51, 0x88, 0xA2, 0x11, 0x48, 0x23, 0x10, 0x86, 0x21, 0x0C, 0x42, 0x29,
  0x0C, 0x52, 0x18, 0xA2, 0x52, 0x47, 0x38, 0x80, 0x00, 0x80, 0x01, 0x81,
  0x00, 0xFC, 0x00, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xB0,
  0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x41, 0x02, 0x06,
  0x08, 0x08, 0x7F, 0xE1, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00,
  0xF0, 0x01, 0x0F, 0xE0, 0x60, 0xE1, 0x80, 0xC4, 0x01, 0x10, 0x04, 0x40,
  0x11, 0x00, 0xCC, 0x02, 0x20, 0x30, 0xFF, 0x02, 0x07, 0x08, 0x06, 0x20,
  0x09, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0xC4, 0x0E, 0x3F,
  0xE0, 0x07, 0xE0, 0x61, 0x84, 0x06, 0x60, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x50, 0x06, 0x80, 0x22, 0x02, 0x18, 0x20, 0x7E, 0x00, 0x1F, 0xC0,
  0x40, 0xC1, 0x01, 0x84, 0x03, 0x10, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x60, 0x0D, 0x00, 0x24, 0x00,
  0x90, 0x04, 0x40, 0x33, 0x01, 0x8C, 0x1C, 0x3F, 0xC0, 0x0F, 0xFE, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xE0, 0x30, 0xC1, 0x01, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x34,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0xFE, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x31, 0x00, 0xC6, 0x06, 0x0F, 0xE0,
  0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x33, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x7F, 0xF1, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x20, 0x08, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x80, 0x0F, 0xFE, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x21, 0x01, 0x86,
  0x0C, 0x0F, 0xC0, 0x08, 0x03, 0x08, 0x06, 0x18, 0x0C, 0x10, 0x18, 0x10,
  0x30, 0x10, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x32, 0x00, 0x26, 0x00, 0x2B,
  0x00, 0x31, 0x00, 0x20, 0x80, 0x20, 0x80, 0x60, 0x40, 0x40, 0x60, 0x40,
  0x20, 0x40, 0x30, 0x40, 0x10, 0xC0, 0x08, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x38, 0xE0, 0x51, 0x41, 0x66, 0x82, 0x89, 0x09,
  0x12, 0x12, 0x24, 0x44, 0x45, 0x88, 0x8A, 0x33, 0x1C, 0x44, 0x30, 0x88,
  0x41, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x11, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x80, 0x18, 0x02, 0x30, 0x04, 0x60, 0x08, 0xA0, 0x31, 0x40, 0x46, 0x80,
  0x88, 0x81, 0x11, 0x02, 0x22, 0x0C, 0x42, 0x11, 0x84, 0x22, 0x0C, 0x44,
  0x08, 0x88, 0x11, 0x10, 0x16, 0x20, 0x28, 0xC0, 0x51, 0x00, 0x62, 0x00,
  0xC4, 0x01, 0x80, 0x07, 0xE0, 0x61, 0x84, 0x04, 0x60, 0x12, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x62, 0x02, 0x18, 0x60, 0x7E, 0x00,
  0x1F, 0xE0, 0x40, 0xE1, 0x00, 0x8C, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x03, 0x20, 0x09, 0x80, 0x44, 0x0E, 0x1F, 0xC0, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03,
  0xF0, 0x0C, 0x30, 0x20, 0x30, 0x80, 0x23, 0x00, 0x44, 0x00, 0xC8, 0x01,
  0xA0, 0x03, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x2C, 0x00, 0x58,
  0x01, 0x30, 0x02, 0x20, 0x0C, 0x40, 0x10, 0xC0, 0x40, 0xC1, 0x00, 0xFC,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x0F, 0xE0, 0x20, 0x61,
  0x80, 0xC4, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x03, 0x30, 0x08,
  0x80, 0x42, 0x0E, 0x0F, 0xE0, 0x20, 0x40, 0x81, 0x06, 0x06, 0x10, 0x08,
  0x40, 0x21, 0x00, 0xC4, 0x01, 0x30, 0x06, 0x03, 0xF0, 0x1C, 0x30, 0x20,
  0x30, 0x80, 0x21, 0x00, 0x62, 0x00, 0xC4, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x60,
  0x04, 0x40, 0x18, 0xC0, 0x20, 0xC1, 0x80, 0xFE, 0x00, 0xFF, 0xFC, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x6C, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x08,
  0x80, 0x63, 0x01, 0x06, 0x18, 0x0F, 0xC0, 0x80, 0x0F, 0x00, 0x2C, 0x01,
  0x90, 0x04, 0x40, 0x31, 0x00, 0x84, 0x06, 0x10, 0x10, 0x60, 0x40, 0x82,
  0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x88, 0x03, 0x20, 0x05, 0x80, 0x14,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC2, 0x85, 0x0A, 0x14, 0x28, 0xD1, 0xA2, 0x44, 0x89, 0x12, 0x64, 0x49,
  0x12, 0x24, 0x48, 0xB1, 0x22, 0x85, 0x0A, 0x14, 0x38, 0x50, 0xC1, 0xC3,
  0x06, 0x0C, 0x18, 0x20, 0x60, 0x08, 0x01, 0x86, 0x01, 0x81, 0x00, 0x80,
  0x80, 0x80, 0x20, 0xC0, 0x10, 0xC0, 0x0C, 0x40, 0x02, 0x40, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x28, 0x00, 0x26, 0x00, 0x31, 0x00, 0x30,
  0x80, 0x10, 0x20, 0x10, 0x10, 0x18, 0x0C, 0x18, 0x02, 0x18, 0x01, 0x80,
  0xC0, 0x0D, 0x00, 0x24, 0x01, 0x18, 0x0C, 0x20, 0x20, 0x81, 0x02, 0x0C,
  0x04, 0x20, 0x11, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x1F,
  0xFC, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x3F, 0xFC, 0x0F, 0x84,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x3E, 0x00, 0x84, 0x21, 0x0C, 0x21, 0x08, 0x43, 0x08,
  0x42, 0x10, 0xC2, 0x10, 0x84, 0x30, 0x84, 0x0F, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xF0, 0x03, 0x00,
  0xC0, 0x50, 0x14, 0x08, 0x82, 0x21, 0x08, 0xC2, 0x20, 0xD8, 0x1C, 0x04,
  0xFF, 0xE0, 0xC9, 0x90, 0x03, 0xE0, 0x61, 0x84, 0x06, 0x60, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x23, 0xFF, 0x30, 0x13, 0x00, 0x90, 0x04, 0x80, 0x64,
  0x07, 0x30, 0x78, 0xFC, 0xC0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x4F, 0x82, 0x86, 0x18, 0x19, 0x80, 0x48, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x03, 0x40, 0x12, 0x01, 0x98, 0x08,
  0xE1, 0x8D, 0xF8, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x32, 0x01, 0x40, 0x14,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x02, 0x40, 0x46,
  0x0C, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0xF9, 0x86, 0x14, 0x30, 0x31, 0x80, 0x44, 0x01, 0x10, 0x04,
  0xC0, 0x32, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x8C, 0x06,
  0x18, 0x70, 0x3E, 0x40, 0x07, 0xC1, 0x86, 0x30, 0x36, 0x01, 0x40, 0x1C,
  0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x26,
  0x0C, 0x1F, 0x80, 0x01, 0xF8, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x03, 0xFF, 0x83, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x07, 0xCC, 0x30, 0xA1, 0x81, 0x8C, 0x02, 0x20, 0x08, 0x80,
  0x26, 0x01, 0x90, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x0C, 0x60,
  0x30, 0xC3, 0x81, 0xFA, 0x00, 0x08, 0x00, 0x60, 0x01, 0x0C, 0x0C, 0x18,
  0xE0, 0x3E, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x47, 0x82, 0xC2, 0x38, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00,
  0x90, 0x05, 0x80, 0x68, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x6C,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x64, 0x06, 0x20, 0x41, 0x0C, 0x08, 0xC0, 0xCC, 0x04, 0x80, 0x3A, 0x01,
  0x98, 0x08, 0x40, 0xC1, 0x06, 0x0C, 0x20, 0x21, 0x00, 0x88, 0x06, 0x00,
  0x1F, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x0F, 0xFE, 0x27, 0x1E, 0x38, 0xA2, 0x30, 0xC1, 0x20,
  0x81, 0x20, 0x83, 0x60, 0x82, 0x40, 0x82, 0x41, 0x82, 0x41, 0x02, 0x41,
  0x02, 0x41, 0x06, 0x81, 0x04, 0x81, 0x04, 0x83, 0x04, 0x82, 0x04, 0x11,
  0xE0, 0xB0, 0x8E, 0x02, 0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03,
  0x60, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x1B, 0x00, 0x80,
  0x07, 0xE0, 0x30, 0xC1, 0x81, 0x8C, 0x02, 0x20, 0x09, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x90, 0x04, 0x60, 0x20, 0xC3,
  0x01, 0xF8, 0x00, 0x09, 0xF0, 0x38, 0x61, 0xC0, 0x86, 0x01, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x30, 0x04, 0x80, 0x22, 0x00, 0x88, 0x06,
  0x30, 0x10, 0xE1, 0x86, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x0F, 0x98, 0xC2, 0x8C, 0x0C, 0xC0, 0x24, 0x01,
  0x20, 0x0B, 0x00, 0xD0, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xCC,
  0x06, 0x30, 0xE0, 0xFD, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x23, 0xE5, 0xC0, 0xE0, 0x18, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x0F, 0xC0, 0xC1, 0x88, 0x04, 0x40, 0x22, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x00, 0x09, 0x00, 0x48, 0x02, 0x20, 0x60, 0xFE,
  0x00, 0x06, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xFE, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x3E, 0x00, 0x20, 0x09, 0x00, 0xD8, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x06, 0xC0, 0x24, 0x01, 0x20, 0x09, 0x00, 0xCC,
  0x06, 0x20, 0xF0, 0xF9, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x44,
  0x04, 0x20, 0x21, 0x02, 0x0C, 0x30, 0x21, 0x01, 0x18, 0x08, 0x80, 0x68,
  0x01, 0x40, 0x0C, 0x00, 0x60, 0x00, 0x81, 0x07, 0x06, 0x0A, 0x0C, 0x14,
  0x18, 0x48, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x88, 0xD9, 0x31, 0xA1,
  0x41, 0x42, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x00, 0x30,
  0x06, 0x20, 0x10, 0x20, 0x60, 0x61, 0x80, 0x46, 0x00, 0xD8, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x80, 0x09, 0x00, 0x23, 0x00, 0x82, 0x02, 0x02, 0x08,
  0x06, 0x30, 0x04, 0x00, 0x30, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x04,
  0x18, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x20, 0x04, 0x60,
  0x04, 0x40, 0x06, 0xC0, 0x02, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x20, 0x18, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x81, 0xC0, 0x38, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x00, 0xC0, 0x38, 0x08, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x02, 0x01, 0x80, 0x40, 0x00, 0x18, 0x00,
  0xDC, 0x0F, 0x0C, 0x14, 0x0C, 0x68, 0x0F, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 5, 6, 16, 7, -21 },
  { 15, 17, 20, 16, 0, -20 },
  { 58, 13, 26, 16, 2, -23 },
  { 101, 13, 20, 16, 2, -20 },
  { 134, 14, 20, 16, 1, -20 },
  { 169, 2, 6, 16, 8, -21 },
  { 171, 8, 28, 16, 5, -22 },
  { 199, 8, 28, 16, 3, -22 },
  { 227, 12, 12, 16, 4, -20 },
  { 245, 13, 14, 16, 2, -16 },
  { 268, 4, 6, 16, 3, -2 },
  { 271, 10, 2, 16, 3, -10 },
  { 274, 2, 2, 16, 6, -2 },
  { 275, 13, 22, 16, 2, -20 },
  { 311, 13, 20, 16, 2, -20 },
  { 344, 8, 20, 16, 4, -20 },
  { 364, 13, 20, 16, 1, -20 },
  { 397, 13, 20, 16, 1, -20 },
  { 430, 13, 20, 16, 1, -20 },
  { 463, 14, 20, 16, 2, -20 },
  { 498, 12, 20, 16, 2, -20 },
  { 528, 13, 20, 16, 3, -20 },
  { 561, 13, 20, 16, 2, -20 },
  { 594, 12, 20, 16, 3, -20 },
  { 624, 4, 14, 16, 7, -14 },
  { 631, 6, 18, 16, 5, -14 },
  { 645, 13, 12, 16, 2, -15 },
  { 665, 13, 6, 16, 2, -12 },
  { 675, 12, 12, 16, 2, -15 },
  { 693, 11, 20, 16, 4, -20 },
  { 721, 15, 20, 16, 1, -20 },
  { 759, 14, 20, 16, 0, -20 },
  { 794, 14, 20, 16, 1, -20 },
  { 829, 13, 20, 16, 2, -20 },
  { 862, 14, 20, 16, 1, -20 },
  { 897, 15, 20, 16, 1, -20 },
  { 935, 15, 20, 16, 1, -20 },
  { 973, 14, 20, 16, 2, -20 },
  { 1008, 15, 20, 16, 1, -20 },
  { 1046, 15, 20, 16, 1, -20 },
  { 1084, 14, 20, 16, 1, -20 },
  { 1119, 16, 20, 16, 1, -20 },
  { 1159, 11, 20, 16, 2, -20 },
  { 1187, 15, 20, 16, 1, -20 },
  { 1225, 15, 20, 16, 1, -20 },
  { 1263, 13, 20, 16, 2, -20 },
  { 1296, 14, 20, 16, 2, -20 },
  { 1331, 15, 24, 16, 1, -20 },
  { 1376, 14, 20, 16, 1, -20 },
  { 1411, 15, 20, 16, 1, -20 },
  { 1449, 14, 20, 16, 3, -20 },
  { 1484, 14, 20, 16, 2, -20 },
  { 1519, 14, 20, 16, 3, -20 },
  { 1554, 14, 20, 16, 3, -20 },
  { 1589, 17, 20, 16, 0, -20 },
  { 1632, 14, 20, 16, 3, -20 },
  { 1667, 14, 20, 16, 1, -20 },
  { 1702, 9, 27, 16, 4, -23 },
  { 1733, 5, 22, 16, 6, -20 },
  { 1747, 8, 27, 16, 4, -23 },
  { 1774, 10, 11, 16, 3, -20 },
  { 1788, 11, 1, 16, 1, 0 },
  { 1790, 3, 4, 16, 8, -21 },
  { 1792, 13, 15, 16, 1, -15 },
  { 1817, 13, 21, 16, 1, -21 },
  { 1852, 12, 15, 16, 2, -15 },
  { 1875, 14, 21, 16, 2, -21 },
  { 1912, 12, 15, 16, 2, -15 },
  { 1935, 13, 21, 16, 4, -21 },
  { 1970, 14, 21, 16, 1, -15 },
  { 2007, 13, 21, 16, 1, -21 },
  { 2042, 11, 20, 16, 2, -20 },
  { 2070, 13, 26, 16, 0, -20 },
  { 2113, 13, 21, 16, 2, -21 },
  { 2148, 11, 21, 16, 2, -21 },
  { 2177, 16, 15, 16, 0, -15 },
  { 2207, 13, 15, 16, 1, -15 },
  { 2232, 14, 15, 16, 1, -15 },
  { 2259, 14, 21, 16, 0, -15 },
  { 2296, 13, 21, 16, 2, -15 },
  { 2331, 11, 15, 16, 4, -15 },
  { 2352, 13, 15, 16, 2, -15 },
  { 2377, 11, 19, 16, 3, -19 },
  { 2404, 13, 15, 16, 2, -15 },
  { 2429, 13, 15, 16, 3, -15 },
  { 2454, 15, 15, 16, 2, -15 },
  { 2483, 15, 15, 16, 1, -15 },
  { 2512, 16, 21, 16, 0, -15 },
  { 2554, 14, 15, 16, 1, -15 },
  { 2581, 11, 28, 16, 4, -22 },
  { 2620, 5, 24, 16, 6, -20 },
  { 2635, 11, 28, 16, 2, -22 },
  { 2674, 15, 5, 16, 1, -11 },
};

const GFXfont RobotoMono_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC28PT7B_H_
