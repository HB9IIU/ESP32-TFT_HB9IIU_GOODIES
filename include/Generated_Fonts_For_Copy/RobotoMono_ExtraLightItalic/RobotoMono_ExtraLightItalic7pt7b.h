#ifndef _ROBOTOMONO_EXTRALIGHTITALIC7PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0x80, 0x37, 0x6F, 0xA0, 0x25, 0x42, 0x1A, 0x40, 0xDE,
  0x25, 0xB0, 0x66, 0x4B, 0xF0, 0x80, 0x5A, 0xA9, 0x95, 0x5A, 0x5F, 0x00,
  0x2B, 0x44, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x79, 0xBD, 0xE0, 0xD5, 0x80,
  0x64, 0xAE, 0x71, 0x61, 0xE0, 0x22, 0x6F, 0x20, 0xF1, 0x9C, 0x6A, 0xDE,
  0xE5, 0x48, 0x75, 0x69, 0xE0, 0xF6, 0xBC, 0x90, 0x42, 0x80, 0x71, 0x00,
  0x7E, 0x43, 0xE0, 0xE5, 0x48, 0x7F, 0xBB, 0xE0, 0x2D, 0xBA, 0x75, 0x69,
  0xE0, 0x79, 0x89, 0xE0, 0x75, 0x99, 0xE0, 0x74, 0x68, 0xE0, 0x74, 0x68,
  0x80, 0x78, 0xA9, 0xF0, 0x59, 0x79, 0x90, 0x72, 0x24, 0xE0, 0x11, 0x11,
  0xE0, 0x56, 0x4A, 0x90, 0x4A, 0x4E, 0x57, 0xB9, 0x90, 0x5D, 0xBA, 0xA0,
  0x79, 0x99, 0xE0, 0x75, 0xF8, 0x80, 0x79, 0x99, 0xE2, 0x75, 0xEA, 0x90,
  0x74, 0x21, 0xE0, 0xE9, 0x48, 0x59, 0x99, 0xE0, 0xB7, 0x68, 0xFE, 0xEC,
  0x56, 0x26, 0x90, 0xB5, 0x48, 0x72, 0x44, 0xE0, 0x5A, 0xA8, 0xA5, 0x40,
  0x55, 0x58, 0x7C, 0xE0, 0x80, 0x61, 0xFE, 0x46, 0x99, 0xE0, 0x69, 0x8E,
  0x17, 0x99, 0xE0, 0x6F, 0x8E, 0x7E, 0x48, 0x79, 0x9A, 0xE0, 0x46, 0x99,
  0x90, 0x2C, 0x9E, 0x2C, 0x92, 0xA0, 0x45, 0x6A, 0xA0, 0x64, 0x9E, 0x5B,
  0xDD, 0x69, 0x99, 0x69, 0x9E, 0x69, 0x9E, 0x80, 0x79, 0x9E, 0x20, 0xF2,
  0x40, 0x65, 0x2E, 0x5E, 0x4C, 0xB6, 0xE0, 0xB7, 0x40, 0xBF, 0x60, 0x52,
  0x4A, 0x95, 0x64, 0x48, 0x72, 0x4E, 0x69, 0x49, 0x80, 0x56, 0xA0, 0x55,
  0xA0, 0xD2,
};

const GFXglyph RobotoMono_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 1, 1, 4, 2, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 1, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 3, 5, 4, 1, -5 },
  { 31, 4, 5, 4, 0, -5 },
  { 34, 2, 5, 4, 1, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 1, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 3, 5, 4, 1, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 3, 5, 4, 1, -5 },
  { 55, 1, 4, 4, 2, -4 },
  { 56, 2, 5, 4, 1, -4 },
  { 58, 3, 3, 4, 1, -4 },
  { 60, 4, 2, 4, 0, -3 },
  { 61, 4, 3, 4, 0, -4 },
  { 63, 3, 5, 4, 1, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 3, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 3, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 6, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 3, 5, 4, 1, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 3, 5, 4, 1, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 2, 7, 4, 1, -6 },
  { 142, 2, 5, 4, 1, -5 },
  { 144, 2, 7, 4, 1, -6 },
  { 146, 2, 3, 4, 1, -5 },
  { 147, 3, 1, 4, 0, 0 },
  { 148, 1, 1, 4, 2, -5 },
  { 149, 4, 4, 4, 0, -4 },
  { 151, 4, 5, 4, 0, -5 },
  { 154, 4, 4, 4, 0, -4 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 3, 5, 4, 1, -5 },
  { 163, 4, 5, 4, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 3, 5, 4, 0, -5 },
  { 171, 3, 7, 4, 0, -5 },
  { 174, 4, 5, 4, 0, -5 },
  { 177, 3, 5, 4, 0, -5 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 4, 5, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -4 },
  { 191, 3, 4, 4, 1, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 3, 5, 4, 1, -5 },
  { 197, 3, 4, 4, 1, -4 },
  { 199, 3, 4, 4, 1, -4 },
  { 201, 3, 4, 4, 1, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 6, 4, 0, -4 },
  { 208, 4, 4, 4, 0, -4 },
  { 210, 3, 6, 4, 1, -5 },
  { 213, 2, 6, 4, 1, -5 },
  { 215, 2, 6, 4, 1, -5 },
  { 217, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC7PT7B_H_
