#ifndef _ROBOTOMONO_EXTRALIGHTITALIC10PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xFC, 0x14, 0xA7, 0xCA, 0xF9, 0x46, 0x00, 0x25, 0x98,
  0x61, 0x9A, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x3A, 0x4C, 0x45, 0xC5, 0xE0,
  0xE0, 0x2A, 0x49, 0x24, 0x90, 0x44, 0x92, 0x4A, 0x50, 0x27, 0xC8, 0xA0,
  0x22, 0xF4, 0x40, 0xC0, 0xF0, 0x80, 0x11, 0x22, 0x44, 0x88, 0x79, 0x9F,
  0x99, 0xE0, 0xD5, 0x68, 0x7A, 0x42, 0x22, 0x23, 0xC0, 0x7A, 0x42, 0x60,
  0xC5, 0xC0, 0x08, 0xCA, 0x9F, 0x88, 0x40, 0x7A, 0x38, 0x21, 0x4B, 0x80,
  0x78, 0xE9, 0x99, 0xE0, 0xF8, 0x84, 0x44, 0x22, 0x00, 0x74, 0x64, 0xC9,
  0x4B, 0x80, 0x79, 0x99, 0x71, 0xE0, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x43,
  0xFF, 0xC3, 0x68, 0xF4, 0xA8, 0x20, 0x3D, 0x5A, 0xF5, 0xD6, 0xA7, 0x00,
  0x11, 0x8A, 0x97, 0xC6, 0x20, 0x7A, 0x52, 0xE4, 0xC7, 0xC0, 0x74, 0x61,
  0x08, 0x4B, 0x80, 0x79, 0x14, 0x51, 0x4A, 0x2F, 0x00, 0x7D, 0x04, 0x1E,
  0x42, 0x0F, 0x80, 0xFC, 0x21, 0xE8, 0x42, 0x00, 0x74, 0x61, 0x49, 0x4B,
  0xC0, 0x45, 0x14, 0x5E, 0x8A, 0x28, 0x80, 0x3C, 0x41, 0x08, 0x20, 0x8F,
  0x00, 0x04, 0x10, 0x82, 0x0A, 0x27, 0x00, 0x8C, 0xA9, 0x8A, 0x52, 0x40,
  0x88, 0x88, 0x88, 0xF0, 0x45, 0x36, 0x9E, 0xAA, 0x28, 0x80, 0x45, 0x96,
  0x56, 0x9A, 0x28, 0x80, 0x79, 0x99, 0x99, 0xE0, 0xFC, 0x63, 0xE8, 0x42,
  0x00, 0x74, 0x63, 0x19, 0x4B, 0x86, 0xF4, 0x63, 0xAA, 0x4A, 0x40, 0x74,
  0x60, 0xC1, 0x4B, 0x80, 0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x63, 0x29,
  0x4B, 0x80, 0x8C, 0xA5, 0x26, 0x21, 0x00, 0xAD, 0x7B, 0xE9, 0x4A, 0x80,
  0x44, 0xA3, 0x04, 0x31, 0x28, 0x80, 0x8C, 0x94, 0xC4, 0x21, 0x00, 0x7C,
  0x21, 0x08, 0x21, 0x0F, 0x80, 0x34, 0x44, 0x44, 0x44, 0x8C, 0xAA, 0x55,
  0x24, 0x92, 0x49, 0x58, 0x26, 0x59, 0xF0, 0x80, 0xF1, 0xF9, 0xF0, 0x42,
  0x14, 0xD4, 0xA6, 0x3E, 0xF8, 0x89, 0xE0, 0x08, 0x5B, 0x29, 0x4A, 0x5C,
  0xF9, 0xE8, 0xF0, 0x19, 0x3C, 0x84, 0x21, 0x08, 0x7A, 0x63, 0x17, 0x0B,
  0xC0, 0x42, 0x14, 0xD4, 0xA6, 0x31, 0x2C, 0x22, 0x24, 0xF0, 0x09, 0x04,
  0x21, 0x08, 0x44, 0xE0, 0x48, 0x89, 0xEC, 0xA9, 0x62, 0x22, 0x22, 0x4F,
  0xFE, 0x5A, 0x6A, 0xA8, 0x7A, 0x53, 0x18, 0x80, 0xF9, 0x99, 0xE0, 0x7A,
  0x53, 0x17, 0x42, 0x00, 0xF9, 0x99, 0xE1, 0x20, 0x7A, 0x21, 0x08, 0x00,
  0xF8, 0x61, 0xE0, 0x2F, 0x44, 0x44, 0x60, 0x99, 0x99, 0xE0, 0x9C, 0xA8,
  0x84, 0x00, 0xAF, 0x6D, 0x4A, 0x00, 0x4C, 0xC2, 0x14, 0x88, 0x45, 0x25,
  0x0C, 0x20, 0x8C, 0x00, 0x78, 0x88, 0x8F, 0x80, 0x29, 0x29, 0x24, 0x88,
  0x56, 0xAA, 0x42, 0x22, 0x23, 0x44, 0x48, 0x66, 0x60,
};

const GFXglyph RobotoMono_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -8 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 4, 7, 6, 1, -7 },
  { 19, 5, 7, 6, 0, -7 },
  { 24, 1, 3, 6, 3, -8 },
  { 25, 3, 10, 6, 2, -8 },
  { 29, 3, 10, 6, 1, -8 },
  { 33, 5, 4, 6, 1, -7 },
  { 36, 4, 5, 6, 1, -6 },
  { 39, 1, 2, 6, 1, -1 },
  { 40, 4, 1, 6, 1, -4 },
  { 41, 1, 1, 6, 2, -1 },
  { 42, 4, 8, 6, 1, -7 },
  { 46, 4, 7, 6, 1, -7 },
  { 50, 2, 7, 6, 2, -7 },
  { 52, 5, 7, 6, 0, -7 },
  { 57, 5, 7, 6, 0, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 1, -7 },
  { 72, 4, 7, 6, 1, -7 },
  { 76, 5, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 2, 5, 6, 2, -5 },
  { 92, 2, 6, 6, 2, -5 },
  { 94, 4, 4, 6, 1, -5 },
  { 96, 4, 2, 6, 1, -4 },
  { 97, 4, 4, 6, 1, -5 },
  { 99, 3, 7, 6, 2, -7 },
  { 102, 6, 7, 6, 0, -7 },
  { 108, 5, 7, 6, 0, -7 },
  { 113, 5, 7, 6, 0, -7 },
  { 118, 5, 7, 6, 1, -7 },
  { 123, 6, 7, 6, 0, -7 },
  { 129, 6, 7, 6, 0, -7 },
  { 135, 5, 7, 6, 1, -7 },
  { 140, 5, 7, 6, 1, -7 },
  { 145, 6, 7, 6, 0, -7 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 5, 7, 6, 1, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 6, 7, 6, 0, -7 },
  { 184, 4, 7, 6, 1, -7 },
  { 188, 5, 7, 6, 1, -7 },
  { 193, 5, 8, 6, 1, -7 },
  { 198, 5, 7, 6, 1, -7 },
  { 203, 5, 7, 6, 1, -7 },
  { 208, 5, 7, 6, 1, -7 },
  { 213, 5, 7, 6, 1, -7 },
  { 218, 5, 7, 6, 1, -7 },
  { 223, 5, 7, 6, 1, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 5, 7, 6, 1, -7 },
  { 239, 6, 7, 6, 0, -7 },
  { 245, 4, 10, 6, 1, -8 },
  { 250, 2, 8, 6, 2, -7 },
  { 252, 3, 10, 6, 1, -8 },
  { 256, 4, 4, 6, 1, -7 },
  { 258, 4, 1, 6, 0, 0 },
  { 259, 1, 1, 6, 3, -7 },
  { 260, 4, 5, 6, 1, -5 },
  { 263, 5, 8, 6, 0, -8 },
  { 268, 4, 5, 6, 1, -5 },
  { 271, 5, 8, 6, 1, -8 },
  { 276, 4, 5, 6, 1, -5 },
  { 279, 5, 8, 6, 1, -8 },
  { 284, 5, 7, 6, 0, -5 },
  { 289, 5, 8, 6, 0, -8 },
  { 294, 4, 7, 6, 1, -7 },
  { 298, 5, 9, 6, 0, -7 },
  { 304, 4, 8, 6, 1, -8 },
  { 308, 4, 8, 6, 1, -8 },
  { 312, 6, 5, 6, 0, -5 },
  { 316, 5, 5, 6, 0, -5 },
  { 320, 4, 5, 6, 1, -5 },
  { 323, 5, 7, 6, 0, -5 },
  { 328, 4, 7, 6, 1, -5 },
  { 332, 5, 5, 6, 1, -5 },
  { 336, 4, 5, 6, 1, -5 },
  { 339, 4, 7, 6, 1, -7 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 5, 5, 6, 1, -5 },
  { 350, 5, 5, 6, 1, -5 },
  { 354, 6, 5, 6, 0, -5 },
  { 358, 6, 7, 6, 0, -5 },
  { 364, 5, 5, 6, 0, -5 },
  { 368, 3, 10, 6, 2, -8 },
  { 372, 2, 8, 6, 2, -7 },
  { 374, 4, 10, 6, 1, -8 },
  { 379, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC10PT7B_H_
