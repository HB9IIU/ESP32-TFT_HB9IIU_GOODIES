#ifndef _ROBOTOMONO_EXTRALIGHTITALIC13PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0x80, 0xB6, 0x80, 0x0A, 0x12, 0x7F, 0x14, 0x24, 0x28,
  0xDE, 0x48, 0x50, 0x08, 0x62, 0x51, 0x41, 0x03, 0x02, 0x86, 0x25, 0x08,
  0xE2, 0xBA, 0xB4, 0x20, 0xF5, 0x65, 0x1C, 0x39, 0x25, 0x08, 0x62, 0x59,
  0x62, 0xF4, 0xE0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x84, 0x40, 0x21, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x10, 0x41, 0x3F,
  0x20, 0x82, 0x00, 0xE0, 0xF8, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x82, 0x00, 0x3D, 0x18, 0x67, 0xA7, 0x18, 0xA2, 0x70, 0x74, 0x92, 0x52,
  0x40, 0x3D, 0x10, 0x41, 0x08, 0x42, 0x10, 0xFC, 0x3C, 0x84, 0x08, 0x21,
  0x80, 0xA1, 0x42, 0x78, 0x04, 0x18, 0x51, 0x22, 0x48, 0xBF, 0x84, 0x08,
  0x3D, 0x04, 0x1E, 0x04, 0x10, 0x62, 0x70, 0x3A, 0x11, 0xF8, 0xC6, 0x31,
  0x70, 0xF8, 0x44, 0x22, 0x21, 0x10, 0x80, 0x3D, 0x14, 0x51, 0x7A, 0x18,
  0x62, 0x70, 0x79, 0x18, 0x61, 0x8D, 0xD0, 0x84, 0x60, 0x40, 0x08, 0x20,
  0x00, 0x12, 0x80, 0x04, 0xEC, 0x18, 0x18, 0xFC, 0x0F, 0x80, 0xC0, 0xC0,
  0xC4, 0xE0, 0x7C, 0x42, 0x22, 0x20, 0x00, 0x40, 0x1E, 0x29, 0x55, 0xA5,
  0xA9, 0xAA, 0xBE, 0x80, 0x78, 0x08, 0x51, 0x49, 0x24, 0x95, 0xD1, 0x84,
  0x7D, 0x18, 0x62, 0xFA, 0x18, 0x62, 0xF0, 0x3D, 0x18, 0x60, 0x82, 0x08,
  0x62, 0x70, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x50, 0xA2, 0xF8, 0x7D, 0x04,
  0x20, 0xFA, 0x08, 0x20, 0xF8, 0x7E, 0x81, 0x04, 0x0F, 0x90, 0x20, 0x40,
  0x80, 0x3D, 0x18, 0x20, 0x9A, 0x18, 0x61, 0x78, 0x22, 0x85, 0x0A, 0x17,
  0xE8, 0x50, 0xC2, 0x84, 0x7C, 0x41, 0x04, 0x20, 0x82, 0x08, 0xF8, 0x02,
  0x04, 0x08, 0x10, 0x20, 0xA1, 0x42, 0x78, 0x46, 0x91, 0x45, 0x0E, 0x12,
  0x24, 0x44, 0x8C, 0x42, 0x11, 0x08, 0x42, 0x10, 0xF8, 0x23, 0x62, 0x66,
  0x56, 0x5A, 0x52, 0x42, 0x84, 0x84, 0x22, 0xC5, 0x4A, 0x95, 0x29, 0x52,
  0xC2, 0x84, 0x3D, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x7C, 0x85, 0x0C,
  0x2F, 0x90, 0x20, 0x40, 0x80, 0x7D, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70,
  0x40, 0x80, 0x7D, 0x14, 0x61, 0xEA, 0x48, 0xA2, 0x88, 0x7D, 0x18, 0x10,
  0x38, 0x18, 0x61, 0x78, 0xFE, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x46, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x83, 0x09, 0x12, 0x44, 0x8A,
  0x14, 0x30, 0x20, 0x93, 0x26, 0xCD, 0xAB, 0x5A, 0xB6, 0x44, 0x88, 0x23,
  0x22, 0x14, 0x18, 0x10, 0x18, 0x24, 0x44, 0x84, 0x86, 0x89, 0x22, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0xFC,
  0x32, 0x44, 0x44, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x95, 0x50, 0x31, 0x11,
  0x22, 0x22, 0x22, 0x44, 0xC0, 0x25, 0x59, 0x90, 0xFC, 0xC0, 0x7A, 0x10,
  0x5E, 0x8A, 0x2F, 0x80, 0x41, 0x04, 0x1E, 0x86, 0x18, 0x62, 0x8B, 0xC0,
  0x39, 0x18, 0x20, 0x82, 0x27, 0x00, 0x04, 0x10, 0x4F, 0x46, 0x18, 0xA2,
  0x89, 0xE0, 0x39, 0x18, 0x7E, 0x82, 0x07, 0x80, 0x1C, 0x84, 0x3E, 0x41,
  0x04, 0x10, 0x82, 0x00, 0x1E, 0x45, 0x0A, 0x24, 0x48, 0x8F, 0x02, 0x88,
  0xE0, 0x41, 0x04, 0x2E, 0x46, 0x18, 0x62, 0x8A, 0x20, 0x10, 0x1C, 0x21,
  0x08, 0x84, 0xF8, 0x04, 0x03, 0x82, 0x08, 0x20, 0x82, 0x08, 0x41, 0x38,
  0x41, 0x04, 0x11, 0x5A, 0x8E, 0x24, 0x92, 0x20, 0x70, 0x84, 0x21, 0x08,
  0x44, 0x27, 0xC0, 0x76, 0x96, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xB9, 0x18,
  0x61, 0x8A, 0x28, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x2F, 0x00, 0x5C, 0xC5,
  0x0A, 0x14, 0x48, 0xAE, 0x40, 0x81, 0x00, 0x3D, 0x18, 0x62, 0x8A, 0x2F,
  0x82, 0x08, 0x40, 0x7A, 0x21, 0x08, 0x42, 0x00, 0x7A, 0x14, 0x0C, 0x0A,
  0x2F, 0x00, 0x22, 0x3E, 0x84, 0x21, 0x10, 0x70, 0x86, 0x18, 0x61, 0x8A,
  0x2F, 0x80, 0x86, 0x14, 0x92, 0x51, 0x82, 0x00, 0x93, 0x2A, 0xD6, 0xAD,
  0x91, 0x24, 0x00, 0x42, 0x48, 0x60, 0x82, 0x88, 0xB1, 0x00, 0x41, 0x42,
  0x44, 0x24, 0x28, 0x28, 0x10, 0x20, 0x20, 0xC0, 0x7E, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0x00, 0x08, 0x88, 0x42, 0x22, 0x08, 0x42, 0x10, 0x82, 0x00,
  0x55, 0xAA, 0xA8, 0x20, 0x84, 0x21, 0x08, 0x22, 0x21, 0x08, 0x88, 0x00,
  0x73, 0x1C,
};

const GFXglyph RobotoMono_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 3, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 12, 8, 1, -11 },
  { 24, 6, 9, 8, 1, -9 },
  { 31, 6, 9, 8, 1, -9 },
  { 38, 1, 3, 8, 4, -10 },
  { 39, 4, 13, 8, 2, -10 },
  { 46, 4, 13, 8, 1, -10 },
  { 53, 5, 5, 8, 2, -9 },
  { 57, 6, 7, 8, 1, -8 },
  { 63, 1, 3, 8, 2, -1 },
  { 64, 5, 1, 8, 1, -5 },
  { 65, 1, 1, 8, 3, -1 },
  { 66, 6, 10, 8, 1, -9 },
  { 74, 6, 9, 8, 1, -9 },
  { 81, 3, 9, 8, 2, -9 },
  { 85, 6, 9, 8, 0, -9 },
  { 92, 7, 9, 8, 0, -9 },
  { 100, 7, 9, 8, 0, -9 },
  { 108, 6, 9, 8, 1, -9 },
  { 115, 5, 9, 8, 1, -9 },
  { 121, 5, 9, 8, 2, -9 },
  { 127, 6, 9, 8, 1, -9 },
  { 134, 6, 9, 8, 1, -9 },
  { 141, 2, 7, 8, 3, -7 },
  { 143, 3, 9, 8, 2, -7 },
  { 147, 6, 5, 8, 1, -7 },
  { 151, 6, 3, 8, 1, -6 },
  { 154, 6, 5, 8, 1, -7 },
  { 158, 5, 9, 8, 2, -9 },
  { 164, 8, 9, 8, 0, -9 },
  { 173, 6, 9, 8, 0, -9 },
  { 180, 6, 9, 8, 1, -9 },
  { 187, 6, 9, 8, 1, -9 },
  { 194, 7, 9, 8, 0, -9 },
  { 202, 6, 9, 8, 1, -9 },
  { 209, 7, 9, 8, 1, -9 },
  { 217, 6, 9, 8, 1, -9 },
  { 224, 7, 9, 8, 0, -9 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 7, 9, 8, 0, -9 },
  { 247, 7, 9, 8, 1, -9 },
  { 255, 5, 9, 8, 1, -9 },
  { 261, 8, 9, 8, 0, -9 },
  { 270, 7, 9, 8, 0, -9 },
  { 278, 6, 9, 8, 1, -9 },
  { 285, 7, 9, 8, 1, -9 },
  { 293, 6, 11, 8, 1, -9 },
  { 302, 6, 9, 8, 1, -9 },
  { 309, 6, 9, 8, 1, -9 },
  { 316, 7, 9, 8, 1, -9 },
  { 324, 6, 9, 8, 1, -9 },
  { 331, 7, 9, 8, 1, -9 },
  { 339, 7, 9, 8, 1, -9 },
  { 347, 8, 9, 8, 0, -9 },
  { 356, 7, 9, 8, 1, -9 },
  { 364, 7, 9, 8, 0, -9 },
  { 372, 4, 13, 8, 2, -11 },
  { 379, 2, 10, 8, 3, -9 },
  { 382, 4, 13, 8, 2, -11 },
  { 389, 4, 5, 8, 2, -9 },
  { 392, 6, 1, 8, 0, 0 },
  { 393, 1, 2, 8, 4, -10 },
  { 394, 6, 7, 8, 1, -7 },
  { 400, 6, 10, 8, 1, -10 },
  { 408, 6, 7, 8, 1, -7 },
  { 414, 6, 10, 8, 1, -10 },
  { 422, 6, 7, 8, 1, -7 },
  { 428, 6, 10, 8, 2, -10 },
  { 436, 7, 10, 8, 0, -7 },
  { 445, 6, 10, 8, 1, -10 },
  { 453, 5, 9, 8, 1, -9 },
  { 459, 6, 12, 8, 0, -9 },
  { 468, 6, 10, 8, 1, -10 },
  { 476, 5, 10, 8, 1, -10 },
  { 483, 7, 7, 8, 0, -7 },
  { 490, 6, 7, 8, 1, -7 },
  { 496, 6, 7, 8, 1, -7 },
  { 502, 7, 10, 8, 0, -7 },
  { 511, 6, 10, 8, 1, -7 },
  { 519, 5, 7, 8, 2, -7 },
  { 524, 6, 7, 8, 1, -7 },
  { 530, 5, 9, 8, 2, -9 },
  { 536, 6, 7, 8, 1, -7 },
  { 542, 6, 7, 8, 1, -7 },
  { 548, 7, 7, 8, 1, -7 },
  { 555, 7, 7, 8, 0, -7 },
  { 562, 8, 10, 8, 0, -7 },
  { 572, 7, 7, 8, 0, -7 },
  { 579, 5, 13, 8, 2, -10 },
  { 588, 2, 11, 8, 3, -9 },
  { 591, 5, 13, 8, 1, -10 },
  { 600, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC13PT7B_H_
