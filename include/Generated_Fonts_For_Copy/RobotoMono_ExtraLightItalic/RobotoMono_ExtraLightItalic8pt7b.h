#ifndef _ROBOTOMONO_EXTRALIGHTITALIC8PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xE0, 0x29, 0x96, 0xAE, 0x50, 0x2E, 0xC7, 0x6A, 0x4B, 0xE3,
  0x73, 0x25, 0x27, 0xBF, 0xC0, 0x6A, 0x49, 0x22, 0x55, 0x5A, 0x5D, 0x50,
  0x22, 0xF2, 0xC0, 0xE0, 0x80, 0x25, 0x29, 0x00, 0x76, 0xFB, 0xC0, 0x75,
  0x50, 0x69, 0x12, 0x4F, 0x35, 0x13, 0x9E, 0x13, 0x55, 0xF2, 0x78, 0xC2,
  0xAE, 0x34, 0x69, 0x97, 0xF2, 0x24, 0x48, 0x35, 0x57, 0x9F, 0x76, 0xF3,
  0x80, 0x90, 0x98, 0x71, 0x80, 0xFC, 0x61, 0xE0, 0x74, 0xA1, 0x00, 0x33,
  0x77, 0xDF, 0x78, 0x22, 0x55, 0xB9, 0x75, 0x5B, 0x9F, 0x35, 0x88, 0x97,
  0x65, 0x59, 0x9E, 0x7A, 0x11, 0x68, 0x78, 0x7A, 0x10, 0xE8, 0x40, 0x35,
  0x8B, 0x97, 0x4A, 0x63, 0xE9, 0x48, 0x72, 0x22, 0x2F, 0x11, 0x11, 0x9E,
  0x4A, 0x98, 0xCA, 0x48, 0x44, 0x44, 0x8F, 0x4A, 0x95, 0x69, 0x48, 0x4A,
  0x53, 0x6B, 0x48, 0x35, 0x99, 0x97, 0x72, 0x52, 0xE8, 0x40, 0x35, 0x99,
  0x97, 0x10, 0x75, 0x56, 0x99, 0x35, 0x43, 0x9F, 0xF4, 0x44, 0x44, 0x4A,
  0x63, 0x29, 0x38, 0x99, 0xAA, 0x48, 0xDD, 0xDA, 0xAA, 0x4A, 0x88, 0x45,
  0x48, 0x9A, 0xA4, 0x48, 0x71, 0x22, 0x4F, 0x69, 0x29, 0x24, 0xFE, 0x64,
  0xA4, 0x96, 0x4A, 0x80, 0xF0, 0x80, 0x77, 0x9F, 0x46, 0x59, 0x9F, 0xF2,
  0x70, 0x2E, 0xDB, 0xC0, 0x7F, 0x87, 0x7E, 0x44, 0x88, 0x79, 0x97, 0x1E,
  0x46, 0x59, 0x99, 0x14, 0x22, 0x2F, 0x16, 0x12, 0x22, 0x2C, 0x44, 0x56,
  0xA9, 0x72, 0x22, 0x2F, 0xFD, 0x6B, 0x60, 0x79, 0x99, 0x79, 0x9F, 0x79,
  0x9F, 0x88, 0xF6, 0xF2, 0x40, 0xF2, 0x40, 0xF8, 0xF0, 0xE9, 0x4E, 0xB6,
  0xF0, 0xBA, 0xC8, 0xDE, 0xAA, 0x52, 0x69, 0x4A, 0x98, 0x44, 0x40, 0x72,
  0x4F, 0x29, 0x44, 0x92, 0xFE, 0x49, 0x14, 0xA4, 0xF8,
};

const GFXglyph RobotoMono_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 4, 6, 5, 0, -6 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 1, 2, 5, 2, -6 },
  { 17, 3, 8, 5, 1, -6 },
  { 20, 2, 8, 5, 1, -6 },
  { 22, 3, 4, 5, 1, -6 },
  { 24, 4, 4, 5, 0, -5 },
  { 26, 1, 2, 5, 1, -1 },
  { 27, 3, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 6, 5, 1, -6 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 2, 6, 5, 1, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 1, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 1, 4, 5, 2, -4 },
  { 62, 1, 5, 5, 2, -4 },
  { 63, 3, 3, 5, 1, -4 },
  { 65, 3, 2, 5, 1, -4 },
  { 66, 4, 3, 5, 0, -4 },
  { 68, 3, 6, 5, 1, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 4, 6, 5, 0, -6 },
  { 78, 4, 6, 5, 0, -6 },
  { 81, 4, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 0, -6 },
  { 105, 4, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 4, 6, 5, 0, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 4, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 4, 7, 5, 0, -6 },
  { 134, 4, 6, 5, 0, -6 },
  { 137, 4, 6, 5, 0, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 4, 6, 5, 0, -6 },
  { 163, 3, 8, 5, 1, -7 },
  { 166, 1, 7, 5, 2, -6 },
  { 167, 3, 8, 5, 1, -7 },
  { 170, 3, 3, 5, 1, -6 },
  { 172, 4, 1, 5, 0, 0 },
  { 173, 1, 1, 5, 2, -6 },
  { 174, 4, 4, 5, 0, -4 },
  { 176, 4, 6, 5, 0, -6 },
  { 179, 3, 4, 5, 1, -4 },
  { 181, 3, 6, 5, 1, -6 },
  { 184, 4, 4, 5, 0, -4 },
  { 186, 4, 6, 5, 1, -6 },
  { 189, 4, 6, 5, 0, -4 },
  { 192, 4, 6, 5, 0, -6 },
  { 195, 4, 6, 5, 0, -6 },
  { 198, 4, 8, 5, 0, -6 },
  { 202, 4, 6, 5, 0, -6 },
  { 205, 4, 6, 5, 0, -6 },
  { 208, 5, 4, 5, 0, -4 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 4, 4, 5, 0, -4 },
  { 215, 4, 6, 5, 0, -4 },
  { 218, 3, 6, 5, 1, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 3, 5, 5, 1, -5 },
  { 227, 3, 4, 5, 1, -4 },
  { 229, 4, 4, 5, 1, -4 },
  { 231, 4, 4, 5, 1, -4 },
  { 233, 4, 4, 5, 0, -4 },
  { 235, 5, 6, 5, 0, -4 },
  { 239, 4, 4, 5, 0, -4 },
  { 241, 3, 8, 5, 1, -6 },
  { 244, 1, 7, 5, 2, -6 },
  { 245, 3, 8, 5, 1, -6 },
  { 248, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC8PT7B_H_
