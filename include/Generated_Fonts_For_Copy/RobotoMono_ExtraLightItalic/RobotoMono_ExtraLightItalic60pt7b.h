#ifndef _ROBOTOMONO_EXTRALIGHTITALIC60PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x39, 0xC1, 0x8C, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x19, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x18, 0xC1, 0xCE, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x41, 0x80, 0x30, 0x03, 0x1C,
  0x01, 0x80, 0x30, 0xC0, 0x0C, 0x03, 0x86, 0x00, 0x60, 0x38, 0x30, 0x03,
  0x01, 0x81, 0x80, 0x38, 0x1C, 0x0C, 0x01, 0x81, 0xC0, 0x60, 0x0C, 0x0C,
  0x03, 0x00, 0xE0, 0xC0, 0x1C, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x60, 0x01,
  0xFE, 0x06, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x0F, 0x80, 0x01, 0xC1, 0xFE, 0x00, 0x1C, 0x1E, 0x38,
  0x00, 0xC1, 0xC0, 0xE0, 0x0E, 0x0C, 0x03, 0x00, 0xE0, 0xE0, 0x18, 0x06,
  0x06, 0x00, 0xC0, 0x60, 0x70, 0x06, 0x07, 0x03, 0x80, 0x30, 0x30, 0x18,
  0x01, 0x83, 0x00, 0xC0, 0x0C, 0x38, 0x06, 0x00, 0x63, 0x80, 0x30, 0x07,
  0x18, 0x01, 0x80, 0x30, 0x40, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x30, 0x01, 0x80,
  0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x63, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x18, 0xF0, 0x1C, 0x00,
  0xC7, 0x00, 0x60, 0x0E, 0x70, 0x03, 0x80, 0x77, 0x00, 0x0E, 0x03, 0x38,
  0x00, 0x70, 0x39, 0x80, 0x01, 0xC1, 0xDC, 0x00, 0x06, 0x1C, 0xE0, 0x00,
  0x38, 0xE7, 0x00, 0x00, 0xEE, 0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x1F,
  0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xFE, 0x07,
  0x00, 0x0F, 0x38, 0x1E, 0x01, 0xE1, 0xC0, 0x7F, 0xFE, 0x07, 0x01, 0xFF,
  0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x39, 0xCC, 0x63, 0x19, 0xCC, 0x63,
  0x19, 0xCC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x0C, 0x01, 0xFC, 0x06, 0x07, 0xFF, 0x83, 0x0F, 0xE3, 0xF9, 0xBF,
  0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0xF0,
  0x00, 0xE0, 0x10, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xE1,
  0x87, 0x0E, 0x38, 0x71, 0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1F, 0x18, 0x00, 0x07, 0xB3,
  0x80, 0x00, 0xE7, 0x38, 0x00, 0x1C, 0x73, 0x80, 0x03, 0x87, 0x30, 0x00,
  0x70, 0x73, 0x00, 0x1E, 0x06, 0x30, 0x03, 0x80, 0x67, 0x00, 0x70, 0x06,
  0x70, 0x0E, 0x00, 0xE7, 0x01, 0xC0, 0x0E, 0x60, 0x38, 0x00, 0xE6, 0x0E,
  0x00, 0x0C, 0x61, 0xC0, 0x00, 0xCE, 0x38, 0x00, 0x0C, 0xE7, 0x00, 0x01,
  0xCE, 0xE0, 0x00, 0x1C, 0xFC, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x00,
  0xFE, 0x07, 0xE6, 0x1F, 0x86, 0x7C, 0x0E, 0xF0, 0x0E, 0xC0, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x01,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x1F, 0xE0, 0x00, 0x77, 0xFF, 0xC0, 0x03, 0xFC,
  0x3F, 0x00, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x02, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x3F,
  0x80, 0x18, 0x7F, 0xF8, 0x0E, 0x7E, 0x1F, 0x03, 0x3C, 0x01, 0xE0, 0xDC,
  0x00, 0x3C, 0x7C, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0x00, 0x78, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x98, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x6C, 0x38, 0x00, 0x33, 0x07,
  0x00, 0x39, 0xC1, 0xF0, 0x7C, 0x60, 0x1F, 0xFE, 0x18, 0x03, 0xFC, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x87,
  0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0x03, 0xC0, 0x78, 0x01, 0xC1, 0xC0, 0x01, 0x87, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0D, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0xE0, 0x0F, 0x80, 0x60, 0x30, 0x0F, 0xF8, 0x0C, 0x1C,
  0x07, 0x07, 0x03, 0x06, 0x03, 0x80, 0xC0, 0xC3, 0x81, 0xC0, 0x60, 0x30,
  0xC0, 0xE0, 0x18, 0x0C, 0x70, 0x30, 0x06, 0x03, 0x18, 0x1C, 0x01, 0x80,
  0xC6, 0x06, 0x00, 0xC0, 0x33, 0x03, 0x80, 0x30, 0x18, 0xC0, 0xC0, 0x0C,
  0x06, 0x30, 0x30, 0x03, 0x01, 0x98, 0x1C, 0x01, 0x80, 0x66, 0x06, 0x00,
  0x60, 0x19, 0x81, 0x80, 0x18, 0x0C, 0x60, 0x60, 0x0C, 0x03, 0x18, 0x18,
  0x03, 0x00, 0xC6, 0x06, 0x00, 0xC0, 0x33, 0x81, 0x00, 0x70, 0x18, 0xE0,
  0x40, 0x3C, 0x06, 0x38, 0x18, 0x1B, 0x03, 0x0E, 0x06, 0x06, 0xC1, 0xC1,
  0x81, 0x87, 0x30, 0xE0, 0x60, 0x7F, 0x8F, 0xF0, 0x18, 0x0F, 0xC1, 0xF8,
  0x06, 0x00, 0x80, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0xF8,
  0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xF0, 0x07,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1E, 0x06, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x80, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0x81, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x30, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x0F, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x60, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xFC, 0x60, 0x01, 0xFF, 0xF1, 0x80, 0x07, 0xFF, 0xC6, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x01, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x0C, 0x7E, 0x00, 0x00, 0x03,
  0x3F, 0x80, 0x00, 0x00, 0xDE, 0x70, 0x00, 0x00, 0x7F, 0x1C, 0x00, 0x00,
  0x1F, 0x83, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xD8, 0x0F, 0xC0, 0x00, 0xEC, 0x07,
  0x60, 0x00, 0xEE, 0x03, 0x30, 0x00, 0x77, 0x01, 0x98, 0x00, 0x73, 0x00,
  0xCE, 0x00, 0x31, 0x80, 0xE7, 0x00, 0x38, 0xC0, 0x71, 0x80, 0x18, 0xE0,
  0x30, 0xC0, 0x1C, 0x70, 0x18, 0x60, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x18,
  0x06, 0x1C, 0x0E, 0x0C, 0x07, 0x06, 0x07, 0x06, 0x03, 0x83, 0x07, 0x07,
  0x01, 0x81, 0x83, 0x03, 0x80, 0xC0, 0xC3, 0x81, 0x80, 0x60, 0x71, 0x80,
  0xC0, 0x30, 0x39, 0xC0, 0x60, 0x38, 0x0C, 0xC0, 0x70, 0x1C, 0x06, 0xE0,
  0x38, 0x0C, 0x03, 0xE0, 0x1C, 0x06, 0x01, 0xF0, 0x0C, 0x03, 0x00, 0xF0,
  0x06, 0x03, 0x80, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x06, 0x03, 0x30, 0x00, 0x06,
  0x03, 0x38, 0x00, 0x06, 0x03, 0x38, 0x00, 0x0E, 0x07, 0x18, 0x00, 0x0E,
  0x07, 0x1C, 0x00, 0x0E, 0x07, 0x0C, 0x00, 0x0C, 0x06, 0x0C, 0x00, 0x0C,
  0x06, 0x0E, 0x00, 0x0C, 0x06, 0x06, 0x00, 0x1C, 0x0E, 0x06, 0x00, 0x1C,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x80, 0x18,
  0x0C, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x38,
  0x1C, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xE0, 0x30,
  0x18, 0x00, 0x60, 0x70, 0x38, 0x00, 0x70, 0x70, 0x38, 0x00, 0x70, 0x70,
  0x38, 0x00, 0x30, 0x60, 0x30, 0x00, 0x38, 0x60, 0x30, 0x00, 0x18, 0x60,
  0x30, 0x00, 0x18, 0xE0, 0x70, 0x00, 0x1C, 0xE0, 0x70, 0x00, 0x0C, 0xE0,
  0x70, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x0E, 0xC0, 0x60, 0x00, 0x06, 0xC0,
  0x60, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x78, 0x01, 0x80, 0x00, 0xF0, 0x06,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x3C, 0x00, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60,
  0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x0F,
  0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x6E, 0x00, 0x78, 0x00, 0xDC,
  0x00, 0xF0, 0x03, 0xB8, 0x01, 0xE0, 0x07, 0x70, 0x07, 0xC0, 0x0C, 0xE0,
  0x0D, 0x80, 0x19, 0xC0, 0x1B, 0x00, 0x73, 0x80, 0x76, 0x00, 0xC7, 0x00,
  0xCC, 0x01, 0x8E, 0x01, 0x98, 0x07, 0x1C, 0x07, 0x30, 0x0C, 0x38, 0x0C,
  0x60, 0x18, 0x70, 0x18, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0xE1, 0xC0, 0xC3,
  0x81, 0x83, 0x81, 0x87, 0x03, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x18, 0x1C, 0x18, 0x38, 0x30, 0x38, 0x70, 0x30, 0xE0, 0x70, 0xC0, 0x61,
  0x80, 0xE3, 0x80, 0xC3, 0x01, 0xC7, 0x01, 0x8E, 0x03, 0x8C, 0x03, 0x1C,
  0x07, 0x38, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0x18, 0xC0, 0x19, 0xC0,
  0x33, 0x80, 0x33, 0x00, 0x66, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xDC, 0x01,
  0xB8, 0x01, 0xB0, 0x03, 0x60, 0x03, 0x60, 0x06, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x81, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0xC0,
  0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x30, 0x03, 0x81, 0x80, 0x18, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x01, 0x80,
  0xE0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x18, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0xC3,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0xF0,
  0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x01, 0xC1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x7C, 0x38, 0x00, 0x1D, 0x87, 0x80,
  0x0F, 0x70, 0x78, 0x07, 0xCE, 0x07, 0xFF, 0xE1, 0xC0, 0x7F, 0xF0, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x0F, 0xF0, 0x01, 0xC7, 0xFF, 0x80, 0x31, 0xE0, 0x78, 0x06, 0xF0,
  0x03, 0x80, 0xD8, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0x7C, 0x00, 0x1C, 0x0D, 0xC0,
  0x07, 0x03, 0x9C, 0x03, 0xC0, 0x71, 0xFF, 0xF0, 0x0E, 0x1F, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x81,
  0x80, 0x07, 0xFF, 0x86, 0x00, 0x7C, 0x0F, 0x38, 0x03, 0xC0, 0x0E, 0xE0,
  0x1E, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x3C,
  0xC0, 0x03, 0xFF, 0xE3, 0x00, 0x07, 0xFE, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x18, 0x00, 0xFF, 0xF0, 0xC0,
  0x1F, 0x03, 0xC6, 0x01, 0xE0, 0x07, 0x70, 0x1E, 0x00, 0x1F, 0x80, 0xE0,
  0x00, 0x7C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0xF0, 0x03,
  0xF8, 0x03, 0xC0, 0x79, 0x80, 0x0F, 0xFF, 0x8C, 0x00, 0x3F, 0xF0, 0x60,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x01,
  0x83, 0xFF, 0xC0, 0x30, 0xF0, 0x3C, 0x06, 0x38, 0x01, 0xC1, 0xCC, 0x00,
  0x38, 0x3B, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x78, 0x06, 0x00, 0x07, 0x80, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30,
  0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x33, 0xE0, 0x00, 0x01, 0xBF, 0x80, 0x00,
  0x1F, 0x8E, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x30,
  0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0,
  0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x1F, 0xC0, 0x7F,
  0x00, 0x67, 0xFE, 0x3F, 0xF0, 0x0D, 0xC1, 0xCF, 0x0F, 0x03, 0xE0, 0x1F,
  0x80, 0x60, 0x78, 0x03, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0x01, 0xC1, 0xC0,
  0x0E, 0x00, 0x38, 0x30, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x00, 0x60, 0xE0, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x07, 0x06, 0x00, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x03, 0x87,
  0x00, 0x1C, 0x00, 0x70, 0x07, 0x03, 0xFE, 0x00, 0xC1, 0xFF, 0xE0, 0x18,
  0x78, 0x1E, 0x03, 0x3C, 0x01, 0xE0, 0xEE, 0x00, 0x1C, 0x1D, 0x80, 0x01,
  0xC3, 0x60, 0x00, 0x38, 0x78, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xF8, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC1, 0xFE, 0x00, 0x0C, 0x3F, 0xFC, 0x00, 0x67, 0xC1, 0xF0, 0x03,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0xB0, 0x00, 0xE0, 0x1D, 0xE0, 0x1E,
  0x00, 0xE3, 0xFF, 0xE0, 0x07, 0x0F, 0xFC, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0xFF, 0x0C, 0x07,
  0xC0, 0xF1, 0x81, 0xE0, 0x07, 0x70, 0x78, 0x00, 0x7E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x1F, 0x03, 0x80, 0x0F, 0xE0, 0x3C, 0x07, 0x98, 0x03, 0xFF, 0xE3,
  0x00, 0x3F, 0xF0, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0x01, 0xFF,
  0x83, 0x03, 0xFF, 0xC1, 0x87, 0xE0, 0x40, 0xC7, 0x80, 0x00, 0xE7, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x7C, 0x01,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x30, 0x00,
  0x36, 0x07, 0x00, 0x1D, 0xC0, 0x70, 0x0F, 0x38, 0x07, 0xFF, 0xC6, 0x00,
  0x7F, 0xE0, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x06, 0x60,
  0x03, 0x80, 0x06, 0x60, 0x03, 0x80, 0x0E, 0x60, 0x07, 0x80, 0x0C, 0x60,
  0x07, 0x80, 0x1C, 0x60, 0x07, 0xC0, 0x18, 0x60, 0x0D, 0xC0, 0x18, 0x60,
  0x0D, 0xC0, 0x38, 0x60, 0x1C, 0xC0, 0x30, 0x60, 0x18, 0xC0, 0x70, 0x60,
  0x38, 0xC0, 0x60, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x30, 0xC0, 0xE0, 0x60,
  0x60, 0xC0, 0xC0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0xE0, 0xC1, 0xC0, 0x60,
  0xC0, 0xC1, 0x80, 0x70, 0xC0, 0xC3, 0x80, 0x71, 0x80, 0xC3, 0x00, 0x71,
  0x80, 0xE3, 0x00, 0x73, 0x00, 0xE7, 0x00, 0x73, 0x00, 0x66, 0x00, 0x37,
  0x00, 0x66, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x30, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xC3, 0xFF,
  0x80, 0x00, 0xC3, 0x80, 0xE0, 0x00, 0x63, 0x80, 0x3C, 0x00, 0x73, 0x80,
  0x0E, 0x00, 0x31, 0x80, 0x03, 0xC0, 0x38, 0xC0, 0x00, 0xF0, 0x78, 0xE0,
  0x00, 0x3F, 0xF8, 0x10, 0x00, 0x07, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 43, 35, 12, -43 },
  { 55, 13, 13, 35, 14, -45 },
  { 77, 35, 43, 35, 1, -43 },
  { 266, 29, 55, 35, 4, -49 },
  { 466, 29, 44, 35, 4, -43 },
  { 626, 29, 44, 35, 3, -43 },
  { 786, 5, 13, 35, 17, -45 },
  { 795, 19, 62, 35, 10, -48 },
  { 943, 19, 62, 35, 5, -48 },
  { 1091, 25, 25, 35, 8, -43 },
  { 1170, 28, 31, 35, 4, -35 },
  { 1279, 7, 13, 35, 7, -5 },
  { 1291, 21, 2, 35, 7, -20 },
  { 1297, 5, 4, 35, 13, -4 },
  { 1300, 27, 47, 35, 5, -43 },
  { 1459, 28, 44, 35, 4, -43 },
  { 1613, 16, 43, 35, 9, -43 },
  { 1699, 29, 43, 35, 1, -43 },
  { 1855, 29, 44, 35, 2, -43 },
  { 2015, 30, 43, 35, 1, -43 },
  { 2177, 29, 44, 35, 5, -43 },
  { 2337, 26, 44, 35, 4, -43 },
  { 2480, 27, 43, 35, 7, -43 },
  { 2626, 29, 44, 35, 4, -43 },
  { 2786, 26, 43, 35, 6, -43 },
  { 2926, 9, 30, 35, 15, -30 },
  { 2960, 13, 38, 35, 11, -30 },
  { 3022, 27, 25, 35, 5, -32 },
  { 3107, 28, 15, 35, 4, -27 },
  { 3160, 28, 25, 35, 3, -32 },
  { 3248, 23, 43, 35, 9, -43 },
  { 3372, 34, 43, 35, 1, -43 },
  { 3555, 30, 43, 35, 0, -43 },
  { 3717, 30, 43, 35, 3, -43 },
  { 3879, 29, 44, 35, 4, -43 },
  { 4039, 31, 43, 35, 2, -43 },
  { 4206, 31, 43, 35, 3, -43 },
  { 4373, 32, 43, 35, 3, -43 },
  { 4545, 30, 44, 35, 3, -43 },
  { 4710, 33, 43, 35, 2, -43 },
  { 4888, 31, 43, 35, 3, -43 },
  { 5055, 31, 44, 35, 2, -43 },
  { 5226, 34, 43, 35, 3, -43 },
  { 5409, 24, 43, 35, 4, -43 },
  { 5538, 33, 43, 35, 2, -43 },
  { 5716, 32, 43, 35, 2, -43 },
  { 5888, 29, 44, 35, 4, -43 },
  { 6048, 32, 43, 35, 3, -43 },
  { 6220, 30, 51, 35, 3, -43 },
  { 6412, 30, 43, 35, 3, -43 },
  { 6574, 30, 44, 35, 3, -43 },
  { 6739, 30, 43, 35, 7, -43 },
  { 6901, 31, 44, 35, 4, -43 },
  { 7072, 29, 43, 35, 7, -43 },
  { 7228, 31, 43, 35, 6, -43 },
  { 7395, 35, 43, 35, 1, -43 },
  { 7584, 29, 43, 35, 7, -43 },
  { 7740, 32, 43, 35, 1, -43 },
  { 7912, 18, 58, 35, 9, -49 },
  { 8043, 12, 47, 35, 12, -43 },
  { 8114, 19, 58, 35, 8, -49 },
  { 8252, 21, 24, 35, 7, -43 },
  { 8315, 25, 2, 35, 2, 0 },
  { 8322, 6, 8, 35, 18, -44 },
  { 8328, 27, 33, 35, 3, -32 },
  { 8440, 27, 46, 35, 3, -45 },
  { 8596, 27, 33, 35, 4, -32 },
  { 8708, 30, 46, 35, 4, -45 },
  { 8881, 27, 33, 35, 4, -32 },
  { 8993, 29, 46, 35, 8, -46 },
  { 9160, 29, 45, 35, 2, -32 },
  { 9324, 27, 45, 35, 3, -45 },
  { 9476, 25, 43, 35, 3, -43 },
  { 9611, 28, 56, 35, 0, -43 },
  { 9807, 29, 45, 35, 4, -45 },
  { 9971, 25, 45, 35, 3, -45 },
  { 10112, 35, 32, 35, -1, -32 },
  { 10252, 27, 32, 35, 3, -32 },
  { 10360, 28, 33, 35, 3, -32 },
  { 10476, 29, 44, 35, 1, -32 },
  { 10636, 27, 44, 35, 4, -32 },
  { 10785, 25, 32, 35, 8, -32 },
  { 10885, 27, 33, 35, 4, -32 },
  { 10997, 23, 41, 35, 7, -40 },
  { 11115, 27, 33, 35, 5, -32 },
  { 11227, 29, 32, 35, 5, -32 },
  { 11343, 32, 32, 35, 4, -32 },
  { 11471, 32, 32, 35, 1, -32 },
  { 11599, 36, 45, 35, -1, -32 },
  { 11802, 31, 32, 35, 1, -32 },
  { 11926, 23, 59, 35, 9, -47 },
  { 12096, 11, 52, 35, 12, -43 },
  { 12168, 23, 59, 35, 5, -47 },
  { 12338, 33, 10, 35, 1, -23 },
};

const GFXfont RobotoMono_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC60PT7B_H_
