#ifndef _ROBOTOMONO_EXTRALIGHTITALIC47PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x30, 0xCC,
  0x32, 0x09, 0x82, 0x61, 0x98, 0x66, 0x19, 0x06, 0xC1, 0x30, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x80, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10,
  0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x38, 0x1C, 0x01,
  0xC0, 0x0C, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0xC0, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xF3,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x20, 0x11, 0x00, 0x80, 0x6C,
  0x02, 0x03, 0x30, 0x18, 0x18, 0xC0, 0x60, 0xC3, 0x01, 0x83, 0x0C, 0x06,
  0x18, 0x30, 0x30, 0xC0, 0xC1, 0xC3, 0x01, 0x8E, 0x18, 0x03, 0xF0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x3C, 0x00, 0xC3, 0xF8, 0x06, 0x1C, 0x30, 0x18, 0x40, 0xC0, 0xC3,
  0x01, 0x06, 0x08, 0x04, 0x30, 0x60, 0x10, 0xC1, 0x80, 0x46, 0x06, 0x03,
  0x30, 0x18, 0x0D, 0xC0, 0x60, 0x32, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0x83, 0x00, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x33, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x60, 0xC0, 0x31, 0x81, 0xC0, 0x67, 0x01, 0x80, 0xCC, 0x01, 0x81, 0xB0,
  0x03, 0x06, 0x60, 0x03, 0x0D, 0x80, 0x07, 0x33, 0x00, 0x06, 0xE6, 0x00,
  0x07, 0x8E, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x6C, 0x1C, 0x03,
  0x9C, 0x1E, 0x3E, 0x18, 0x1F, 0xF0, 0x18, 0x6D, 0xAD, 0xB6, 0x90, 0x00,
  0x04, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x01, 0x60, 0x20, 0x7F, 0xC6,
  0x3F, 0x1F, 0x6F, 0x80, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x03,
  0xB0, 0x00, 0x71, 0x80, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x06, 0x07,
  0x00, 0x70, 0x20, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0xC6, 0x33, 0x18, 0xCC, 0xC6, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0x70, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1E, 0x07, 0x00,
  0xE0, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x03, 0xCC, 0x00, 0x1F,
  0x30, 0x00, 0xCC, 0xC0, 0x06, 0x33, 0x00, 0x30, 0xD8, 0x03, 0x83, 0x60,
  0x1C, 0x09, 0x80, 0xC0, 0x66, 0x06, 0x01, 0x98, 0x30, 0x06, 0x63, 0x80,
  0x1B, 0x1C, 0x00, 0x6C, 0xC0, 0x03, 0x36, 0x00, 0x0C, 0xF0, 0x00, 0x33,
  0x80, 0x01, 0x84, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80,
  0x06, 0x03, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1E, 0x3C, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x38, 0x07, 0x81, 0xFC, 0x3C, 0x67, 0x83, 0x60, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x1E, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x03,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x1C, 0x01,
  0xC0, 0x1F, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x9F, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0x80,
  0x70, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0F,
  0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x7E, 0x03, 0x1F, 0xF8, 0x37, 0x01, 0xC6, 0xC0, 0x0E, 0x78, 0x00, 0x67,
  0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x30, 0x03, 0x83, 0x80,
  0x70, 0x1E, 0x3E, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xC0, 0x03, 0x81, 0xE0, 0x1C, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0xC0, 0x01, 0x83, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0xC0,
  0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1C, 0x07, 0x00, 0xE0, 0x03, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1E, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xF0, 0x07, 0x03, 0x80, 0xE0, 0x1C, 0x18, 0x00, 0xC3,
  0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0x60, 0x01, 0x67, 0x00,
  0x74, 0x38, 0x0E, 0xC1, 0xFF, 0x8C, 0x0F, 0xE0, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00,
  0x0E, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x03, 0xC0, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0xE0, 0x70, 0x70, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00,
  0x0F, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0xF0,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x20, 0x30, 0x00,
  0x0C, 0x18, 0x07, 0x03, 0x0C, 0x0F, 0xE0, 0xC3, 0x07, 0x0C, 0x11, 0x83,
  0x03, 0x04, 0x60, 0xC0, 0x81, 0x30, 0x60, 0x20, 0x4C, 0x10, 0x18, 0x12,
  0x0C, 0x06, 0x0D, 0x82, 0x01, 0x03, 0x61, 0x80, 0x40, 0xD0, 0x60, 0x30,
  0x24, 0x18, 0x0C, 0x0B, 0x04, 0x02, 0x06, 0xC1, 0x01, 0x81, 0xB0, 0xC0,
  0x60, 0x4C, 0x30, 0x38, 0x33, 0x0C, 0x1E, 0x08, 0xC1, 0x0D, 0x86, 0x30,
  0x76, 0x23, 0x0C, 0x0F, 0x0F, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x88, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x04,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0x46, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x03, 0xFF, 0xE0, 0x06, 0x03, 0xF0, 0x18, 0x00,
  0x70, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38,
  0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x0E, 0x06, 0x00, 0x78, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0x81, 0xC0,
  0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x39, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1E,
  0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x06, 0x03, 0xE0, 0x06,
  0x00, 0x78, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0,
  0x0F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x7F, 0xF6, 0x00, 0xFF, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x1F, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x20, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x70, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x06, 0x01, 0xC0,
  0x01, 0x80, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC7, 0x80, 0x00,
  0x1B, 0xB0, 0x00, 0x03, 0xE3, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x80, 0x03,
  0x00, 0x30, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xD8, 0x00, 0xD8, 0x6C, 0x00, 0xC8,
  0x36, 0x00, 0x6C, 0x19, 0x00, 0x66, 0x0C, 0xC0, 0x33, 0x06, 0x60, 0x31,
  0x86, 0x30, 0x18, 0x83, 0x18, 0x18, 0xC1, 0x84, 0x1C, 0x60, 0xC3, 0x0C,
  0x30, 0x61, 0x8C, 0x18, 0x30, 0xC6, 0x0C, 0x30, 0x66, 0x04, 0x18, 0x33,
  0x06, 0x0C, 0x0B, 0x03, 0x06, 0x07, 0x81, 0x83, 0x03, 0x80, 0xC1, 0x01,
  0x80, 0x61, 0x80, 0xC0, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0A,
  0x00, 0x06, 0x06, 0xC0, 0x01, 0x81, 0xB0, 0x00, 0x60, 0x66, 0x00, 0x18,
  0x19, 0x80, 0x06, 0x06, 0x60, 0x01, 0x03, 0x0C, 0x00, 0xC0, 0xC3, 0x00,
  0x30, 0x30, 0x40, 0x0C, 0x0C, 0x18, 0x03, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x81,
  0x80, 0x60, 0x60, 0x60, 0x18, 0x18, 0x18, 0x03, 0x0C, 0x0C, 0x00, 0xC3,
  0x03, 0x00, 0x10, 0xC0, 0xC0, 0x06, 0x30, 0x30, 0x01, 0x8C, 0x0C, 0x00,
  0x33, 0x02, 0x00, 0x0D, 0x81, 0x80, 0x03, 0x60, 0x60, 0x00, 0x78, 0x18,
  0x00, 0x1E, 0x06, 0x00, 0x07, 0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0x83, 0xC0, 0x1C, 0x01,
  0x80, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1F, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x06, 0x00, 0xF8, 0x06, 0x00, 0x1C,
  0x06, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0x18, 0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0xF0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x30, 0x00, 0x60,
  0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0x9F, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xE0, 0x03, 0x00, 0xF8,
  0x03, 0x00, 0x1C, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x20, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x70, 0x00, 0x30, 0x38, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x0F, 0x9F, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x38, 0x02, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x06, 0xC0,
  0x68, 0x06, 0xC0, 0x68, 0x0C, 0xC0, 0x48, 0x0C, 0xC0, 0xC8, 0x0C, 0xC0,
  0xC8, 0x18, 0xC0, 0x88, 0x18, 0xC1, 0x88, 0x18, 0xC1, 0x88, 0x10, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x60, 0xC6,
  0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x0C, 0xC0, 0xD8, 0x0C, 0x80, 0xD8, 0x0D, 0x80, 0xD8, 0x0D, 0x80, 0xF0,
  0x0D, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x07, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01,
  0x86, 0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x82, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0xD8, 0x01, 0x98, 0x01,
  0x98, 0x03, 0x08, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x18, 0x63, 0x0C, 0x60, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x06, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x38,
  0x00, 0x41, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x07, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x0F, 0x87,
  0x00, 0x76, 0x0F, 0x9F, 0x18, 0x0F, 0xF0, 0x60, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x43, 0xF8, 0x03, 0x3F, 0xF8, 0x0D, 0xC0, 0x70, 0x3C, 0x00, 0xC0, 0xE0,
  0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x0C, 0x1E, 0x00, 0x70,
  0x6C, 0x03, 0x81, 0xBE, 0x7C, 0x0C, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xE0, 0x1C, 0x03, 0xE7, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x03, 0xF8, 0x70, 0x1F,
  0xFC, 0xC0, 0x70, 0x0D, 0x81, 0xC0, 0x0F, 0x03, 0x00, 0x0E, 0x0C, 0x00,
  0x1C, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x38,
  0x06, 0xC0, 0x3C, 0x79, 0x80, 0x3F, 0xC6, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x0C, 0x00, 0x0C,
  0xE0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x04, 0x18, 0x00, 0x70, 0x60, 0x0E, 0x01, 0xE3, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x86, 0x03, 0xFF, 0x98, 0x0E, 0x01, 0xB0, 0x38, 0x01, 0xE0, 0x60, 0x01,
  0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0x80, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x03, 0x00,
  0x3C, 0x07, 0x00, 0xD8, 0x07, 0x8F, 0x30, 0x07, 0xF8, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x08, 0x00, 0x70,
  0x30, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC1, 0xFC, 0x03, 0x1F, 0xFC,
  0x0C, 0xE0, 0x38, 0x36, 0x00, 0x60, 0xF0, 0x01, 0x83, 0x80, 0x03, 0x1C,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x78, 0x60, 0x01,
  0xC0, 0xC0, 0x07, 0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80,
  0x18, 0x0E, 0x00, 0x30, 0x30, 0x00, 0x61, 0xC0, 0x00, 0xC7, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0xF8, 0x00, 0x0F, 0xB8, 0x00, 0x1E, 0x30, 0x00, 0x38,
  0x70, 0x00, 0x60, 0x70, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0xFC, 0x1F, 0x82, 0xFF,
  0x9F, 0xF1, 0xB0, 0x6C, 0x0C, 0x70, 0x1E, 0x03, 0x1C, 0x03, 0x00, 0xC6,
  0x00, 0xC0, 0x31, 0x80, 0x20, 0x0C, 0x40, 0x18, 0x03, 0x30, 0x06, 0x00,
  0xCC, 0x01, 0x80, 0x33, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x02, 0x30, 0x0C,
  0x01, 0x88, 0x03, 0x00, 0x66, 0x00, 0xC0, 0x19, 0x80, 0x30, 0x06, 0x60,
  0x0C, 0x01, 0x98, 0x03, 0x00, 0x46, 0x01, 0x80, 0x31, 0x00, 0x60, 0x0C,
  0xC0, 0x18, 0x03, 0x30, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x33, 0x00, 0x40,
  0x18, 0xC0, 0x30, 0x06, 0x00, 0x0C, 0x1F, 0xC0, 0x31, 0xFF, 0xC0, 0xCE,
  0x03, 0x03, 0x60, 0x06, 0x0B, 0x00, 0x18, 0x78, 0x00, 0x31, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x60, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x38, 0x07, 0x01, 0xC0,
  0x0E, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x71, 0x80, 0x00, 0xCE, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x30, 0x00, 0xE0,
  0xE0, 0x07, 0x01, 0xC0, 0x38, 0x03, 0xC7, 0xC0, 0x07, 0xFC, 0x00, 0x06,
  0x1F, 0xC0, 0x0C, 0xFF, 0xE0, 0x1B, 0x80, 0xE0, 0x3C, 0x00, 0xC0, 0x70,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x80, 0x06, 0x07,
  0x80, 0x1C, 0x0F, 0x80, 0x70, 0x1B, 0xC7, 0xC0, 0x61, 0xFE, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0C, 0x0F, 0xFE, 0x60, 0x70, 0x0D,
  0x83, 0x80, 0x1E, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x80, 0x6C, 0x07, 0x8F, 0x30, 0x0F, 0xF1,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x0F, 0xF0, 0xC3, 0xFF, 0x0C, 0xE0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFF, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0xCE, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0, 0x0F, 0x03, 0xE3, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xF1, 0x00, 0x3F, 0xE0,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x70, 0x03, 0xC1, 0x80, 0x76,
  0x07, 0x9F, 0x30, 0x1F, 0xE1, 0x80, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0x66, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x01, 0xA0, 0x0E, 0x00,
  0xD0, 0x07, 0x00, 0xC8, 0x03, 0x80, 0x66, 0x03, 0xC0, 0x63, 0x01, 0x60,
  0x31, 0x81, 0xB0, 0x18, 0xC0, 0xD8, 0x18, 0x60, 0xCC, 0x0C, 0x30, 0x66,
  0x04, 0x18, 0x21, 0x06, 0x0C, 0x30, 0x83, 0x06, 0x18, 0x43, 0x03, 0x18,
  0x21, 0x81, 0x8C, 0x18, 0x80, 0xC4, 0x0C, 0xC0, 0x66, 0x06, 0x60, 0x32,
  0x03, 0x20, 0x1B, 0x01, 0xB0, 0x0D, 0x80, 0xD8, 0x06, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x70,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x00,
  0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0x00,
  0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x80, 0x01, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x4E, 0x1C, 0x00, 0x6E,
  0x03, 0x00, 0x36, 0x00, 0xC0, 0x36, 0x00, 0x38, 0x33, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 33, 28, 10, -33 },
  { 34, 10, 10, 28, 11, -35 },
  { 47, 27, 33, 28, 1, -33 },
  { 159, 23, 43, 28, 3, -38 },
  { 283, 22, 34, 28, 3, -34 },
  { 377, 23, 34, 28, 2, -34 },
  { 475, 3, 10, 28, 14, -35 },
  { 479, 14, 48, 28, 8, -37 },
  { 563, 15, 48, 28, 4, -37 },
  { 653, 20, 19, 28, 6, -33 },
  { 701, 22, 25, 28, 3, -28 },
  { 770, 5, 10, 28, 6, -4 },
  { 777, 17, 2, 28, 5, -16 },
  { 782, 4, 3, 28, 10, -3 },
  { 784, 21, 36, 28, 4, -33 },
  { 879, 22, 34, 28, 3, -34 },
  { 973, 13, 33, 28, 7, -33 },
  { 1027, 22, 34, 28, 1, -34 },
  { 1121, 23, 34, 28, 1, -34 },
  { 1219, 23, 33, 28, 1, -33 },
  { 1314, 23, 33, 28, 4, -33 },
  { 1409, 20, 34, 28, 3, -34 },
  { 1494, 21, 33, 28, 6, -33 },
  { 1581, 23, 34, 28, 3, -34 },
  { 1679, 20, 34, 28, 5, -34 },
  { 1764, 7, 23, 28, 12, -23 },
  { 1785, 10, 29, 28, 9, -23 },
  { 1822, 21, 19, 28, 4, -25 },
  { 1872, 22, 11, 28, 3, -21 },
  { 1903, 21, 19, 28, 3, -25 },
  { 1953, 18, 34, 28, 7, -34 },
  { 2030, 26, 34, 28, 1, -34 },
  { 2141, 23, 33, 28, 0, -33 },
  { 2236, 23, 33, 28, 2, -33 },
  { 2331, 23, 34, 28, 3, -34 },
  { 2429, 24, 33, 28, 2, -33 },
  { 2528, 25, 33, 28, 2, -33 },
  { 2632, 24, 33, 28, 3, -33 },
  { 2731, 23, 35, 28, 3, -34 },
  { 2832, 26, 33, 28, 1, -33 },
  { 2940, 24, 33, 28, 2, -33 },
  { 3039, 24, 33, 28, 2, -33 },
  { 3138, 27, 33, 28, 2, -33 },
  { 3250, 19, 33, 28, 3, -33 },
  { 3329, 25, 33, 28, 2, -33 },
  { 3433, 26, 33, 28, 1, -33 },
  { 3541, 23, 34, 28, 3, -34 },
  { 3639, 24, 33, 28, 3, -33 },
  { 3738, 24, 40, 28, 2, -34 },
  { 3858, 24, 33, 28, 2, -33 },
  { 3957, 24, 34, 28, 2, -34 },
  { 4059, 24, 33, 28, 5, -33 },
  { 4158, 24, 33, 28, 3, -33 },
  { 4257, 23, 33, 28, 5, -33 },
  { 4352, 24, 33, 28, 5, -33 },
  { 4451, 28, 33, 28, 0, -33 },
  { 4567, 23, 33, 28, 5, -33 },
  { 4662, 25, 33, 28, 1, -33 },
  { 4766, 14, 45, 28, 7, -38 },
  { 4845, 10, 36, 28, 9, -33 },
  { 4890, 14, 45, 28, 7, -38 },
  { 4969, 16, 18, 28, 6, -33 },
  { 5005, 20, 2, 28, 1, 0 },
  { 5010, 5, 7, 28, 14, -35 },
  { 5015, 22, 25, 28, 2, -25 },
  { 5084, 22, 35, 28, 2, -35 },
  { 5181, 21, 25, 28, 3, -25 },
  { 5247, 23, 35, 28, 3, -35 },
  { 5348, 21, 25, 28, 3, -25 },
  { 5414, 23, 36, 28, 6, -36 },
  { 5518, 23, 35, 28, 2, -25 },
  { 5619, 22, 35, 28, 2, -35 },
  { 5716, 19, 34, 28, 3, -34 },
  { 5797, 22, 44, 28, 0, -34 },
  { 5918, 23, 35, 28, 3, -35 },
  { 6019, 19, 35, 28, 3, -35 },
  { 6103, 26, 25, 28, 0, -25 },
  { 6185, 22, 25, 28, 2, -25 },
  { 6254, 22, 25, 28, 2, -25 },
  { 6323, 23, 35, 28, 1, -25 },
  { 6424, 22, 35, 28, 3, -25 },
  { 6521, 20, 25, 28, 6, -25 },
  { 6584, 21, 25, 28, 3, -25 },
  { 6650, 18, 31, 28, 6, -31 },
  { 6720, 21, 25, 28, 4, -25 },
  { 6786, 23, 25, 28, 4, -25 },
  { 6858, 25, 25, 28, 3, -25 },
  { 6937, 25, 25, 28, 1, -25 },
  { 7016, 28, 35, 28, -1, -25 },
  { 7139, 24, 25, 28, 1, -25 },
  { 7214, 18, 47, 28, 7, -37 },
  { 7320, 8, 40, 28, 10, -33 },
  { 7360, 18, 47, 28, 4, -37 },
  { 7466, 25, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC47PT7B_H_
