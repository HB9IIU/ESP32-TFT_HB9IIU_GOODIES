#ifndef _ROBOTOMONO_EXTRALIGHTITALIC59PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x38, 0x33, 0x03, 0x30, 0x33, 0x07,
  0x70, 0x67, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C, 0xE0, 0xCC, 0x0C,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x1C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0xCE, 0x00, 0xC0, 0x18,
  0xC0, 0x0C, 0x03, 0x8C, 0x00, 0xC0, 0x70, 0xC0, 0x0C, 0x06, 0x0C, 0x01,
  0xC0, 0xC0, 0xC0, 0x18, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x38, 0x30,
  0x0C, 0x03, 0x07, 0x00, 0xE0, 0x60, 0xE0, 0x07, 0x9E, 0x0C, 0x00, 0x3F,
  0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0F, 0x00,
  0x03, 0x83, 0xF8, 0x00, 0x70, 0x79, 0xC0, 0x06, 0x0E, 0x06, 0x00, 0xC1,
  0xC0, 0x60, 0x1C, 0x18, 0x03, 0x01, 0x81, 0x80, 0x30, 0x30, 0x30, 0x03,
  0x07, 0x03, 0x00, 0x30, 0x60, 0x30, 0x03, 0x0C, 0x03, 0x00, 0x71, 0xC0,
  0x30, 0x06, 0x38, 0x03, 0x00, 0x63, 0x00, 0x30, 0x06, 0x10, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x1C, 0x01, 0x87,
  0x00, 0x30, 0x06, 0x38, 0x00, 0xE0, 0x38, 0xE0, 0x01, 0xC0, 0xC3, 0x00,
  0x03, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x70, 0x00, 0x1C, 0xE1, 0x80, 0x00,
  0x73, 0x86, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x3E, 0x03, 0x80, 0x01, 0xF8, 0x07, 0x00, 0x0E, 0x70,
  0x1E, 0x00, 0xF0, 0xE0, 0x1F, 0xFF, 0x01, 0x80, 0x3F, 0xF0, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x33, 0x33, 0x76, 0x66, 0x6E, 0xCC, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x0C,
  0x07, 0x7E, 0x0E, 0x0F, 0xDF, 0xC6, 0x3F, 0x81, 0xFF, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xC6, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xE0, 0x1C, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x38, 0x61, 0xC7, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1F, 0x18, 0x00,
  0x03, 0xF3, 0x80, 0x00, 0xE7, 0x38, 0x00, 0x1C, 0x63, 0x00, 0x03, 0x86,
  0x30, 0x00, 0x70, 0x63, 0x00, 0x0E, 0x06, 0x70, 0x03, 0x80, 0xE7, 0x00,
  0x70, 0x0E, 0x70, 0x0E, 0x00, 0xC6, 0x01, 0xC0, 0x0C, 0x60, 0x38, 0x00,
  0xC6, 0x0F, 0x00, 0x1C, 0xE1, 0xC0, 0x01, 0xCE, 0x38, 0x00, 0x1C, 0xE7,
  0x00, 0x01, 0x8E, 0xE0, 0x00, 0x18, 0xFC, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x38, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1E, 0x00,
  0x7E, 0x01, 0xF6, 0x0F, 0xCE, 0x3F, 0x0E, 0xF8, 0x0C, 0xE0, 0x0C, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01,
  0xC0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0E, 0x7F, 0xE0, 0x00, 0x6F, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x08, 0x00, 0x30, 0x7F, 0xC0, 0x38, 0xFF, 0xF8, 0x19, 0xE0, 0x1E, 0x0D,
  0xC0, 0x07, 0x8F, 0xC0, 0x01, 0xC7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7C,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x3E, 0x38, 0x00, 0x37, 0x1E, 0x00, 0x73, 0x07, 0x80,
  0xF1, 0x81, 0xFF, 0xF1, 0xC0, 0x3F, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0F,
  0x00, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xE0, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xE3, 0x80, 0x01,
  0x9C, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x07, 0x01, 0x80, 0x18, 0x01, 0x81, 0xC0, 0x3F, 0x80, 0xC1, 0xC0, 0x7F,
  0xE0, 0x60, 0xC0, 0x70, 0x30, 0x30, 0xE0, 0x70, 0x18, 0x18, 0x60, 0x70,
  0x0C, 0x0C, 0x70, 0x30, 0x06, 0x06, 0x30, 0x38, 0x06, 0x03, 0x18, 0x18,
  0x03, 0x01, 0x98, 0x1C, 0x01, 0x80, 0xCC, 0x0C, 0x00, 0x80, 0x66, 0x06,
  0x00, 0xC0, 0x37, 0x07, 0x00, 0x60, 0x33, 0x03, 0x00, 0x30, 0x19, 0x81,
  0x80, 0x30, 0x0C, 0xC0, 0xC0, 0x18, 0x06, 0x60, 0x60, 0x0C, 0x06, 0x30,
  0x60, 0x0E, 0x03, 0x38, 0x30, 0x06, 0x01, 0x98, 0x18, 0x07, 0x01, 0x8C,
  0x0C, 0x07, 0x80, 0xC7, 0x07, 0x07, 0xC0, 0xC1, 0x81, 0x87, 0x20, 0xE0,
  0xC0, 0xFF, 0x1C, 0xE0, 0x60, 0x3F, 0x0F, 0xE0, 0x30, 0x0E, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x60, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x3C,
  0x03, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x07, 0x80, 0x18,
  0x00, 0x3E, 0x00, 0x30, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x01, 0xFF, 0xF1, 0x80, 0x07, 0xFF, 0x8E, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x07, 0x80,
  0x60, 0x00, 0x07, 0x80, 0x30, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x00, 0xCF, 0xE0, 0x00, 0x00, 0x6F, 0x70, 0x00, 0x00, 0x7F, 0x1C,
  0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0x70, 0x00, 0x76, 0x03, 0x30, 0x00, 0x66, 0x03,
  0x30, 0x00, 0xE6, 0x03, 0x30, 0x00, 0xCE, 0x07, 0x30, 0x01, 0xCE, 0x07,
  0x38, 0x01, 0x8C, 0x06, 0x38, 0x03, 0x8C, 0x06, 0x18, 0x07, 0x0C, 0x06,
  0x18, 0x06, 0x0C, 0x06, 0x18, 0x0E, 0x1C, 0x0E, 0x1C, 0x0C, 0x1C, 0x0E,
  0x1C, 0x1C, 0x18, 0x0C, 0x0C, 0x18, 0x18, 0x0C, 0x0C, 0x38, 0x18, 0x0C,
  0x0C, 0x30, 0x38, 0x1C, 0x0C, 0x70, 0x38, 0x1C, 0x0E, 0xE0, 0x30, 0x1C,
  0x06, 0xC0, 0x30, 0x18, 0x07, 0xC0, 0x30, 0x18, 0x07, 0x80, 0x30, 0x18,
  0x07, 0x80, 0x70, 0x38, 0x07, 0x00, 0x70, 0x38, 0x07, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x06, 0x03,
  0xE0, 0x00, 0x06, 0x03, 0x70, 0x00, 0x0E, 0x03, 0x30, 0x00, 0x0E, 0x03,
  0x30, 0x00, 0x0C, 0x07, 0x38, 0x00, 0x0C, 0x07, 0x18, 0x00, 0x0C, 0x06,
  0x1C, 0x00, 0x1C, 0x06, 0x0C, 0x00, 0x1C, 0x06, 0x0C, 0x00, 0x1C, 0x06,
  0x0E, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x18, 0x0C,
  0x07, 0x00, 0x38, 0x0C, 0x03, 0x00, 0x38, 0x0C, 0x03, 0x00, 0x38, 0x1C,
  0x03, 0x80, 0x30, 0x1C, 0x01, 0x80, 0x30, 0x1C, 0x01, 0xC0, 0x30, 0x18,
  0x00, 0xC0, 0x70, 0x18, 0x00, 0xC0, 0x70, 0x18, 0x00, 0xE0, 0x70, 0x38,
  0x00, 0x60, 0x60, 0x38, 0x00, 0x60, 0x60, 0x38, 0x00, 0x70, 0x60, 0x30,
  0x00, 0x30, 0xE0, 0x30, 0x00, 0x38, 0xE0, 0x30, 0x00, 0x38, 0xC0, 0x70,
  0x00, 0x18, 0xC0, 0x70, 0x00, 0x1C, 0xC0, 0x70, 0x00, 0x0D, 0xC0, 0x60,
  0x00, 0x0D, 0xC0, 0x60, 0x00, 0x0F, 0xC0, 0x60, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0F,
  0x80, 0x0E, 0x00, 0x07, 0x80, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0x80,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x78, 0x01, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x30,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1B, 0x80, 0x0E, 0x00, 0x37, 0x00, 0x3C, 0x00,
  0xEE, 0x00, 0x78, 0x01, 0x9C, 0x00, 0xF0, 0x03, 0x38, 0x03, 0x60, 0x0E,
  0x70, 0x06, 0xC0, 0x1C, 0xE0, 0x0D, 0x80, 0x31, 0xC0, 0x33, 0x00, 0x63,
  0x80, 0x66, 0x01, 0xC7, 0x01, 0xCC, 0x03, 0x0E, 0x03, 0x18, 0x06, 0x1C,
  0x06, 0x30, 0x1C, 0x38, 0x1C, 0x60, 0x30, 0x70, 0x30, 0xC0, 0x60, 0xC0,
  0x61, 0x81, 0xC1, 0x81, 0xC3, 0x03, 0x83, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x18, 0x30, 0x30, 0x60, 0x30, 0x60,
  0x60, 0xC0, 0x61, 0xC0, 0xC3, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x86, 0x03,
  0x0C, 0x03, 0x1C, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x60, 0x0C, 0x60, 0x1C,
  0xC0, 0x19, 0xC0, 0x39, 0x80, 0x33, 0x00, 0x77, 0x00, 0x66, 0x00, 0xEC,
  0x00, 0xDC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xF0, 0x03, 0x60, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00,
  0x1D, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x00, 0x03, 0x38, 0x00, 0x1B, 0x80, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xC1, 0xC1, 0x83, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0xF8,
  0x03, 0xC0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30,
  0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x01, 0x81, 0xF0, 0x00,
  0x30, 0x78, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x7C, 0x38, 0x00, 0x1F, 0x87, 0x00,
  0x0F, 0x70, 0x78, 0x07, 0x8E, 0x07, 0xFF, 0xE1, 0xC0, 0x7F, 0xF0, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x0E, 0x1F, 0xF8, 0x01, 0x8F, 0xFF, 0x80, 0x33, 0x80, 0x78, 0x06, 0xE0,
  0x03, 0x80, 0xF0, 0x00, 0x30, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0x6C, 0x00, 0x78, 0x1C, 0xE0,
  0x1E, 0x03, 0x8F, 0xFF, 0x80, 0x60, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x80,
  0x3C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x30,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x0E, 0x00,
  0x3F, 0xF8, 0x70, 0x03, 0xFF, 0xE3, 0x80, 0x3C, 0x03, 0x98, 0x03, 0x80,
  0x0E, 0xC0, 0x38, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x07,
  0x80, 0x38, 0x00, 0xEC, 0x00, 0xF0, 0x1E, 0x60, 0x03, 0xFF, 0xE7, 0x00,
  0x0F, 0xFC, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x80, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE1, 0xC0,
  0x0F, 0xFF, 0x8E, 0x00, 0xF0, 0x0E, 0x60, 0x0E, 0x00, 0x3B, 0x00, 0xE0,
  0x00, 0xD8, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0xE0, 0x03,
  0xB0, 0x03, 0xC0, 0x79, 0x80, 0x0F, 0xFF, 0x9C, 0x00, 0x3F, 0xF0, 0xE0,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x0C, 0x0F, 0xFC, 0x01,
  0x87, 0xFF, 0xC0, 0x31, 0xC0, 0x3C, 0x0E, 0x70, 0x01, 0xC1, 0xD8, 0x00,
  0x38, 0x36, 0x00, 0x03, 0x07, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x0C, 0x01, 0xE0,
  0x00, 0xC0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x18,
  0x3C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x19, 0xF0, 0x00, 0x03, 0xBF, 0x00,
  0x00, 0x3F, 0xB8, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00, 0x70, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0xCF, 0xF8, 0x3F, 0xC0,
  0x37, 0xFF, 0x3F, 0xF8, 0x1F, 0x81, 0xDC, 0x07, 0x07, 0xC0, 0x36, 0x01,
  0xC1, 0xE0, 0x0F, 0x00, 0x30, 0x70, 0x03, 0x80, 0x0C, 0x18, 0x00, 0xE0,
  0x03, 0x06, 0x00, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x70, 0xE0, 0x03,
  0x00, 0x1C, 0x30, 0x00, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0x01, 0x83, 0x00,
  0x1C, 0x00, 0x61, 0xC0, 0x06, 0x00, 0x18, 0x70, 0x01, 0x80, 0x0E, 0x18,
  0x00, 0x60, 0x03, 0x86, 0x00, 0x38, 0x00, 0xC1, 0x80, 0x0E, 0x00, 0x30,
  0x60, 0x03, 0x80, 0x0C, 0x38, 0x00, 0xC0, 0x03, 0x0E, 0x00, 0x30, 0x01,
  0xC3, 0x00, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x01, 0x87, 0x00, 0x18, 0x00, 0x61, 0xC0, 0x06,
  0x00, 0x38, 0x60, 0x01, 0x80, 0x0E, 0x18, 0x00, 0xE0, 0x03, 0x06, 0x00,
  0x38, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0xC0,
  0xFF, 0xC0, 0x18, 0x7F, 0xFC, 0x03, 0x1C, 0x03, 0xC0, 0xE6, 0x00, 0x1C,
  0x1D, 0x80, 0x03, 0x83, 0x60, 0x00, 0x30, 0x78, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0x80, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x78, 0x00, 0x0C, 0x1F, 0xF8, 0x00, 0x63,
  0xFF, 0xE0, 0x03, 0x38, 0x07, 0x80, 0x1B, 0x80, 0x0E, 0x01, 0xF0, 0x00,
  0x70, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xF0, 0x01, 0xE0,
  0x1D, 0xE0, 0x3E, 0x00, 0xE7, 0xFF, 0xE0, 0x06, 0x0F, 0xFC, 0x00, 0x30,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFE, 0x1C, 0x03, 0xFF, 0xE3, 0x80, 0xF0, 0x0E, 0x60, 0x38, 0x00, 0xEC,
  0x0E, 0x00, 0x0F, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x1C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0xC0, 0x3C, 0x07, 0x98,
  0x03, 0xFF, 0xE7, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0x80, 0xFF, 0xC0, 0xC1, 0xFF, 0xE0, 0xE3, 0xE0,
  0x00, 0x73, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x38, 0x0C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x18, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x1F, 0x0E, 0x00, 0x0F, 0xC1, 0xC0, 0x07, 0x60, 0x78, 0x07,
  0x98, 0x0F, 0xFF, 0x86, 0x00, 0xFF, 0xC3, 0x80, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60,
  0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x33,
  0x00, 0x3C, 0x00, 0xE6, 0x00, 0x78, 0x01, 0x8C, 0x01, 0xF0, 0x03, 0x18,
  0x03, 0x60, 0x0E, 0x30, 0x06, 0xC0, 0x18, 0x60, 0x19, 0x80, 0x30, 0xC0,
  0x33, 0x00, 0xE1, 0x80, 0xE6, 0x01, 0x83, 0x01, 0x8E, 0x07, 0x06, 0x07,
  0x1C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x70, 0x30, 0x60,
  0x60, 0xC0, 0x60, 0xC0, 0xC3, 0x80, 0xC3, 0x81, 0x86, 0x01, 0x86, 0x03,
  0x0C, 0x03, 0x0C, 0x06, 0x38, 0x06, 0x30, 0x0C, 0x60, 0x0E, 0x60, 0x18,
  0xC0, 0x1D, 0x80, 0x33, 0x00, 0x3B, 0x00, 0x66, 0x00, 0x76, 0x00, 0xDC,
  0x00, 0x78, 0x00, 0xB0, 0x00, 0xF0, 0x01, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x11, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0x0F, 0xFE, 0x00, 0x03, 0x1C, 0x0F, 0x00, 0x07, 0x38, 0x07, 0x80,
  0x06, 0x30, 0x03, 0xC0, 0x0E, 0x70, 0x01, 0xE0, 0x1C, 0x60, 0x00, 0x78,
  0x38, 0xE0, 0x00, 0x3F, 0xF8, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 42, 35, 12, -42 },
  { 54, 12, 12, 35, 14, -44 },
  { 72, 34, 42, 35, 1, -42 },
  { 251, 28, 54, 35, 4, -48 },
  { 440, 28, 44, 35, 4, -43 },
  { 594, 30, 44, 35, 2, -43 },
  { 759, 4, 12, 35, 17, -44 },
  { 765, 18, 61, 35, 10, -47 },
  { 903, 18, 61, 35, 5, -47 },
  { 1041, 25, 24, 35, 8, -42 },
  { 1116, 28, 31, 35, 4, -35 },
  { 1225, 7, 13, 35, 7, -5 },
  { 1237, 20, 2, 35, 7, -20 },
  { 1242, 5, 4, 35, 13, -4 },
  { 1245, 27, 46, 35, 5, -42 },
  { 1401, 28, 44, 35, 4, -43 },
  { 1555, 16, 42, 35, 9, -42 },
  { 1639, 28, 43, 35, 1, -43 },
  { 1790, 29, 44, 35, 1, -43 },
  { 1950, 29, 42, 35, 1, -42 },
  { 2103, 29, 43, 35, 5, -42 },
  { 2259, 25, 43, 35, 4, -42 },
  { 2394, 27, 42, 35, 7, -42 },
  { 2536, 30, 44, 35, 3, -43 },
  { 2701, 25, 43, 35, 6, -43 },
  { 2836, 9, 29, 35, 15, -29 },
  { 2869, 13, 37, 35, 11, -29 },
  { 2930, 26, 24, 35, 5, -31 },
  { 3008, 27, 14, 35, 4, -26 },
  { 3056, 27, 24, 35, 3, -31 },
  { 3137, 22, 43, 35, 9, -43 },
  { 3256, 33, 42, 35, 1, -42 },
  { 3430, 29, 42, 35, 0, -42 },
  { 3583, 29, 42, 35, 3, -42 },
  { 3736, 29, 44, 35, 4, -43 },
  { 3896, 31, 42, 35, 2, -42 },
  { 4059, 31, 42, 35, 3, -42 },
  { 4222, 31, 42, 35, 3, -42 },
  { 4385, 30, 44, 35, 3, -43 },
  { 4550, 32, 42, 35, 2, -42 },
  { 4718, 30, 42, 35, 3, -42 },
  { 4876, 31, 43, 35, 2, -42 },
  { 5043, 33, 42, 35, 3, -42 },
  { 5217, 24, 42, 35, 3, -42 },
  { 5343, 32, 42, 35, 2, -42 },
  { 5511, 32, 42, 35, 2, -42 },
  { 5679, 28, 44, 35, 4, -43 },
  { 5833, 31, 42, 35, 3, -42 },
  { 5996, 30, 50, 35, 3, -43 },
  { 6184, 30, 42, 35, 3, -42 },
  { 6342, 30, 44, 35, 3, -43 },
  { 6507, 29, 42, 35, 7, -42 },
  { 6660, 30, 43, 35, 4, -42 },
  { 6822, 28, 42, 35, 7, -42 },
  { 6969, 31, 42, 35, 6, -42 },
  { 7132, 35, 42, 35, 1, -42 },
  { 7316, 29, 42, 35, 7, -42 },
  { 7469, 31, 42, 35, 1, -42 },
  { 7632, 18, 57, 35, 9, -48 },
  { 7761, 11, 46, 35, 12, -42 },
  { 7825, 18, 57, 35, 8, -48 },
  { 7954, 21, 23, 35, 7, -42 },
  { 8015, 24, 2, 35, 2, 0 },
  { 8021, 7, 7, 35, 17, -43 },
  { 8028, 27, 33, 35, 3, -32 },
  { 8140, 27, 45, 35, 3, -44 },
  { 8292, 26, 33, 35, 4, -32 },
  { 8400, 29, 45, 35, 4, -44 },
  { 8564, 26, 33, 35, 4, -32 },
  { 8672, 29, 45, 35, 7, -45 },
  { 8836, 29, 45, 35, 2, -32 },
  { 9000, 27, 44, 35, 3, -44 },
  { 9149, 25, 42, 35, 3, -42 },
  { 9281, 27, 55, 35, 0, -42 },
  { 9467, 28, 44, 35, 4, -44 },
  { 9621, 25, 44, 35, 3, -44 },
  { 9759, 34, 32, 35, -1, -32 },
  { 9895, 27, 32, 35, 3, -32 },
  { 10003, 28, 33, 35, 3, -32 },
  { 10119, 29, 44, 35, 1, -32 },
  { 10279, 27, 44, 35, 4, -32 },
  { 10428, 25, 32, 35, 7, -32 },
  { 10528, 27, 33, 35, 4, -32 },
  { 10640, 23, 40, 35, 7, -39 },
  { 10755, 26, 32, 35, 5, -31 },
  { 10859, 28, 31, 35, 5, -31 },
  { 10968, 31, 31, 35, 4, -31 },
  { 11089, 32, 31, 35, 1, -31 },
  { 11213, 35, 44, 35, -1, -31 },
  { 11406, 30, 31, 35, 1, -31 },
  { 11523, 23, 58, 35, 9, -46 },
  { 11690, 10, 51, 35, 12, -42 },
  { 11754, 23, 58, 35, 5, -46 },
  { 11921, 32, 11, 35, 1, -23 },
};

const GFXfont RobotoMono_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC59PT7B_H_
