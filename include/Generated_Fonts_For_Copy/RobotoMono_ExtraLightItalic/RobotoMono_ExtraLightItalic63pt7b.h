#ifndef _ROBOTOMONO_EXTRALIGHTITALIC63PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x38, 0x39, 0xC1, 0xCC, 0x0E, 0x60, 0x63, 0x03, 0x38,
  0x19, 0xC0, 0xCC, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x19, 0xC0, 0xCC, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x86, 0x00, 0x60, 0x07,
  0x18, 0x01, 0x80, 0x38, 0xE0, 0x06, 0x00, 0xC3, 0x80, 0x18, 0x07, 0x0C,
  0x00, 0x60, 0x38, 0x30, 0x03, 0x80, 0xC0, 0xC0, 0x0C, 0x06, 0x03, 0x00,
  0x30, 0x38, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x06, 0x06, 0x00, 0x60, 0x38,
  0x38, 0x01, 0xC3, 0xC1, 0xC0, 0x03, 0xFE, 0x06, 0x00, 0x07, 0xE0, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x00,
  0x01, 0xC0, 0xFF, 0x00, 0x0E, 0x0F, 0x1E, 0x00, 0x30, 0x30, 0x18, 0x01,
  0x81, 0x80, 0x70, 0x0E, 0x0E, 0x00, 0xC0, 0x70, 0x30, 0x03, 0x01, 0x80,
  0xC0, 0x0C, 0x0E, 0x07, 0x00, 0x30, 0x70, 0x18, 0x00, 0xC1, 0x80, 0x60,
  0x07, 0x0E, 0x01, 0x80, 0x1C, 0x70, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01,
  0x8C, 0x00, 0x60, 0x0E, 0x10, 0x01, 0x80, 0x30, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7C, 0x1C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x38,
  0xE0, 0x0E, 0x00, 0x63, 0xC0, 0x0E, 0x00, 0xC7, 0x00, 0x0E, 0x03, 0x9C,
  0x00, 0x1C, 0x07, 0x38, 0x00, 0x1C, 0x1C, 0x60, 0x00, 0x38, 0x39, 0xC0,
  0x00, 0x38, 0xE3, 0x80, 0x00, 0x39, 0xC7, 0x00, 0x00, 0x77, 0x0E, 0x00,
  0x00, 0x7C, 0x1C, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0xF9, 0xC0, 0x78, 0x07,
  0xC1, 0xC0, 0x7F, 0xFF, 0x03, 0x80, 0x3F, 0xF8, 0x03, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x39, 0xCC, 0x63, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x40, 0x06, 0x00, 0x6E, 0x00, 0xC0,
  0x3F, 0xF8, 0x18, 0x3F, 0x9F, 0xE3, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x86, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xF1, 0xC0, 0x00, 0x1F, 0xC7, 0x00, 0x00, 0xE7, 0x18, 0x00, 0x07, 0x1C,
  0xE0, 0x00, 0x38, 0x63, 0x80, 0x01, 0xC1, 0x8E, 0x00, 0x1E, 0x06, 0x38,
  0x00, 0xE0, 0x38, 0xC0, 0x07, 0x00, 0xE3, 0x00, 0x38, 0x03, 0x9C, 0x01,
  0xC0, 0x0C, 0x70, 0x1E, 0x00, 0x31, 0xC0, 0xF0, 0x01, 0xC7, 0x07, 0x00,
  0x07, 0x18, 0x38, 0x00, 0x1C, 0x61, 0xC0, 0x00, 0x71, 0x8E, 0x00, 0x01,
  0x86, 0xF0, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xE6, 0x1F,
  0x86, 0xFE, 0x06, 0xF0, 0x0E, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x1B, 0xFF, 0xF0, 0x00, 0x7F, 0x81,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x1F, 0xF8, 0x03, 0x0F, 0xFF, 0x80, 0xE7, 0xC0, 0x78, 0x1D,
  0xE0, 0x03, 0x83, 0x70, 0x00, 0x38, 0x7C, 0x00, 0x03, 0x9F, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x78, 0x01, 0xF0, 0x03, 0x80, 0x78, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x3E, 0x38, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xB8,
  0x78, 0x01, 0xE6, 0x07, 0x80, 0xF9, 0xC0, 0x7F, 0xFC, 0x38, 0x03, 0xFE,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0F,
  0x07, 0xC3, 0xC1, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x78, 0x01, 0xC1,
  0xC0, 0x01, 0xC7, 0x00, 0x01, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0xF0, 0x06, 0x03, 0x80, 0x7F, 0xC0, 0x60,
  0x30, 0x0F, 0x9E, 0x06, 0x07, 0x01, 0xC0, 0x60, 0x60, 0x60, 0x38, 0x06,
  0x06, 0x0E, 0x07, 0x00, 0x60, 0x70, 0xC0, 0x60, 0x0C, 0x06, 0x1C, 0x0E,
  0x00, 0xC0, 0x61, 0x80, 0xC0, 0x0C, 0x06, 0x18, 0x1C, 0x01, 0x80, 0x63,
  0x81, 0x80, 0x18, 0x06, 0x30, 0x18, 0x01, 0x80, 0x63, 0x03, 0x80, 0x18,
  0x06, 0x70, 0x30, 0x03, 0x00, 0xE6, 0x03, 0x00, 0x30, 0x0C, 0x60, 0x30,
  0x03, 0x00, 0xC6, 0x07, 0x00, 0x30, 0x0C, 0x60, 0x60, 0x06, 0x01, 0xC6,
  0x06, 0x00, 0x60, 0x18, 0x60, 0x60, 0x0E, 0x01, 0x86, 0x06, 0x01, 0xE0,
  0x30, 0x60, 0x60, 0x1E, 0x03, 0x06, 0x06, 0x03, 0x60, 0x60, 0x60, 0x70,
  0x66, 0x0E, 0x06, 0x03, 0x9C, 0x71, 0xC0, 0x60, 0x3F, 0x83, 0xF8, 0x06,
  0x01, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0E, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x07, 0x80,
  0x30, 0x00, 0x07, 0x80, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x07,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xE0, 0x60, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x3E, 0x03, 0x80,
  0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x3E, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xFF, 0xF9, 0xC0, 0x03, 0xFF, 0xF3, 0x00, 0x07, 0xFF,
  0xE6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x00,
  0x30, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00,
  0xE3, 0xE0, 0x00, 0x00, 0x0E, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x38, 0x00,
  0x00, 0x0D, 0xC3, 0x80, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x01, 0x80, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x6C, 0x03, 0x60, 0x00, 0x1F, 0x80,
  0x6C, 0x00, 0x07, 0x70, 0x0D, 0xC0, 0x00, 0xEC, 0x03, 0xB8, 0x00, 0x39,
  0x80, 0x73, 0x00, 0x07, 0x30, 0x0E, 0x60, 0x01, 0xCE, 0x01, 0x8C, 0x00,
  0x39, 0xC0, 0x31, 0xC0, 0x0E, 0x38, 0x06, 0x38, 0x01, 0x86, 0x01, 0xC3,
  0x00, 0x70, 0xC0, 0x38, 0x60, 0x1C, 0x18, 0x07, 0x0C, 0x03, 0x87, 0x00,
  0xC1, 0xC0, 0xE0, 0xE0, 0x18, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x07, 0x03,
  0x00, 0xE0, 0x60, 0xC0, 0x60, 0x1C, 0x0C, 0x38, 0x1C, 0x03, 0x81, 0x86,
  0x03, 0x80, 0x60, 0x39, 0xC0, 0x70, 0x0C, 0x07, 0x70, 0x0E, 0x03, 0x80,
  0x6E, 0x01, 0x80, 0x70, 0x0F, 0x80, 0x30, 0x0E, 0x01, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x01, 0xC0, 0x30, 0x07, 0x00, 0x38, 0x06, 0x00, 0x60, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x01, 0x80,
  0x6C, 0x00, 0x00, 0x60, 0x1B, 0x00, 0x00, 0x18, 0x0E, 0xE0, 0x00, 0x0E,
  0x03, 0x98, 0x00, 0x03, 0x80, 0xE7, 0x00, 0x00, 0xE0, 0x31, 0xC0, 0x00,
  0x30, 0x0C, 0x30, 0x00, 0x0C, 0x03, 0x0E, 0x00, 0x07, 0x01, 0xC3, 0x80,
  0x01, 0xC0, 0x70, 0x60, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0x1C, 0x06, 0x03,
  0x00, 0x06, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xE0, 0x38, 0x00, 0xE0, 0x38,
  0x06, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x03, 0x80,
  0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0x70, 0x18, 0x00, 0x30, 0x18, 0x06, 0x00, 0x0E, 0x06, 0x03, 0x80, 0x01,
  0x83, 0x80, 0xE0, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x1C, 0x38, 0x0C, 0x00,
  0x03, 0x0C, 0x03, 0x00, 0x00, 0xE3, 0x00, 0xC0, 0x00, 0x19, 0xC0, 0x70,
  0x00, 0x06, 0x70, 0x1C, 0x00, 0x01, 0xDC, 0x07, 0x00, 0x00, 0x37, 0x01,
  0x80, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x01,
  0xC0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x78, 0x01,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xF0, 0x0C,
  0x00, 0x03, 0xE0, 0x1C, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0xC0, 0x0E,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x70,
  0x00, 0xEC, 0x00, 0x38, 0x00, 0x66, 0x00, 0x3C, 0x00, 0x73, 0x00, 0x1E,
  0x00, 0x39, 0x80, 0x0F, 0x00, 0x18, 0xC0, 0x0F, 0x80, 0x0C, 0x60, 0x06,
  0xC0, 0x0E, 0x30, 0x03, 0x60, 0x06, 0x18, 0x03, 0xB8, 0x03, 0x0C, 0x01,
  0x9C, 0x03, 0x86, 0x00, 0xCE, 0x01, 0xC3, 0x00, 0xE7, 0x00, 0xC1, 0x80,
  0x63, 0x80, 0xE0, 0xC0, 0x31, 0xC0, 0x70, 0x60, 0x38, 0xE0, 0x30, 0x30,
  0x18, 0x70, 0x18, 0x18, 0x0C, 0x38, 0x1C, 0x0C, 0x0E, 0x1C, 0x0C, 0x06,
  0x06, 0x0E, 0x06, 0x03, 0x07, 0x03, 0x07, 0x01, 0x83, 0x81, 0x83, 0x80,
  0xC1, 0x80, 0xC1, 0x80, 0x61, 0xC0, 0x61, 0xC0, 0x30, 0xE0, 0x30, 0xE0,
  0x18, 0x60, 0x18, 0x60, 0x0C, 0x70, 0x0C, 0x30, 0x06, 0x38, 0x06, 0x38,
  0x03, 0x18, 0x03, 0x18, 0x01, 0x9C, 0x01, 0x8C, 0x00, 0xCE, 0x00, 0xCE,
  0x00, 0x66, 0x00, 0x67, 0x00, 0x37, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x1B,
  0x80, 0x1D, 0x80, 0x0D, 0xC0, 0x0F, 0xC0, 0x06, 0xC0, 0x07, 0xE0, 0x03,
  0x60, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x98, 0x00, 0x0C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x83, 0x00, 0x0E,
  0x0C, 0x00, 0x70, 0x38, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x18, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00,
  0x06, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x03,
  0x01, 0xF0, 0x00, 0x18, 0x3E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F,
  0x87, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x0E, 0xC0, 0xE0, 0x01, 0xE6, 0x07,
  0xC0, 0x3E, 0x30, 0x1F, 0xFF, 0xC1, 0x80, 0x3F, 0xF8, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0xFC, 0x00, 0x0C, 0x1F, 0xFC, 0x00, 0x63, 0xFF, 0xF0,
  0x07, 0x3C, 0x03, 0xC0, 0x3B, 0x80, 0x0F, 0x01, 0xF0, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x1F, 0x00,
  0x03, 0x80, 0xDC, 0x00, 0x78, 0x06, 0x78, 0x0F, 0x80, 0x71, 0xFF, 0xF8,
  0x03, 0x83, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFC, 0x07, 0x00, 0x0F, 0xFE, 0x0E, 0x00, 0x3F, 0xFF,
  0x1C, 0x01, 0xF0, 0x0F, 0x30, 0x07, 0x80, 0x07, 0x60, 0x0E, 0x00, 0x07,
  0xC0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0xE0, 0x03,
  0xF8, 0x01, 0xF0, 0x1E, 0x70, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0xFF, 0xC1,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC1, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x7F, 0xFE, 0x38,
  0x03, 0xE0, 0x1E, 0x70, 0x0F, 0x00, 0x0E, 0xC0, 0x1C, 0x00, 0x0F, 0x80,
  0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xE0, 0x3C, 0xE0, 0x01, 0xFF, 0xF1, 0xC0, 0x01, 0xFF, 0x83, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x20,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x1C, 0x0F, 0xFE, 0x00, 0xE1, 0xFF,
  0xF8, 0x07, 0x1E, 0x01, 0xE0, 0x31, 0xC0, 0x07, 0x81, 0x98, 0x00, 0x1C,
  0x0D, 0x80, 0x00, 0x60, 0xF8, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00,
  0x60, 0x00, 0xF0, 0x01, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0C, 0x07,
  0x80, 0x00, 0x30, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x1C, 0xF8, 0x00, 0x00, 0x77, 0xF0, 0x00, 0x01, 0xF9, 0xC0, 0x00,
  0x07, 0xC3, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x87,
  0xC0, 0x1F, 0x80, 0x31, 0xFF, 0x07, 0xFC, 0x03, 0x3F, 0xF8, 0xFF, 0xE0,
  0x37, 0x03, 0x9C, 0x07, 0x03, 0xC0, 0x1F, 0x80, 0x70, 0x78, 0x01, 0xF0,
  0x03, 0x07, 0x00, 0x1E, 0x00, 0x30, 0x70, 0x01, 0xC0, 0x03, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x60, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0xE0, 0x01, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x80,
  0x06, 0x0C, 0x00, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x80, 0x06, 0x1C, 0x00,
  0x30, 0x00, 0xE1, 0xC0, 0x03, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x00, 0xE1,
  0x80, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x00, 0xC1, 0x80, 0x07, 0x00,
  0x0C, 0x38, 0x00, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x00, 0x1C, 0x38, 0x00,
  0x60, 0x01, 0xC3, 0x00, 0x0E, 0x00, 0x18, 0x30, 0x00, 0xE0, 0x01, 0x83,
  0x00, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x00,
  0x38, 0x60, 0x00, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x00, 0x30, 0x60, 0x01,
  0xC0, 0x03, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x1F, 0xFC, 0x01, 0xC3, 0xFF, 0xF0, 0x0E, 0x3C, 0x03, 0xC0, 0x63, 0x80,
  0x0E, 0x03, 0x30, 0x00, 0x38, 0x1B, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x06,
  0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0x87, 0xFF, 0x80, 0x07, 0x1F, 0xFF, 0x80, 0x0E,
  0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x07, 0x80, 0x36, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x70, 0x06, 0xE0, 0x03, 0xC0, 0x1C,
  0xF0, 0x1F, 0x00, 0x38, 0xFF, 0xFC, 0x00, 0x70, 0x7F, 0xE0, 0x00, 0xE0,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xC0, 0x1F, 0xFF,
  0x8E, 0x03, 0xE0, 0x1E, 0x60, 0x3C, 0x00, 0x3B, 0x01, 0xC0, 0x00, 0xF8,
  0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x0F, 0x80, 0x70, 0x01, 0xFC, 0x03, 0xE0, 0x3C, 0xE0, 0x07, 0xFF,
  0xC6, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x60, 0x3F, 0xF8,
  0x1C, 0x1F, 0xFF, 0x03, 0x8F, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0F, 0x06, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x76, 0x07, 0x80, 0x0E,
  0x60, 0x3C, 0x03, 0xCE, 0x01, 0xFF, 0xF8, 0xE0, 0x0F, 0xFE, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80, 0x00, 0x60,
  0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xE0,
  0x01, 0xC0, 0x03, 0xB0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0xF0, 0x00, 0xCC,
  0x00, 0x78, 0x00, 0xE6, 0x00, 0x3E, 0x00, 0x63, 0x00, 0x3F, 0x00, 0x71,
  0x80, 0x1B, 0x80, 0x38, 0xC0, 0x1D, 0xC0, 0x18, 0x70, 0x0C, 0x60, 0x1C,
  0x38, 0x06, 0x30, 0x0C, 0x1C, 0x07, 0x18, 0x06, 0x0E, 0x03, 0x0C, 0x07,
  0x07, 0x03, 0x86, 0x03, 0x03, 0x81, 0x83, 0x03, 0x81, 0xC1, 0xC1, 0x81,
  0x80, 0xE0, 0xC0, 0xC0, 0xC0, 0x70, 0x60, 0x60, 0xE0, 0x18, 0x70, 0x30,
  0x60, 0x0C, 0x30, 0x1C, 0x70, 0x06, 0x38, 0x0E, 0x38, 0x03, 0x18, 0x07,
  0x18, 0x01, 0x8C, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x66, 0x00, 0x37, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x0D, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x30, 0xFF, 0xF0, 0x00, 0x0C, 0x70, 0x1E, 0x00, 0x07, 0x38, 0x01, 0xC0,
  0x01, 0x8C, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x07, 0x00, 0x71, 0x80, 0x00,
  0xF0, 0x38, 0x60, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 11, 45, 37, 13, -45 },
  { 63, 13, 13, 37, 15, -47 },
  { 85, 36, 45, 37, 1, -45 },
  { 288, 30, 57, 37, 4, -51 },
  { 502, 30, 46, 37, 4, -45 },
  { 675, 31, 46, 37, 3, -45 },
  { 854, 5, 13, 37, 18, -47 },
  { 863, 19, 64, 37, 11, -50 },
  { 1015, 19, 64, 37, 6, -50 },
  { 1167, 27, 26, 37, 8, -45 },
  { 1255, 30, 33, 37, 4, -37 },
  { 1379, 8, 13, 37, 7, -5 },
  { 1392, 22, 2, 37, 7, -21 },
  { 1398, 5, 5, 37, 14, -5 },
  { 1402, 29, 49, 37, 5, -45 },
  { 1580, 30, 46, 37, 4, -45 },
  { 1753, 16, 45, 37, 10, -45 },
  { 1843, 30, 45, 37, 1, -45 },
  { 2012, 30, 46, 37, 2, -45 },
  { 2185, 31, 45, 37, 1, -45 },
  { 2360, 31, 46, 37, 5, -45 },
  { 2539, 27, 46, 37, 4, -45 },
  { 2695, 28, 45, 37, 8, -45 },
  { 2853, 31, 46, 37, 4, -45 },
  { 3032, 27, 45, 37, 6, -45 },
  { 3184, 9, 32, 37, 16, -32 },
  { 3220, 13, 40, 37, 12, -32 },
  { 3285, 28, 25, 37, 5, -33 },
  { 3373, 29, 15, 37, 4, -28 },
  { 3428, 28, 25, 37, 4, -33 },
  { 3516, 23, 45, 37, 10, -45 },
  { 3646, 36, 45, 37, 1, -45 },
  { 3849, 31, 45, 37, 0, -45 },
  { 4024, 31, 45, 37, 3, -45 },
  { 4199, 31, 46, 37, 4, -45 },
  { 4378, 33, 45, 37, 2, -45 },
  { 4564, 33, 45, 37, 3, -45 },
  { 4750, 33, 45, 37, 3, -45 },
  { 4936, 31, 46, 37, 4, -45 },
  { 5115, 34, 45, 37, 2, -45 },
  { 5307, 32, 45, 37, 3, -45 },
  { 5487, 33, 46, 37, 2, -45 },
  { 5677, 36, 45, 37, 3, -45 },
  { 5880, 25, 45, 37, 4, -45 },
  { 6021, 35, 45, 37, 2, -45 },
  { 6218, 34, 45, 37, 2, -45 },
  { 6410, 30, 46, 37, 4, -45 },
  { 6583, 32, 45, 37, 4, -45 },
  { 6763, 32, 53, 37, 3, -45 },
  { 6975, 32, 45, 37, 3, -45 },
  { 7155, 32, 46, 37, 3, -45 },
  { 7339, 31, 45, 37, 7, -45 },
  { 7514, 32, 46, 37, 4, -45 },
  { 7698, 31, 45, 37, 7, -45 },
  { 7873, 33, 45, 37, 6, -45 },
  { 8059, 37, 45, 37, 1, -45 },
  { 8268, 31, 45, 37, 7, -45 },
  { 8443, 34, 45, 37, 1, -45 },
  { 8635, 20, 61, 37, 9, -51 },
  { 8788, 12, 49, 37, 13, -45 },
  { 8862, 19, 61, 37, 9, -51 },
  { 9007, 22, 25, 37, 8, -45 },
  { 9076, 26, 2, 37, 2, 0 },
  { 9083, 8, 8, 37, 18, -46 },
  { 9091, 29, 35, 37, 3, -34 },
  { 9218, 29, 48, 37, 3, -47 },
  { 9392, 28, 35, 37, 4, -34 },
  { 9515, 31, 48, 37, 4, -47 },
  { 9701, 29, 35, 37, 4, -34 },
  { 9828, 30, 48, 37, 8, -48 },
  { 10008, 31, 47, 37, 2, -34 },
  { 10191, 29, 47, 37, 3, -47 },
  { 10362, 26, 45, 37, 4, -45 },
  { 10509, 29, 58, 37, 0, -45 },
  { 10720, 30, 47, 37, 4, -47 },
  { 10897, 26, 47, 37, 4, -47 },
  { 11050, 36, 34, 37, -1, -34 },
  { 11203, 29, 34, 37, 3, -34 },
  { 11327, 30, 35, 37, 3, -34 },
  { 11459, 31, 47, 37, 1, -34 },
  { 11642, 29, 47, 37, 4, -34 },
  { 11813, 27, 34, 37, 8, -34 },
  { 11928, 29, 35, 37, 4, -34 },
  { 12055, 24, 43, 37, 8, -42 },
  { 12184, 28, 34, 37, 5, -33 },
  { 12303, 30, 33, 37, 6, -33 },
  { 12427, 33, 33, 37, 5, -33 },
  { 12564, 34, 33, 37, 1, -33 },
  { 12705, 38, 46, 37, -1, -33 },
  { 12924, 33, 33, 37, 1, -33 },
  { 13061, 24, 62, 37, 10, -49 },
  { 13247, 11, 54, 37, 13, -45 },
  { 13322, 25, 62, 37, 5, -49 },
  { 13516, 34, 11, 37, 1, -24 },
};

const GFXfont RobotoMono_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC63PT7B_H_
