#ifndef _ROBOTOMONO_EXTRALIGHTITALIC70PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0xF8, 0x07, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x30,
  0x1D, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x38,
  0x0C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x70, 0x01,
  0x80, 0x0E, 0x1C, 0x00, 0x60, 0x07, 0x06, 0x00, 0x18, 0x01, 0xC1, 0x80,
  0x06, 0x00, 0xE0, 0x60, 0x03, 0x80, 0x70, 0x38, 0x00, 0xE0, 0x18, 0x0E,
  0x00, 0x38, 0x0E, 0x03, 0x80, 0x0C, 0x07, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x18, 0x01, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x38,
  0x00, 0x38, 0x78, 0x0E, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x00, 0xFE, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x70, 0x3F, 0xE0,
  0x00, 0x38, 0x1E, 0x3C, 0x00, 0x1C, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x60, 0x03, 0x81, 0xC0, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x38, 0x0C, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x01,
  0xC0, 0x07, 0x03, 0x00, 0x70, 0x01, 0xC1, 0xC0, 0x18, 0x00, 0x60, 0xE0,
  0x06, 0x00, 0x18, 0x70, 0x01, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0x03, 0x82,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x30, 0x70, 0x03, 0xC0,
  0x0E, 0x1E, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x38, 0xE0, 0x00,
  0x70, 0x0E, 0x1C, 0x00, 0x07, 0x01, 0xC7, 0x00, 0x00, 0xF0, 0x78, 0xE0,
  0x00, 0x0E, 0x0E, 0x1C, 0x00, 0x00, 0xE3, 0xC3, 0x00, 0x00, 0x1E, 0x70,
  0x60, 0x00, 0x01, 0xDC, 0x0C, 0x00, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x03,
  0xE0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x07, 0xF0, 0x0F, 0x00, 0x01, 0xE7, 0x00, 0xF0, 0x00, 0xF8, 0xF0, 0x0F,
  0x80, 0xFC, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0xFF, 0x80, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0xCE, 0x73, 0x9C, 0xC6, 0x73, 0x9C,
  0xC6, 0x73, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x0E, 0x00, 0x27, 0x80, 0x38, 0x07, 0xFF,
  0x80, 0xE0, 0x7F, 0x3F, 0xC3, 0x0F, 0xF0, 0x1F, 0xCD, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x87, 0x81, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x77, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3E,
  0x1C, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x3F, 0x87, 0x00, 0x00, 0x39,
  0xC7, 0x00, 0x00, 0x38, 0xE3, 0x80, 0x00, 0x78, 0x71, 0xC0, 0x00, 0x78,
  0x38, 0xE0, 0x00, 0x78, 0x1C, 0x70, 0x00, 0x70, 0x0E, 0x70, 0x00, 0x70,
  0x07, 0x38, 0x00, 0xF0, 0x07, 0x1C, 0x00, 0xF0, 0x03, 0x8E, 0x00, 0xF0,
  0x01, 0xC7, 0x00, 0xE0, 0x00, 0xE3, 0x80, 0xE0, 0x00, 0x73, 0x81, 0xE0,
  0x00, 0x31, 0xC1, 0xE0, 0x00, 0x38, 0xE1, 0xE0, 0x00, 0x1C, 0x71, 0xE0,
  0x00, 0x0E, 0x39, 0xC0, 0x00, 0x07, 0x1D, 0xC0, 0x00, 0x07, 0x0F, 0xC0,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x01, 0xFD, 0x81, 0xF8, 0xE3, 0xF8, 0x3B, 0xF8, 0x0E, 0xF0,
  0x03, 0xB0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x1C, 0x7F, 0xF8, 0x00, 0x07, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x38, 0x3F, 0xFC, 0x00, 0xE1, 0xFF, 0xFC, 0x01,
  0xC7, 0xC0, 0x7C, 0x03, 0xBE, 0x00, 0x3C, 0x0E, 0xF0, 0x00, 0x3C, 0x1F,
  0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1B, 0x0E, 0x00, 0x00,
  0xFC, 0x3C, 0x00, 0x0F, 0x70, 0x78, 0x00, 0x79, 0xC0, 0xF8, 0x0F, 0x86,
  0x01, 0xFF, 0xFC, 0x38, 0x03, 0xFF, 0xC0, 0xE0, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xE0,
  0xFC, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x39,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x1F,
  0x00, 0x30, 0x1C, 0x00, 0xFF, 0x00, 0x60, 0x38, 0x07, 0xFF, 0x80, 0xC0,
  0xE0, 0x1E, 0x07, 0x01, 0xC1, 0x80, 0x78, 0x06, 0x03, 0x87, 0x01, 0xC0,
  0x0C, 0x07, 0x0C, 0x03, 0x80, 0x30, 0x0E, 0x38, 0x0E, 0x00, 0x60, 0x1C,
  0x60, 0x18, 0x00, 0xC0, 0x31, 0xC0, 0x70, 0x01, 0x80, 0x63, 0x80, 0xC0,
  0x06, 0x00, 0xC6, 0x03, 0x80, 0x0C, 0x01, 0x9C, 0x07, 0x00, 0x18, 0x03,
  0x38, 0x0C, 0x00, 0x70, 0x06, 0x60, 0x38, 0x00, 0xC0, 0x1C, 0xC0, 0x70,
  0x01, 0x80, 0x33, 0x80, 0xC0, 0x03, 0x00, 0x67, 0x01, 0x80, 0x0E, 0x00,
  0xCE, 0x07, 0x00, 0x18, 0x03, 0x98, 0x0E, 0x00, 0x30, 0x06, 0x30, 0x1C,
  0x00, 0xE0, 0x0C, 0x60, 0x30, 0x03, 0xC0, 0x38, 0xC0, 0x60, 0x07, 0x00,
  0x61, 0x80, 0xC0, 0x1E, 0x01, 0xC3, 0x01, 0xC0, 0x7C, 0x03, 0x06, 0x03,
  0x81, 0xD8, 0x0E, 0x0C, 0x03, 0x07, 0x38, 0x38, 0x18, 0x07, 0xBC, 0x39,
  0xE0, 0x38, 0x0F, 0xF0, 0x7F, 0x80, 0x70, 0x07, 0xC0, 0x7E, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x02, 0x30, 0x00, 0x3F, 0xFF, 0x8E, 0x00, 0x07, 0xFF,
  0xF1, 0xC0, 0x00, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x1C,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x01, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x3F, 0x80, 0x00,
  0x00, 0x1C, 0xF7, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0x00, 0x00, 0x00, 0xFE,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x07, 0x80, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x77, 0x00, 0x6E, 0x00, 0x00, 0xEE, 0x01, 0xCC, 0x00, 0x03,
  0x98, 0x03, 0x98, 0x00, 0x07, 0x70, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x0E,
  0x70, 0x00, 0x79, 0xC0, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x30, 0xC0, 0x03,
  0x86, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x03,
  0xC1, 0xC0, 0x18, 0x18, 0x07, 0x03, 0x00, 0x70, 0x38, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x03, 0x81, 0xC1,
  0xC0, 0x70, 0x07, 0x01, 0x87, 0x00, 0xE0, 0x0C, 0x03, 0x0E, 0x01, 0x80,
  0x38, 0x07, 0x38, 0x07, 0x00, 0x70, 0x0E, 0xF0, 0x0E, 0x00, 0xE0, 0x1D,
  0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x03, 0x80, 0x3E, 0x00, 0x70,
  0x06, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x3E, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x0D, 0xC0, 0x00, 0x03, 0x80, 0x77, 0x00, 0x00, 0x0E, 0x01,
  0xCE, 0x00, 0x00, 0x38, 0x07, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0xE0, 0x00,
  0x03, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x01, 0x87, 0x00, 0x00, 0x70, 0x0E,
  0x1C, 0x00, 0x01, 0xC0, 0x38, 0x38, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x03, 0x81, 0x80, 0x00, 0x60, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x30,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x06, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x00,
  0x1C, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x06, 0x00, 0x00, 0xC1, 0xC0,
  0x38, 0x00, 0x03, 0x87, 0x00, 0xE0, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x00,
  0x18, 0x70, 0x0E, 0x00, 0x00, 0x71, 0x80, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0xC0, 0x00, 0x03, 0xB8, 0x07, 0x00, 0x00, 0x0E, 0xE0, 0x1C, 0x00, 0x00,
  0x3B, 0x80, 0x70, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3E,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x83, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x3B, 0x00, 0x03, 0x80, 0x03, 0x98, 0x00,
  0x3C, 0x00, 0x1C, 0xC0, 0x01, 0xE0, 0x00, 0xE6, 0x00, 0x0F, 0x00, 0x06,
  0x30, 0x00, 0xF8, 0x00, 0x71, 0x80, 0x07, 0xC0, 0x03, 0x8C, 0x00, 0x36,
  0x00, 0x18, 0x60, 0x03, 0xB0, 0x01, 0xC3, 0x00, 0x1D, 0x80, 0x0E, 0x38,
  0x00, 0xCC, 0x00, 0x71, 0xC0, 0x0E, 0x60, 0x07, 0x0E, 0x00, 0x73, 0x00,
  0x38, 0x70, 0x03, 0x18, 0x01, 0xC3, 0x80, 0x38, 0xC0, 0x0C, 0x1C, 0x01,
  0xC6, 0x00, 0xE0, 0xE0, 0x0C, 0x30, 0x07, 0x07, 0x00, 0xE1, 0x80, 0x30,
  0x38, 0x07, 0x0C, 0x03, 0x81, 0xC0, 0x30, 0x60, 0x1C, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x18, 0x07, 0x03, 0x01, 0xC1,
  0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x60, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE1, 0x80,
  0x1C, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0E,
  0x70, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x3B, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x30, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C,
  0x0E, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xE0, 0x7E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x7C, 0x70, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07, 0x70, 0xE0, 0x00,
  0x3C, 0xE1, 0xF0, 0x01, 0xF1, 0xC1, 0xF8, 0x0F, 0xC7, 0x81, 0xFF, 0xFE,
  0x0F, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x01, 0x87, 0xFF, 0xF0, 0x03, 0x8F,
  0x81, 0xF8, 0x03, 0x9E, 0x00, 0x78, 0x03, 0xB8, 0x00, 0x3C, 0x03, 0xF0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x01, 0xE0, 0x77, 0x00,
  0x03, 0xC0, 0x77, 0x80, 0x0F, 0x80, 0x73, 0xE0, 0x3F, 0x00, 0x70, 0xFF,
  0xFC, 0x00, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x0F, 0xFF, 0xC3, 0x80, 0x0F,
  0xC0, 0x78, 0xE0, 0x07, 0xC0, 0x07, 0x38, 0x03, 0xE0, 0x00, 0xEE, 0x01,
  0xE0, 0x00, 0x1B, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0x80,
  0x0F, 0x70, 0x00, 0xF8, 0x1F, 0x9C, 0x00, 0x1F, 0xFF, 0x86, 0x00, 0x03,
  0xFF, 0x83, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x20, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x70, 0x00, 0xFF, 0xFC, 0x18, 0x00, 0xFC, 0x07, 0x8E, 0x00,
  0x7C, 0x00, 0x73, 0x80, 0x3E, 0x00, 0x0E, 0xE0, 0x1E, 0x00, 0x01, 0xF8,
  0x07, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x01, 0xF0, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xF7, 0x00, 0x0F,
  0x81, 0xF9, 0xC0, 0x01, 0xFF, 0xF8, 0x70, 0x00, 0x3F, 0xF8, 0x38, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x7F, 0xE0,
  0x03, 0x81, 0xFF, 0xF8, 0x03, 0x87, 0xC0, 0x7C, 0x03, 0x8F, 0x00, 0x1E,
  0x03, 0x9C, 0x00, 0x0E, 0x03, 0x38, 0x00, 0x0F, 0x07, 0x60, 0x00, 0x07,
  0x07, 0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0xE0,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xF0, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x07, 0xC0, 0x00, 0x06, 0x03, 0xE0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0xF8,
  0x00, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x03, 0xBF, 0xC0, 0x00, 0x00, 0xDE,
  0x70, 0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0x87, 0xFC, 0x07, 0xFC, 0x03, 0x9F, 0xFE, 0x1F, 0xFE,
  0x03, 0xBC, 0x1E, 0x3C, 0x1E, 0x03, 0xF0, 0x0F, 0x70, 0x0F, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x07, 0x80, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x70, 0x00, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70, 0x60, 0x00, 0x60,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0xFF, 0xE0, 0x03, 0x81, 0xFF, 0xF8, 0x03, 0x87, 0xC0, 0x7C, 0x03,
  0x8F, 0x00, 0x3C, 0x03, 0x9C, 0x00, 0x0E, 0x03, 0x38, 0x00, 0x0E, 0x07,
  0x60, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x1F, 0xFC, 0x00,
  0x0E, 0x1F, 0xFF, 0x80, 0x03, 0x8F, 0x81, 0xF8, 0x00, 0xEF, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x03, 0xC0, 0x0D, 0xC0, 0x00, 0x70, 0x03, 0xE0, 0x00,
  0x0E, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07,
  0xE0, 0x00, 0x3C, 0x01, 0xDE, 0x00, 0x3E, 0x00, 0x73, 0xE0, 0x3F, 0x00,
  0x1C, 0x7F, 0xFF, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x07, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0xFC, 0x07, 0x8E,
  0x01, 0xF0, 0x01, 0xCE, 0x03, 0xE0, 0x00, 0xEE, 0x07, 0x80, 0x00, 0x7E,
  0x07, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0,
  0x1E, 0x00, 0x3D, 0xC0, 0x0F, 0x81, 0xF9, 0xC0, 0x07, 0xFF, 0xE1, 0x80,
  0x03, 0xFF, 0x81, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x1C, 0x03, 0xFF, 0xC0, 0xE0, 0x7F, 0xFE, 0x07,
  0x0F, 0xF0, 0x30, 0x38, 0xF8, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x04, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x06, 0xE0, 0x38, 0x00,
  0x1E, 0xC0, 0x3C, 0x00, 0x7D, 0xC0, 0x1F, 0x01, 0xF1, 0xC0, 0x0F, 0xFF,
  0xE1, 0xC0, 0x03, 0xFF, 0x81, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x03, 0xB8, 0x00, 0x3C,
  0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x0E, 0x70,
  0x00, 0xD8, 0x00, 0x73, 0x80, 0x06, 0xC0, 0x07, 0x1C, 0x00, 0x76, 0x00,
  0x38, 0x60, 0x03, 0x30, 0x01, 0xC3, 0x00, 0x39, 0x80, 0x1C, 0x18, 0x01,
  0xCC, 0x00, 0xE0, 0xC0, 0x1C, 0x60, 0x06, 0x06, 0x00, 0xE3, 0x00, 0x70,
  0x30, 0x06, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x03, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x38, 0x0C, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x1C,
  0x0C, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x70, 0x07, 0x06, 0x01, 0x83,
  0x80, 0x38, 0x70, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x61, 0xC0, 0x0E, 0x38,
  0x03, 0x0E, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x03, 0x8C, 0x00, 0xC7, 0x00,
  0x1C, 0xE0, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x33, 0x80, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x1B, 0x80, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x30, 0x7F, 0xF8, 0x00, 0x01, 0xC3, 0xE1, 0xF8,
  0x00, 0x07, 0x1E, 0x01, 0xF0, 0x00, 0x18, 0xF0, 0x01, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0xC0, 0x07, 0x9C, 0x00, 0x07, 0x80, 0x1C, 0x70, 0x00, 0x0F,
  0x01, 0xE1, 0x80, 0x00, 0x1F, 0xFF, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 12, 50, 41, 14, -50 },
  { 76, 14, 15, 41, 17, -53 },
  { 103, 41, 50, 41, 1, -50 },
  { 360, 33, 64, 41, 5, -57 },
  { 624, 34, 52, 41, 4, -51 },
  { 845, 35, 52, 41, 3, -51 },
  { 1073, 5, 15, 41, 20, -53 },
  { 1083, 21, 72, 41, 12, -56 },
  { 1272, 22, 72, 41, 6, -56 },
  { 1470, 30, 29, 41, 9, -50 },
  { 1579, 34, 36, 41, 4, -41 },
  { 1732, 9, 15, 41, 8, -6 },
  { 1749, 25, 3, 41, 8, -24 },
  { 1759, 5, 5, 41, 16, -5 },
  { 1763, 33, 54, 41, 5, -50 },
  { 1986, 33, 52, 41, 5, -51 },
  { 2201, 18, 50, 41, 11, -50 },
  { 2314, 34, 50, 41, 1, -50 },
  { 2527, 34, 51, 41, 2, -50 },
  { 2744, 34, 50, 41, 2, -50 },
  { 2957, 34, 51, 41, 6, -50 },
  { 3174, 31, 51, 41, 4, -50 },
  { 3372, 32, 50, 41, 8, -50 },
  { 3572, 35, 51, 41, 4, -50 },
  { 3796, 30, 51, 41, 7, -50 },
  { 3988, 11, 35, 41, 17, -35 },
  { 4037, 15, 44, 41, 13, -35 },
  { 4120, 31, 29, 41, 6, -37 },
  { 4233, 32, 17, 41, 5, -31 },
  { 4301, 32, 29, 41, 4, -37 },
  { 4417, 26, 50, 41, 11, -50 },
  { 4580, 39, 50, 41, 2, -50 },
  { 4824, 34, 50, 41, 0, -50 },
  { 5037, 35, 50, 41, 3, -50 },
  { 5256, 35, 51, 41, 4, -50 },
  { 5480, 36, 50, 41, 3, -50 },
  { 5705, 37, 50, 41, 3, -50 },
  { 5937, 36, 50, 41, 4, -50 },
  { 6162, 35, 51, 41, 4, -50 },
  { 6386, 38, 50, 41, 2, -50 },
  { 6624, 36, 50, 41, 3, -50 },
  { 6849, 36, 51, 41, 3, -50 },
  { 7079, 39, 50, 41, 4, -50 },
  { 7323, 29, 50, 41, 4, -50 },
  { 7505, 39, 50, 41, 2, -50 },
  { 7749, 38, 50, 41, 2, -50 },
  { 7987, 34, 51, 41, 4, -50 },
  { 8204, 36, 50, 41, 4, -50 },
  { 8429, 35, 59, 41, 4, -50 },
  { 8688, 35, 50, 41, 4, -50 },
  { 8907, 35, 51, 41, 4, -50 },
  { 9131, 35, 50, 41, 8, -50 },
  { 9350, 36, 51, 41, 4, -50 },
  { 9580, 34, 50, 41, 8, -50 },
  { 9793, 37, 50, 41, 7, -50 },
  { 10025, 41, 50, 41, 1, -50 },
  { 10282, 34, 50, 41, 8, -50 },
  { 10495, 37, 50, 41, 1, -50 },
  { 10727, 21, 68, 41, 11, -57 },
  { 10906, 14, 54, 41, 14, -50 },
  { 11001, 21, 68, 41, 10, -57 },
  { 11180, 24, 27, 41, 9, -50 },
  { 11261, 29, 3, 41, 2, 0 },
  { 11272, 8, 10, 41, 21, -52 },
  { 11282, 31, 39, 41, 4, -38 },
  { 11434, 32, 54, 41, 3, -53 },
  { 11650, 31, 39, 41, 5, -38 },
  { 11802, 34, 54, 41, 5, -53 },
  { 12032, 32, 39, 41, 4, -38 },
  { 12188, 34, 53, 41, 9, -53 },
  { 12414, 34, 53, 41, 3, -38 },
  { 12640, 32, 53, 41, 3, -53 },
  { 12852, 29, 50, 41, 4, -50 },
  { 13034, 32, 65, 41, 0, -50 },
  { 13294, 34, 53, 41, 4, -53 },
  { 13520, 29, 53, 41, 4, -53 },
  { 13713, 40, 38, 41, -1, -38 },
  { 13903, 32, 38, 41, 3, -38 },
  { 14055, 32, 39, 41, 4, -38 },
  { 14211, 34, 52, 41, 1, -38 },
  { 14432, 32, 52, 41, 5, -38 },
  { 14640, 29, 38, 41, 9, -38 },
  { 14778, 31, 39, 41, 5, -38 },
  { 14930, 26, 48, 41, 9, -47 },
  { 15086, 32, 38, 41, 5, -37 },
  { 15238, 34, 37, 41, 6, -37 },
  { 15396, 37, 37, 41, 5, -37 },
  { 15568, 38, 37, 41, 1, -37 },
  { 15744, 42, 52, 41, -1, -37 },
  { 16017, 35, 37, 41, 2, -37 },
  { 16179, 27, 69, 41, 11, -55 },
  { 16412, 12, 60, 41, 14, -50 },
  { 16502, 27, 69, 41, 6, -55 },
  { 16735, 38, 12, 41, 1, -27 },
};

const GFXfont RobotoMono_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC70PT7B_H_
