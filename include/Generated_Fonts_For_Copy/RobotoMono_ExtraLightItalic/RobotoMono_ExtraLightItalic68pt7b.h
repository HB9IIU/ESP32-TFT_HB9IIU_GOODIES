#ifndef _ROBOTOMONO_EXTRALIGHTITALIC68PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x18, 0x0C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x70, 0x39, 0xC0,
  0xE6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x81, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0xE0,
  0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x18, 0x30, 0x01, 0xC0, 0x1C, 0x18,
  0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0x30, 0x0E, 0x07,
  0x00, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0x0C, 0x07, 0x00,
  0x60, 0x0E, 0x07, 0x00, 0x30, 0x0E, 0x07, 0x00, 0x1C, 0x0F, 0x03, 0x00,
  0x07, 0x0F, 0x03, 0x80, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x7E, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x70, 0x3F, 0xF0, 0x00, 0x70,
  0x38, 0x38, 0x00, 0x70, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x00, 0x38,
  0x1C, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0xE0, 0x18, 0x0E, 0x00, 0x70, 0x1C,
  0x06, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x1C, 0x1C, 0x03, 0x80, 0x0C, 0x0E,
  0x01, 0xC0, 0x06, 0x0E, 0x00, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0x03, 0x8F,
  0x00, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x01, 0x07, 0x80, 0xE0, 0x01,
  0x83, 0xC0, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x00, 0x38, 0x70, 0x00, 0xE0,
  0x0E, 0x38, 0x00, 0x38, 0x03, 0x0E, 0x00, 0x07, 0x01, 0xC7, 0x00, 0x00,
  0xE0, 0x71, 0xC0, 0x00, 0x38, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x38, 0x00,
  0x01, 0xE7, 0x0E, 0x00, 0x00, 0x3B, 0xC3, 0x80, 0x00, 0x07, 0xE0, 0x60,
  0x00, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0x38, 0x07, 0x80, 0x07, 0x8F,
  0x00, 0xF8, 0x0F, 0xC1, 0xC0, 0x1F, 0xFF, 0xC0, 0x38, 0x01, 0xFF, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x39, 0x8C, 0x67, 0x39, 0xCC, 0x67,
  0x39, 0xCC, 0x60, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x13, 0x80,
  0x18, 0x03, 0xBF, 0x81, 0xC0, 0xFE, 0xFF, 0x0E, 0x3F, 0xE0, 0xFF, 0x6F,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x71, 0xEF, 0xBE, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x3F, 0x18, 0x00, 0x00, 0xFE, 0x70, 0x00, 0x03, 0x9C,
  0xE0, 0x00, 0x0E, 0x39, 0xC0, 0x00, 0x78, 0x73, 0x80, 0x01, 0xE0, 0xE6,
  0x00, 0x07, 0x81, 0xDC, 0x00, 0x1C, 0x03, 0xB8, 0x00, 0x70, 0x06, 0x70,
  0x03, 0xC0, 0x1C, 0xE0, 0x0F, 0x00, 0x39, 0xC0, 0x3C, 0x00, 0x73, 0x00,
  0xE0, 0x00, 0xEE, 0x03, 0x80, 0x01, 0xDC, 0x0E, 0x00, 0x03, 0x38, 0x78,
  0x00, 0x0E, 0x71, 0xE0, 0x00, 0x1C, 0xE7, 0x80, 0x00, 0x39, 0xDC, 0x00,
  0x00, 0x73, 0xF0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xF1, 0x83, 0xF0, 0x67, 0xF0, 0x39, 0xE0, 0x0E, 0x60, 0x03,
  0xA0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x81,
  0xF0, 0x00, 0x01, 0x8F, 0xFF, 0x00, 0x01, 0xDF, 0xFF, 0xE0, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x00, 0xC0, 0xFF, 0xE0, 0x07, 0x0F,
  0xFF, 0xE0, 0x1C, 0xF8, 0x07, 0xC0, 0x67, 0x80, 0x07, 0x83, 0xB8, 0x00,
  0x0E, 0x0F, 0xC0, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0xD8,
  0x70, 0x00, 0x1D, 0xC3, 0xC0, 0x01, 0xCE, 0x0F, 0x00, 0x3C, 0x70, 0x3F,
  0x0F, 0xC7, 0x00, 0xFF, 0xF8, 0x38, 0x01, 0xFF, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x0F, 0x83, 0xE0, 0xF8, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x01, 0xF8, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0xE0, 0x0F, 0xF0, 0x06, 0x03, 0x00,
  0x7F, 0xF0, 0x18, 0x1C, 0x03, 0xC1, 0xC0, 0x60, 0xE0, 0x1C, 0x03, 0x01,
  0x83, 0x80, 0xE0, 0x0C, 0x06, 0x1C, 0x07, 0x00, 0x30, 0x18, 0x70, 0x18,
  0x01, 0x80, 0x61, 0x80, 0xE0, 0x06, 0x01, 0x8E, 0x03, 0x00, 0x18, 0x06,
  0x30, 0x1C, 0x00, 0xE0, 0x18, 0xC0, 0x60, 0x03, 0x00, 0x67, 0x01, 0x80,
  0x0C, 0x01, 0x98, 0x0E, 0x00, 0x30, 0x0E, 0x60, 0x30, 0x01, 0xC0, 0x31,
  0x80, 0xC0, 0x06, 0x00, 0xCE, 0x07, 0x00, 0x18, 0x03, 0x30, 0x1C, 0x00,
  0xE0, 0x0C, 0xC0, 0x60, 0x03, 0x00, 0x63, 0x01, 0x80, 0x0C, 0x01, 0x8C,
  0x06, 0x00, 0x70, 0x06, 0x30, 0x18, 0x01, 0xC0, 0x30, 0xC0, 0x60, 0x0F,
  0x00, 0xC3, 0x01, 0x80, 0x6C, 0x07, 0x0C, 0x06, 0x03, 0xF0, 0x18, 0x30,
  0x1C, 0x1C, 0xC0, 0xC0, 0xC0, 0x70, 0xE3, 0x0F, 0x03, 0x00, 0xFF, 0x0F,
  0xF8, 0x0E, 0x01, 0xF8, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x1F,
  0xC0, 0x03, 0x80, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1F, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78,
  0x01, 0x80, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x13, 0x80, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0xFF, 0xFE,
  0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x01, 0xC7,
  0xE0, 0x00, 0x00, 0x03, 0x9F, 0xC0, 0x00, 0x00, 0x06, 0x79, 0xC0, 0x00,
  0x00, 0x1D, 0xE3, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0x80, 0x00, 0x00, 0x7E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0xD8, 0x00, 0x01, 0xF8, 0x03, 0x60, 0x00, 0x0E, 0xE0, 0x1D, 0xC0,
  0x00, 0x3B, 0x00, 0x77, 0x00, 0x01, 0xCC, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x07, 0x30, 0x00, 0x39, 0xC0, 0x18, 0xC0, 0x00, 0xE7, 0x00, 0x63, 0x80,
  0x07, 0x1C, 0x03, 0x8E, 0x00, 0x38, 0x60, 0x0E, 0x38, 0x00, 0xE1, 0x80,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x38, 0x03, 0x06, 0x00,
  0xE0, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0C, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x07, 0x03, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x1C,
  0x07, 0x00, 0x60, 0x38, 0x70, 0x1C, 0x03, 0x80, 0xE3, 0x80, 0x60, 0x0E,
  0x03, 0x8E, 0x03, 0x80, 0x38, 0x06, 0x70, 0x0E, 0x00, 0xE0, 0x19, 0xC0,
  0x38, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x80, 0x70,
  0x07, 0xC0, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x60,
  0x0F, 0x80, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x07, 0x70, 0x00,
  0x01, 0xC0, 0x3B, 0x80, 0x00, 0x0E, 0x01, 0xCC, 0x00, 0x00, 0x70, 0x0C,
  0x70, 0x00, 0x03, 0x00, 0x63, 0x80, 0x00, 0x38, 0x07, 0x0C, 0x00, 0x01,
  0xC0, 0x38, 0x70, 0x00, 0x0E, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x0E, 0x0E,
  0x00, 0x03, 0x80, 0x60, 0x70, 0x00, 0x18, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x0E, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x38,
  0x01, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x70, 0x00, 0x30, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x70, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x70,
  0x00, 0x0E, 0x1C, 0x03, 0x80, 0x00, 0x38, 0xE0, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0xC0, 0x00, 0x06, 0x30, 0x06, 0x00, 0x00, 0x3B, 0x80, 0x70, 0x00,
  0x01, 0xDC, 0x03, 0x80, 0x00, 0x06, 0xE0, 0x1C, 0x00, 0x00, 0x3F, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x01, 0xF8, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xE0, 0x0E,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x06,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03,
  0xC0, 0x0C, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x6E,
  0x00, 0x1E, 0x00, 0x1D, 0xC0, 0x03, 0xC0, 0x03, 0xB8, 0x00, 0xF8, 0x00,
  0x67, 0x00, 0x1B, 0x00, 0x1C, 0xE0, 0x03, 0x60, 0x03, 0x9C, 0x00, 0xEC,
  0x00, 0x63, 0x80, 0x19, 0x80, 0x1C, 0x70, 0x07, 0x30, 0x03, 0x8E, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0x18, 0xE0, 0x0C, 0x38, 0x07, 0x1C, 0x03, 0x87,
  0x00, 0xE3, 0x80, 0x70, 0xE0, 0x18, 0x70, 0x0C, 0x1C, 0x07, 0x0E, 0x03,
  0x83, 0x80, 0xE1, 0xC0, 0x70, 0x70, 0x18, 0x38, 0x0C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x07, 0x07,
  0x03, 0x81, 0x80, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x18, 0x0E, 0x0E, 0x03,
  0x87, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x38, 0x70, 0x0E, 0x18, 0x07, 0x0E,
  0x01, 0xC7, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0C, 0x70, 0x07, 0x18, 0x01,
  0x8E, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x1C, 0xE0, 0x06, 0x30, 0x03, 0x98,
  0x00, 0xCE, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0xE0, 0x03, 0x30, 0x01,
  0xD8, 0x00, 0x6E, 0x00, 0x3F, 0x00, 0x0D, 0xC0, 0x07, 0xE0, 0x01, 0xB0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x38, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x70,
  0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0x30, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x3E, 0x38, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x1E, 0xE1, 0xE0,
  0x01, 0xE3, 0x83, 0xE0, 0x3F, 0x0E, 0x07, 0xFF, 0xF0, 0x38, 0x07, 0xFF,
  0x00, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0x00, 0x00, 0xC0, 0xFF, 0xC0, 0x03, 0x87, 0xFF, 0xE0,
  0x07, 0x3F, 0x03, 0xE0, 0x0E, 0xF0, 0x01, 0xE0, 0x1F, 0x80, 0x01, 0xC0,
  0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x78, 0x1F, 0x80, 0x01, 0xE0, 0x3B, 0xC0, 0x07, 0x80,
  0x73, 0xE0, 0x7E, 0x00, 0xC3, 0xFF, 0xF8, 0x03, 0x81, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x18, 0x00, 0x7F, 0xFE,
  0x1C, 0x00, 0x7E, 0x07, 0x8E, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x78, 0x00,
  0x3B, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x7C,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF7, 0x00, 0x1F, 0x01, 0xF3,
  0x80, 0x07, 0xFF, 0xF1, 0xC0, 0x00, 0xFF, 0xE0, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF3, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xC0, 0x07, 0xFF, 0xE0, 0xC0, 0x07,
  0xE0, 0x7C, 0xE0, 0x07, 0x80, 0x0E, 0x70, 0x07, 0x80, 0x03, 0xB8, 0x07,
  0x80, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x07, 0xC0, 0x0E, 0x00,
  0x07, 0xE0, 0x07, 0x80, 0x0F, 0x70, 0x01, 0xF0, 0x1F, 0x38, 0x00, 0x7F,
  0xFF, 0x1C, 0x00, 0x0F, 0xFE, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x03, 0x83, 0xFF, 0xF0, 0x07,
  0x0F, 0x81, 0xF0, 0x0C, 0x78, 0x00, 0xF0, 0x19, 0xC0, 0x00, 0xE0, 0x77,
  0x00, 0x01, 0xE0, 0xEC, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x03, 0x00, 0x78, 0x00, 0x03, 0x80,
  0xF8, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x00, 0x19, 0xFC, 0x00, 0x00, 0x1D,
  0xEE, 0x00, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x07, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0E, 0x7F, 0xF0, 0xFF, 0xF0, 0x1D, 0xE0, 0xF3, 0xC1,
  0xE0, 0x3F, 0x00, 0xEE, 0x01, 0xE0, 0x7C, 0x01, 0xF8, 0x01, 0xC0, 0xF0,
  0x01, 0xE0, 0x03, 0x83, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x80, 0x03, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x00, 0x38, 0x30, 0x00, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x00, 0x60,
  0xE0, 0x00, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x83, 0x80, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x70, 0x00, 0x60, 0x00, 0xE0, 0xE0, 0x00,
  0xC0, 0x01, 0xC1, 0x80, 0x03, 0x80, 0x03, 0x83, 0x00, 0x07, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x01,
  0xFF, 0x80, 0x0E, 0x0F, 0xFF, 0xC0, 0x1C, 0x3E, 0x07, 0xC0, 0x31, 0xE0,
  0x03, 0xC0, 0x67, 0x00, 0x03, 0x81, 0xDC, 0x00, 0x07, 0x03, 0xB0, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x3F, 0xF0, 0x00, 0x38, 0x7F, 0xFE, 0x00, 0x1C,
  0xF8, 0x1F, 0x80, 0x0E, 0xF0, 0x03, 0xC0, 0x06, 0xE0, 0x00, 0x70, 0x03,
  0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x80,
  0x01, 0xE0, 0x0E, 0xE0, 0x01, 0xE0, 0x07, 0x3C, 0x07, 0xE0, 0x03, 0x0F,
  0xFF, 0xE0, 0x03, 0x81, 0xFF, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x1C, 0x01, 0xFF, 0xF8, 0x30, 0x07, 0xE0, 0x7C, 0xE0, 0x1E, 0x00, 0x39,
  0xC0, 0x78, 0x00, 0x3B, 0x81, 0xE0, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0xF7, 0x00, 0x7C, 0x07, 0xCE, 0x00, 0x7F, 0xFF, 0x1C,
  0x00, 0x3F, 0xF8, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x38, 0x07, 0xFF, 0x03, 0x03, 0xFF, 0xF0, 0x70, 0x7F,
  0x03, 0x07, 0x1F, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00,
  0x03, 0xF0, 0x1C, 0x00, 0x0E, 0xE0, 0x3C, 0x00, 0x79, 0x80, 0x3E, 0x07,
  0xE7, 0x00, 0x3F, 0xFF, 0x0E, 0x00, 0x3F, 0xF8, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0E, 0xE0,
  0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0x0C, 0xE0, 0x01, 0xE0, 0x01,
  0xCE, 0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x03, 0x60, 0x03, 0x8E, 0x00, 0x36,
  0x00, 0x38, 0xE0, 0x07, 0x60, 0x03, 0x0E, 0x00, 0x67, 0x00, 0x70, 0xE0,
  0x0E, 0x70, 0x07, 0x06, 0x00, 0xC7, 0x00, 0xE0, 0x60, 0x1C, 0x70, 0x0E,
  0x06, 0x01, 0xC7, 0x00, 0xC0, 0x60, 0x18, 0x70, 0x1C, 0x06, 0x03, 0x83,
  0x01, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x06, 0x07, 0x03, 0x03, 0x80, 0x60,
  0x70, 0x30, 0x30, 0x06, 0x06, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x30, 0x70,
  0x07, 0x0C, 0x03, 0x06, 0x00, 0x71, 0xC0, 0x30, 0xE0, 0x07, 0x18, 0x03,
  0x8C, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73,
  0x00, 0x39, 0x80, 0x07, 0x70, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC3,
  0xFF, 0xE0, 0x00, 0x0E, 0x1E, 0x07, 0x80, 0x00, 0x71, 0xC0, 0x1E, 0x00,
  0x03, 0x1C, 0x00, 0x78, 0x00, 0x38, 0xC0, 0x00, 0xE0, 0x03, 0x8E, 0x00,
  0x03, 0xC0, 0x3C, 0x70, 0x00, 0x0F, 0x87, 0xC3, 0x00, 0x00, 0x3F, 0xFC,
  0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 11, 48, 40, 14, -48 },
  { 67, 14, 14, 40, 16, -51 },
  { 92, 39, 48, 40, 1, -48 },
  { 326, 33, 62, 40, 4, -55 },
  { 582, 33, 50, 40, 4, -49 },
  { 789, 34, 50, 40, 3, -49 },
  { 1002, 5, 14, 40, 20, -51 },
  { 1011, 20, 70, 40, 12, -54 },
  { 1186, 21, 70, 40, 6, -54 },
  { 1370, 29, 28, 40, 9, -48 },
  { 1472, 33, 35, 40, 4, -40 },
  { 1617, 8, 15, 40, 8, -6 },
  { 1632, 24, 2, 40, 8, -23 },
  { 1638, 6, 5, 40, 15, -5 },
  { 1642, 32, 52, 40, 5, -48 },
  { 1850, 31, 50, 40, 5, -49 },
  { 2044, 18, 48, 40, 10, -48 },
  { 2152, 33, 49, 40, 1, -49 },
  { 2355, 33, 50, 40, 2, -49 },
  { 2562, 33, 48, 40, 2, -48 },
  { 2760, 33, 49, 40, 6, -48 },
  { 2963, 30, 50, 40, 4, -49 },
  { 3151, 31, 48, 40, 8, -48 },
  { 3337, 34, 50, 40, 4, -49 },
  { 3550, 29, 50, 40, 7, -49 },
  { 3732, 10, 34, 40, 17, -34 },
  { 3775, 14, 43, 40, 13, -34 },
  { 3851, 31, 28, 40, 5, -36 },
  { 3960, 31, 16, 40, 5, -30 },
  { 4022, 31, 28, 40, 4, -36 },
  { 4131, 25, 49, 40, 11, -49 },
  { 4285, 38, 49, 40, 2, -49 },
  { 4518, 33, 48, 40, 0, -48 },
  { 4716, 34, 48, 40, 3, -48 },
  { 4920, 34, 50, 40, 4, -49 },
  { 5133, 35, 48, 40, 3, -48 },
  { 5343, 36, 48, 40, 3, -48 },
  { 5559, 35, 48, 40, 4, -48 },
  { 5769, 34, 50, 40, 4, -49 },
  { 5982, 37, 48, 40, 2, -48 },
  { 6204, 35, 48, 40, 3, -48 },
  { 6414, 36, 49, 40, 2, -48 },
  { 6635, 39, 48, 40, 3, -48 },
  { 6869, 28, 48, 40, 4, -48 },
  { 7037, 38, 48, 40, 2, -48 },
  { 7265, 37, 48, 40, 2, -48 },
  { 7487, 33, 50, 40, 4, -49 },
  { 7694, 35, 48, 40, 4, -48 },
  { 7904, 35, 58, 40, 3, -49 },
  { 8158, 33, 48, 40, 4, -48 },
  { 8356, 35, 50, 40, 3, -49 },
  { 8575, 33, 48, 40, 8, -48 },
  { 8773, 35, 49, 40, 4, -48 },
  { 8988, 33, 48, 40, 8, -48 },
  { 9186, 35, 48, 40, 7, -48 },
  { 9396, 40, 48, 40, 1, -48 },
  { 9636, 33, 48, 40, 8, -48 },
  { 9834, 36, 48, 40, 1, -48 },
  { 10050, 21, 65, 40, 10, -55 },
  { 10221, 13, 52, 40, 14, -48 },
  { 10306, 20, 65, 40, 10, -55 },
  { 10469, 24, 26, 40, 8, -48 },
  { 10547, 28, 3, 40, 2, 0 },
  { 10558, 8, 9, 40, 20, -50 },
  { 10567, 30, 38, 40, 4, -37 },
  { 10710, 31, 52, 40, 3, -51 },
  { 10912, 30, 38, 40, 5, -37 },
  { 11055, 33, 52, 40, 5, -51 },
  { 11270, 31, 38, 40, 4, -37 },
  { 11418, 32, 52, 40, 9, -52 },
  { 11626, 33, 51, 40, 3, -37 },
  { 11837, 31, 51, 40, 3, -51 },
  { 12035, 28, 49, 40, 4, -49 },
  { 12207, 31, 64, 40, 0, -49 },
  { 12455, 33, 51, 40, 4, -51 },
  { 12666, 28, 51, 40, 4, -51 },
  { 12845, 39, 37, 40, -1, -37 },
  { 13026, 31, 37, 40, 3, -37 },
  { 13170, 31, 38, 40, 4, -37 },
  { 13318, 33, 51, 40, 1, -37 },
  { 13529, 31, 51, 40, 5, -37 },
  { 13727, 28, 37, 40, 9, -37 },
  { 13857, 30, 38, 40, 5, -37 },
  { 14000, 26, 46, 40, 8, -45 },
  { 14150, 31, 37, 40, 5, -36 },
  { 14294, 32, 36, 40, 6, -36 },
  { 14438, 36, 36, 40, 5, -36 },
  { 14600, 37, 36, 40, 1, -36 },
  { 14767, 41, 51, 40, -1, -36 },
  { 15029, 35, 36, 40, 1, -36 },
  { 15187, 26, 67, 40, 11, -53 },
  { 15405, 12, 58, 40, 14, -48 },
  { 15492, 26, 67, 40, 6, -53 },
  { 15710, 37, 12, 40, 1, -26 },
};

const GFXfont RobotoMono_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC68PT7B_H_
