#ifndef _ROBOTOMONO_EXTRALIGHTITALIC35PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC3,
  0x08, 0x20, 0x80, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x23, 0x62, 0x62, 0x42,
  0x46, 0x46, 0xC4, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x0C, 0x18, 0x00,
  0x40, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x02, 0x01, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x04, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x04, 0x00, 0x10,
  0x20, 0x01, 0x83, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x06, 0x0C, 0x07,
  0xFF, 0xFE, 0x01, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x18,
  0x00, 0x60, 0x80, 0x02, 0x04, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x1C, 0x30, 0x18, 0x0C,
  0x18, 0x02, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x13, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x06, 0x30, 0x02, 0x18, 0x03, 0x07, 0x07, 0x00, 0xFE, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x80,
  0x18, 0x40, 0x08, 0x30, 0x6C, 0x18, 0x26, 0x0C, 0x22, 0x04, 0x31, 0x02,
  0x30, 0xC3, 0x10, 0x23, 0x10, 0x0F, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x78, 0x04, 0x62, 0x06, 0x21, 0x86, 0x20, 0x42, 0x10,
  0x22, 0x08, 0x33, 0x0C, 0x1B, 0x06, 0x08, 0x81, 0x04, 0x00, 0x84, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x63, 0x00, 0x30, 0x60, 0x08, 0x18, 0x06,
  0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x20, 0x06, 0x30, 0x00, 0x98,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0x30, 0x01, 0x84, 0x0C,
  0xC1, 0x83, 0x20, 0x30, 0x98, 0x04, 0x64, 0x01, 0x91, 0x00, 0x2C, 0x40,
  0x0E, 0x18, 0x03, 0x86, 0x01, 0xA0, 0xE1, 0xCC, 0x1F, 0xC1, 0x80, 0x69,
  0x25, 0xA0, 0x00, 0x20, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x03, 0x84, 0x77, 0xB7, 0x83, 0xF0, 0x07, 0x00, 0x36, 0x01,
  0x88, 0x0C, 0x30, 0x20, 0x61, 0x81, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x11, 0x33, 0x26, 0xC4, 0xFF, 0xF0, 0x5F, 0x00, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0x87, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x80,
  0x10, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07, 0x20, 0x05, 0x90, 0x0C, 0xD8,
  0x0C, 0x4C, 0x0C, 0x26, 0x0C, 0x12, 0x0C, 0x09, 0x08, 0x0C, 0x98, 0x06,
  0x58, 0x02, 0x78, 0x01, 0x18, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC3, 0x00,
  0x40, 0x80, 0x60, 0x70, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0xE1, 0xE9,
  0xC2, 0xC1, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x00, 0x01, 0xF8, 0x07, 0x0E, 0x0C, 0x02, 0x18, 0x03,
  0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0x83, 0x01, 0x80,
  0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x20, 0x00, 0x90, 0x00,
  0xCC, 0x00, 0x46, 0x00, 0x61, 0x80, 0x60, 0x60, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0x40, 0x01, 0x20, 0x01,
  0x90, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x86, 0x00, 0x82, 0x00, 0x81, 0x00,
  0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x20, 0x40, 0x10, 0x60, 0x08,
  0x7F, 0xFF, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0xF0, 0x0F, 0xFC, 0x07, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x20, 0x01, 0x10, 0x01,
  0x8C, 0x00, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x47, 0xE1, 0xB0, 0x63, 0xC0, 0x66, 0x00,
  0x6C, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x24, 0x00, 0xCC, 0x01, 0x08, 0x06, 0x1C, 0x38, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xC3, 0x81, 0x80, 0xC1, 0x80, 0x30, 0x80, 0x08,
  0xC0, 0x04, 0x40, 0x02, 0x20, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x83, 0x01,
  0x80, 0xF7, 0x00, 0x3F, 0x00, 0x60, 0x60, 0xC0, 0x18, 0xC0, 0x04, 0x60,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x62, 0x00, 0x31,
  0x80, 0x30, 0x60, 0x70, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x1C, 0x30, 0x60,
  0x30, 0x80, 0x33, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x07, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x6C, 0x01, 0xCC, 0x0D, 0x0E,
  0xF2, 0x0F, 0x8C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x7C, 0x00, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0xC6, 0x00, 0x04, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x40, 0x83, 0x04,
  0x18, 0x20, 0x00, 0x00, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0xE1, 0x8C, 0x06, 0xC0,
  0x14, 0x00, 0xE0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0x00, 0x3C, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x30, 0xC0, 0x02, 0x30,
  0x70, 0x44, 0x3B, 0x89, 0x8C, 0x21, 0x21, 0x04, 0x2C, 0x60, 0x85, 0x08,
  0x10, 0xA3, 0x04, 0x1C, 0x40, 0x83, 0x08, 0x10, 0xE1, 0x06, 0x14, 0x20,
  0x82, 0x84, 0x30, 0xD0, 0x8E, 0x12, 0x13, 0x64, 0x43, 0xC7, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20,
  0x01, 0x98, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20,
  0x40, 0x30, 0x20, 0x10, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x0F, 0xFF, 0x07,
  0xFF, 0x86, 0x00, 0x42, 0x00, 0x23, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x06,
  0x80, 0x01, 0xC0, 0x00, 0x80, 0x0F, 0xF8, 0x04, 0x1F, 0x02, 0x00, 0xC3,
  0x00, 0x21, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x30, 0x03,
  0x18, 0x01, 0x8C, 0x03, 0x84, 0x0F, 0x03, 0xFF, 0x81, 0x00, 0x61, 0x80,
  0x18, 0xC0, 0x04, 0x60, 0x03, 0x20, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x4C,
  0x00, 0x66, 0x00, 0x63, 0x00, 0x61, 0x01, 0xE0, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x01, 0xC3, 0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0x80, 0x04,
  0xC0, 0x02, 0x40, 0x01, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x01, 0xB0, 0x00, 0x98, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x80, 0x60,
  0x60, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0x07, 0x80, 0xC0, 0x30,
  0x30, 0x06, 0x08, 0x00, 0x82, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x01, 0x18,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x66, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x06, 0x10, 0x03, 0x04, 0x01, 0x81, 0x07, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xFE, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xC7,
  0x01, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0x80, 0x04, 0xC0, 0x02, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x03, 0xFB, 0x01, 0xFD, 0x00, 0x06, 0x80, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0x98, 0x00, 0x44, 0x00, 0x23, 0x00, 0x30, 0x80, 0x38, 0x70, 0x70, 0x0F,
  0xE0, 0x00, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x30,
  0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00, 0xC2,
  0x00, 0x18, 0x40, 0x02, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x40, 0x03, 0x08,
  0x00, 0x61, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20,
  0x01, 0x84, 0x00, 0x30, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x10, 0xC0,
  0x06, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x10, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0x40, 0x04, 0x10, 0x03,
  0x06, 0x01, 0x80, 0xC1, 0xC0, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x61, 0x00,
  0x18, 0x20, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x18, 0x04, 0x06,
  0x00, 0x81, 0x80, 0x10, 0x60, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x19, 0x80,
  0x02, 0x78, 0x00, 0x73, 0x00, 0x0C, 0x30, 0x03, 0x02, 0x00, 0x60, 0x60,
  0x0C, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x0C, 0x04, 0x01, 0x81, 0x80, 0x18,
  0x30, 0x01, 0x06, 0x00, 0x30, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x03, 0x85,
  0x00, 0xF0, 0xA0, 0x16, 0x14, 0x06, 0x86, 0xC0, 0x90, 0xD8, 0x32, 0x11,
  0x04, 0x42, 0x21, 0x98, 0x44, 0x23, 0x18, 0xCC, 0x43, 0x1B, 0x08, 0x61,
  0x41, 0x08, 0x38, 0x61, 0x06, 0x0C, 0x20, 0xC1, 0x8C, 0x00, 0x21, 0x80,
  0x04, 0x30, 0x00, 0x84, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0xC6, 0x00,
  0x10, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x21, 0x80, 0x0C, 0x38, 0x01, 0x85,
  0x00, 0x30, 0xA0, 0x04, 0x36, 0x00, 0x86, 0x40, 0x10, 0xC8, 0x06, 0x11,
  0x80, 0xC2, 0x10, 0x18, 0x43, 0x02, 0x18, 0x60, 0x43, 0x04, 0x08, 0x40,
  0xC3, 0x08, 0x08, 0x61, 0x01, 0x08, 0x20, 0x31, 0x0C, 0x02, 0x21, 0x80,
  0x4C, 0x20, 0x0D, 0x84, 0x00, 0xB0, 0x80, 0x1C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x00, 0x01, 0xFC, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x80,
  0x21, 0x80, 0x10, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x01, 0x60, 0x00, 0xB0,
  0x00, 0x50, 0x00, 0x68, 0x00, 0x34, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0x30, 0x00, 0x98, 0x00, 0xC4, 0x00,
  0xC2, 0x00, 0x41, 0x80, 0x60, 0x70, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xFC,
  0x03, 0x03, 0xC0, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x11,
  0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x18, 0xC0,
  0x0C, 0x30, 0x06, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xE3, 0x80,
  0xE0, 0x30, 0x20, 0x04, 0x18, 0x01, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80,
  0x02, 0x60, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00,
  0xB0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xC8,
  0x00, 0x23, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x06, 0x01, 0x80, 0xE1,
  0xC0, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0F, 0xF8, 0x04, 0x0F, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x80, 0x18,
  0xC0, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x98, 0x00, 0x8C, 0x00,
  0xC6, 0x00, 0xC2, 0x00, 0xC1, 0xFF, 0x80, 0x80, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x08, 0x10, 0x06, 0x08, 0x03, 0x04, 0x00, 0x86, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x08, 0x80, 0x06, 0x00, 0x01, 0xFC, 0x01, 0xC3, 0x80,
  0xC0, 0x30, 0x60, 0x06, 0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC8,
  0x00, 0x32, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x86, 0x00, 0xC0, 0xE0,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x23,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0x62, 0x00, 0x11, 0x80,
  0x04, 0x60, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x02,
  0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x02, 0x06,
  0x01, 0x80, 0xE1, 0xC0, 0x1F, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xB0,
  0x00, 0xD8, 0x00, 0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x18,
  0x60, 0x18, 0x30, 0x0C, 0x08, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x03,
  0x00, 0xC1, 0x00, 0x61, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02,
  0x60, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x80, 0xE0, 0x20, 0x28, 0x1C, 0x0A, 0x07, 0x06, 0x81, 0xC1,
  0x20, 0xF0, 0x48, 0x2C, 0x12, 0x0B, 0x0C, 0x86, 0xC2, 0x21, 0x30, 0x88,
  0x4C, 0x62, 0x33, 0x10, 0x88, 0x44, 0x22, 0x13, 0x09, 0x84, 0x82, 0x41,
  0x20, 0xB0, 0x58, 0x2C, 0x16, 0x0A, 0x05, 0x03, 0x81, 0x40, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x80, 0x80, 0x40, 0x00, 0x0C, 0x00,
  0x18, 0x30, 0x01, 0x80, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0xC6, 0x00, 0x02, 0x60,
  0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x60, 0x00, 0x11, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x81, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x80, 0xC0, 0x04, 0x0C, 0x00,
  0x30, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0xE0, 0x01, 0x90, 0x00, 0x8C, 0x00,
  0xC6, 0x00, 0xC1, 0x00, 0x40, 0xC0, 0x60, 0x60, 0x60, 0x10, 0x20, 0x0C,
  0x30, 0x06, 0x30, 0x01, 0x10, 0x00, 0x98, 0x00, 0x78, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xFC, 0x00, 0x81, 0x83, 0x02, 0x04, 0x08, 0x18, 0x30,
  0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0xC1,
  0x83, 0x02, 0x04, 0x0C, 0x18, 0x07, 0xE0, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0xF8, 0x00, 0x00, 0x80, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x40, 0x66,
  0x0C, 0x60, 0x82, 0x18, 0x21, 0x02, 0x30, 0x32, 0x03, 0x60, 0x1C, 0x01,
  0xFF, 0xFE, 0xC6, 0x23, 0x10, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18,
  0x02, 0x30, 0x02, 0x20, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x7E, 0x0F,
  0xFE, 0x38, 0x06, 0x60, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x0C, 0xC0,
  0x1C, 0xC0, 0x3C, 0x60, 0xEC, 0x3F, 0x8C, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0xF0, 0x13,
  0xFC, 0x14, 0x0C, 0x38, 0x06, 0x30, 0x02, 0x30, 0x02, 0x20, 0x03, 0x20,
  0x03, 0x20, 0x03, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40,
  0x04, 0x40, 0x0C, 0xC0, 0x08, 0xE0, 0x18, 0xB8, 0x70, 0x8F, 0xC0, 0x01,
  0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20,
  0x03, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x20, 0x18, 0x38, 0x70, 0x0F,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x07, 0x84, 0x07, 0xF9, 0x03, 0x03, 0xC1,
  0x80, 0x70, 0xC0, 0x0C, 0x20, 0x02, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00,
  0x18, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04,
  0x10, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70, 0x30, 0x68, 0x07, 0xF2, 0x00,
  0x00, 0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x02, 0x30, 0x03, 0x20, 0x03,
  0x60, 0x01, 0x40, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x04, 0x30, 0x0C, 0x18, 0x38,
  0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x7F, 0xFE, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xFE, 0x41, 0x81, 0xA1, 0x80, 0x71, 0x80, 0x18, 0xC0,
  0x08, 0xC0, 0x04, 0x60, 0x02, 0x20, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x46, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x0E,
  0x0C, 0x1A, 0x03, 0xF9, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x41, 0x00,
  0x61, 0x80, 0x60, 0x70, 0x60, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x70,
  0x13, 0xFC, 0x36, 0x06, 0x3C, 0x02, 0x38, 0x03, 0x30, 0x03, 0x20, 0x03,
  0x20, 0x02, 0x60, 0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x06, 0x40, 0x06,
  0x40, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0xFC,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x80, 0xFE, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x01, 0x18, 0x03, 0x08, 0x07, 0x04, 0x06, 0x02,
  0x06, 0x03, 0x06, 0x01, 0x8E, 0x00, 0xCC, 0x00, 0x4C, 0x00, 0x2F, 0x00,
  0x1C, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x06, 0x06, 0x02, 0x01, 0x01, 0x00,
  0xC0, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x06, 0x00, 0x0F, 0xF8, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x03, 0xC3, 0xC1, 0x7E, 0x7E, 0x18,
  0x28, 0x23, 0x03, 0x03, 0x30, 0x30, 0x32, 0x02, 0x03, 0x20, 0x20, 0x22,
  0x02, 0x02, 0x60, 0x20, 0x26, 0x06, 0x06, 0x60, 0x60, 0x64, 0x04, 0x04,
  0x40, 0x40, 0x44, 0x04, 0x04, 0xC0, 0xC0, 0x4C, 0x0C, 0x0C, 0x80, 0xC0,
  0xC8, 0x08, 0x08, 0x80, 0x80, 0x80, 0x00, 0xF8, 0x13, 0xFC, 0x36, 0x06,
  0x38, 0x02, 0x38, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x02, 0x60, 0x02,
  0x60, 0x02, 0x60, 0x06, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04,
  0xC0, 0x04, 0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x01, 0xF0, 0x07, 0xFC,
  0x0C, 0x0C, 0x18, 0x06, 0x30, 0x03, 0x60, 0x03, 0x60, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x06,
  0xC0, 0x04, 0x40, 0x0C, 0x60, 0x18, 0x30, 0x70, 0x1F, 0xC0, 0x00, 0x3C,
  0x01, 0x3F, 0xC0, 0x70, 0x30, 0x38, 0x06, 0x0C, 0x00, 0x83, 0x00, 0x20,
  0x80, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x08, 0x40,
  0x06, 0x10, 0x01, 0x84, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x08, 0x38, 0x06,
  0x0B, 0x07, 0x02, 0x3F, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0xF9, 0x0C, 0x0F, 0x18, 0x07, 0x30, 0x03, 0x30, 0x02, 0x60, 0x02, 0x60,
  0x02, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x40,
  0x04, 0x40, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x30, 0x68, 0x1F, 0xC8, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x3E, 0x31, 0xFC, 0x6C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x03, 0x10, 0x01, 0x30,
  0x01, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x30,
  0x38, 0x1F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x07,
  0xFF, 0xE0, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x20, 0x02, 0x40, 0x05,
  0x80, 0x1B, 0x00, 0x34, 0x00, 0x68, 0x00, 0x90, 0x01, 0x60, 0x02, 0xC0,
  0x0D, 0x80, 0x1A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x06,
  0x60, 0x3C, 0x60, 0xD8, 0x7E, 0x20, 0xC0, 0x00, 0xE0, 0x00, 0x90, 0x00,
  0xC8, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x60, 0x80, 0x20, 0x40, 0x30, 0x30,
  0x10, 0x18, 0x18, 0x04, 0x08, 0x02, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00,
  0x26, 0x00, 0x12, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x80, 0xE0, 0x60, 0x28, 0x1C, 0x1A, 0x0F, 0x04, 0x82, 0xC1, 0x20, 0xB0,
  0xC8, 0x64, 0x22, 0x11, 0x18, 0x8C, 0x44, 0x22, 0x11, 0x08, 0x84, 0xC2,
  0x41, 0x20, 0x90, 0x58, 0x2C, 0x14, 0x0A, 0x05, 0x02, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x00, 0x18, 0x00, 0x02, 0x00, 0x30, 0xC0, 0x18, 0x10,
  0x0C, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x04, 0x80, 0x03, 0x30, 0x01, 0x84, 0x00,
  0xC1, 0x80, 0x60, 0x30, 0x30, 0x04, 0x18, 0x01, 0x8C, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x08, 0x00, 0x60, 0x40, 0x06,
  0x03, 0x00, 0x20, 0x18, 0x03, 0x00, 0x40, 0x10, 0x03, 0x01, 0x80, 0x18,
  0x18, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41,
  0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x00, 0x3F, 0x00, 0x6C, 0x30,
  0x09, 0x03, 0x03, 0x60, 0x30, 0xC8, 0x03, 0xF0, 0x00, 0x08, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 25, 21, 7, -25 },
  { 20, 8, 7, 21, 8, -26 },
  { 27, 21, 25, 21, 0, -25 },
  { 93, 17, 33, 21, 2, -29 },
  { 164, 17, 25, 21, 2, -25 },
  { 218, 18, 25, 21, 1, -25 },
  { 275, 3, 7, 21, 10, -26 },
  { 278, 11, 36, 21, 6, -28 },
  { 328, 11, 36, 21, 3, -28 },
  { 378, 14, 14, 21, 5, -25 },
  { 403, 17, 19, 21, 2, -21 },
  { 444, 4, 8, 21, 4, -3 },
  { 448, 12, 1, 21, 4, -12 },
  { 450, 3, 3, 21, 8, -3 },
  { 452, 16, 27, 21, 3, -25 },
  { 506, 17, 25, 21, 2, -25 },
  { 560, 10, 25, 21, 5, -25 },
  { 592, 16, 25, 21, 1, -25 },
  { 642, 17, 25, 21, 1, -25 },
  { 696, 17, 25, 21, 1, -25 },
  { 750, 17, 25, 21, 3, -25 },
  { 804, 15, 25, 21, 2, -25 },
  { 851, 16, 25, 21, 4, -25 },
  { 901, 17, 25, 21, 2, -25 },
  { 955, 15, 25, 21, 3, -25 },
  { 1002, 5, 18, 21, 9, -18 },
  { 1014, 7, 23, 21, 7, -18 },
  { 1035, 15, 14, 21, 3, -18 },
  { 1062, 17, 9, 21, 2, -16 },
  { 1082, 16, 14, 21, 2, -18 },
  { 1110, 13, 25, 21, 5, -25 },
  { 1151, 19, 25, 21, 1, -25 },
  { 1211, 17, 25, 21, 0, -25 },
  { 1265, 17, 25, 21, 2, -25 },
  { 1319, 17, 25, 21, 2, -25 },
  { 1373, 18, 25, 21, 1, -25 },
  { 1430, 18, 25, 21, 2, -25 },
  { 1487, 18, 25, 21, 2, -25 },
  { 1544, 17, 25, 21, 2, -25 },
  { 1598, 19, 25, 21, 1, -25 },
  { 1658, 18, 25, 21, 2, -25 },
  { 1715, 18, 25, 21, 1, -25 },
  { 1772, 19, 25, 21, 2, -25 },
  { 1832, 14, 25, 21, 2, -25 },
  { 1876, 19, 25, 21, 1, -25 },
  { 1936, 19, 25, 21, 1, -25 },
  { 1996, 17, 25, 21, 2, -25 },
  { 2050, 18, 25, 21, 2, -25 },
  { 2107, 18, 29, 21, 2, -25 },
  { 2173, 17, 25, 21, 2, -25 },
  { 2227, 18, 25, 21, 2, -25 },
  { 2284, 17, 25, 21, 4, -25 },
  { 2338, 18, 25, 21, 2, -25 },
  { 2395, 17, 25, 21, 4, -25 },
  { 2449, 18, 25, 21, 4, -25 },
  { 2506, 21, 25, 21, 0, -25 },
  { 2572, 17, 25, 21, 4, -25 },
  { 2626, 18, 25, 21, 1, -25 },
  { 2683, 11, 33, 21, 5, -28 },
  { 2729, 7, 27, 21, 7, -25 },
  { 2753, 11, 33, 21, 5, -28 },
  { 2799, 12, 14, 21, 4, -25 },
  { 2820, 15, 1, 21, 1, 0 },
  { 2822, 4, 5, 21, 10, -26 },
  { 2825, 16, 19, 21, 2, -19 },
  { 2863, 16, 26, 21, 2, -26 },
  { 2915, 16, 19, 21, 2, -19 },
  { 2953, 18, 26, 21, 2, -26 },
  { 3012, 16, 19, 21, 2, -19 },
  { 3050, 17, 27, 21, 4, -27 },
  { 3108, 17, 26, 21, 1, -19 },
  { 3164, 16, 26, 21, 2, -26 },
  { 3216, 14, 25, 21, 2, -25 },
  { 3260, 16, 32, 21, 0, -25 },
  { 3324, 17, 26, 21, 2, -26 },
  { 3380, 14, 26, 21, 2, -26 },
  { 3426, 20, 19, 21, 0, -19 },
  { 3474, 16, 19, 21, 2, -19 },
  { 3512, 16, 19, 21, 2, -19 },
  { 3550, 18, 26, 21, 0, -19 },
  { 3609, 16, 26, 21, 2, -19 },
  { 3661, 15, 19, 21, 4, -19 },
  { 3697, 16, 19, 21, 2, -19 },
  { 3735, 14, 23, 21, 4, -23 },
  { 3776, 15, 18, 21, 3, -18 },
  { 3810, 17, 19, 21, 3, -19 },
  { 3851, 18, 18, 21, 3, -18 },
  { 3892, 18, 19, 21, 1, -19 },
  { 3935, 21, 26, 21, -1, -19 },
  { 4004, 18, 18, 21, 1, -18 },
  { 4045, 14, 34, 21, 5, -27 },
  { 4105, 6, 30, 21, 7, -25 },
  { 4128, 13, 34, 21, 3, -27 },
  { 4184, 19, 6, 21, 1, -13 },
};

const GFXfont RobotoMono_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC35PT7B_H_
