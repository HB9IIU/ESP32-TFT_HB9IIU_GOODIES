#ifndef _ROBOTOMONO_EXTRALIGHTITALIC53PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x00, 0x30, 0xEC, 0x19, 0x83,
  0x30, 0x66, 0x0C, 0xC1, 0x98, 0x26, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x38, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x02, 0x18, 0x06, 0x00, 0xC6,
  0x01, 0x80, 0x61, 0x80, 0x60, 0x30, 0xC0, 0x18, 0x1C, 0x30, 0x06, 0x06,
  0x0C, 0x01, 0x83, 0x03, 0x00, 0xC1, 0x80, 0xC0, 0x30, 0x60, 0x18, 0x18,
  0x30, 0x07, 0x0E, 0x18, 0x00, 0xFF, 0x0E, 0x00, 0x1F, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x07, 0xF0, 0x01, 0x83, 0x8E, 0x00, 0xC1,
  0x81, 0x80, 0x70, 0xC0, 0x60, 0x18, 0x30, 0x0C, 0x0C, 0x18, 0x03, 0x07,
  0x06, 0x00, 0xC1, 0x81, 0x80, 0x20, 0xC0, 0x60, 0x18, 0x60, 0x18, 0x06,
  0x18, 0x06, 0x01, 0x8C, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x0E,
  0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x1C,
  0x01, 0xC3, 0x81, 0x80, 0x30, 0xE0, 0x18, 0x06, 0x38, 0x03, 0x80, 0xC6,
  0x00, 0x30, 0x39, 0xC0, 0x07, 0x06, 0x30, 0x00, 0x71, 0xC6, 0x00, 0x06,
  0x30, 0xC0, 0x00, 0xEE, 0x18, 0x00, 0x0F, 0x83, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x03, 0xB8, 0x0E, 0x01, 0xE3,
  0x80, 0xFF, 0xF8, 0x30, 0x0F, 0xFC, 0x07, 0x00, 0x10, 0x00, 0x00, 0x33,
  0x33, 0x36, 0x66, 0x66, 0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x10, 0x06, 0x03, 0xF0, 0x30, 0x3D, 0xF8, 0xC7, 0xF0, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE3,
  0x00, 0x07, 0x0E, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x18,
  0x30, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0xE3, 0x82, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x6F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x3C, 0x01, 0xC0,
  0x0C, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x07, 0x38, 0x00,
  0x0F, 0x30, 0x00, 0x1F, 0x30, 0x00, 0x33, 0x70, 0x00, 0xE3, 0x70, 0x01,
  0xC3, 0x60, 0x03, 0x83, 0x60, 0x07, 0x03, 0x60, 0x0C, 0x07, 0x60, 0x38,
  0x06, 0xE0, 0x70, 0x06, 0xE0, 0xE0, 0x06, 0xC1, 0xC0, 0x06, 0xC3, 0x80,
  0x0E, 0xC6, 0x00, 0x0C, 0xDC, 0x00, 0x0C, 0xF8, 0x00, 0x0C, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x0F, 0xC0, 0xFF, 0x1F, 0x99, 0xF0, 0x6F, 0x01, 0xA0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3C, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x18, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0x80, 0xF0, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60,
  0x30, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x06, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x98, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xE0,
  0x01, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x31,
  0xF8, 0x00, 0x37, 0xFF, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x00, 0x78, 0x0E,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xE0, 0x06, 0x1F, 0xF8,
  0x1C, 0xF8, 0xF8, 0x33, 0x80, 0x38, 0x7C, 0x00, 0x30, 0xF0, 0x00, 0x73,
  0xC0, 0x00, 0x67, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00,
  0x1C, 0x70, 0x00, 0x30, 0x60, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xF0, 0x1E,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0x80, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x30, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x80, 0x78,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x30, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38,
  0x60, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x07, 0x80, 0x70, 0x07,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0xE0,
  0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00,
  0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x01, 0xE7, 0x00, 0x06, 0xC7,
  0x00, 0x1B, 0x87, 0x00, 0xE6, 0x0F, 0x8F, 0x8C, 0x07, 0xFE, 0x38, 0x03,
  0xC0, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x06, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0xF0, 0xF0, 0x70, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0x03, 0xC1, 0xC0, 0x0E, 0x38, 0x00, 0x63, 0x00, 0x06, 0x70, 0x00, 0x76,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03,
  0x01, 0xF8, 0x08, 0x18, 0x0F, 0xF0, 0x30, 0xE0, 0x60, 0xE0, 0xC3, 0x03,
  0x01, 0x03, 0x18, 0x18, 0x0C, 0x0C, 0x60, 0xC0, 0x30, 0x33, 0x83, 0x00,
  0xC0, 0xCC, 0x18, 0x02, 0x03, 0x30, 0x60, 0x18, 0x09, 0x81, 0x80, 0x60,
  0x66, 0x0C, 0x01, 0x81, 0x98, 0x30, 0x04, 0x06, 0x60, 0xC0, 0x30, 0x19,
  0x03, 0x00, 0xC0, 0x4C, 0x08, 0x03, 0x03, 0x30, 0x60, 0x18, 0x0C, 0xC1,
  0x80, 0xE0, 0x23, 0x06, 0x03, 0x81, 0x8C, 0x18, 0x1E, 0x04, 0x30, 0x30,
  0xD8, 0x30, 0xC0, 0xEE, 0x33, 0x81, 0x81, 0xF0, 0xFC, 0x06, 0x01, 0x00,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x06, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x81, 0x80, 0x01, 0xE0, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0x81, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x01, 0xF0, 0x01, 0x80,
  0x07, 0x00, 0x30, 0x00, 0x70, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x80, 0x70, 0x07,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xB8, 0x01, 0xFF, 0xCC, 0x00, 0x7F, 0xF3, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0xC0,
  0x03, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x18, 0x03, 0x80, 0x00,
  0xC0, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x3E, 0x00,
  0x00, 0x37, 0xB0, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F, 0x06, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x1F, 0x03, 0x60, 0x00, 0xD8, 0x1B, 0x00, 0x0E, 0xC0, 0xDC, 0x00, 0x66,
  0x06, 0x60, 0x07, 0x60, 0x33, 0x00, 0x33, 0x03, 0x98, 0x03, 0x18, 0x18,
  0xC0, 0x18, 0xC0, 0xC6, 0x01, 0x86, 0x06, 0x18, 0x1C, 0x70, 0x30, 0xC0,
  0xC3, 0x01, 0x86, 0x0E, 0x18, 0x1C, 0x30, 0x60, 0xC0, 0xC1, 0x87, 0x06,
  0x06, 0x06, 0x30, 0x30, 0x30, 0x33, 0x03, 0x81, 0x81, 0x98, 0x18, 0x0C,
  0x0D, 0x80, 0xC0, 0xE0, 0x7C, 0x06, 0x06, 0x03, 0xC0, 0x30, 0x30, 0x0E,
  0x03, 0x81, 0x80, 0x60, 0x1C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x30, 0x6C, 0x00, 0x07, 0x06, 0xC0,
  0x00, 0x60, 0x66, 0x00, 0x06, 0x06, 0x60, 0x00, 0x60, 0x67, 0x00, 0x06,
  0x0E, 0x30, 0x00, 0x60, 0xC3, 0x00, 0x0E, 0x0C, 0x18, 0x00, 0xC0, 0xC1,
  0x80, 0x0C, 0x0C, 0x18, 0x00, 0xC1, 0xC0, 0xC0, 0x0C, 0x18, 0x0C, 0x01,
  0xC1, 0x80, 0xE0, 0x1C, 0x18, 0x06, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18,
  0x07, 0x01, 0x83, 0x80, 0x30, 0x18, 0x30, 0x03, 0x03, 0x83, 0x00, 0x18,
  0x30, 0x30, 0x01, 0x83, 0x03, 0x00, 0x18, 0x30, 0x30, 0x00, 0xC3, 0x07,
  0x00, 0x0C, 0x30, 0x60, 0x00, 0xE7, 0x06, 0x00, 0x06, 0x60, 0x60, 0x00,
  0x66, 0x06, 0x00, 0x07, 0x60, 0x60, 0x00, 0x36, 0x0E, 0x00, 0x03, 0x60,
  0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0x81, 0xE0,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x38, 0x03,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x0F, 0x01, 0x80, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0x80,
  0x38, 0x00, 0x30, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x30, 0x07, 0xE0, 0x0C, 0x00, 0x3C, 0x03, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x1C, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x01, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x38, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x38, 0x03, 0x00, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x36, 0x00, 0x60, 0x03, 0x60, 0x06, 0x00, 0x66, 0x00, 0xE0,
  0x06, 0x60, 0x0E, 0x00, 0x66, 0x00, 0xF0, 0x0C, 0x60, 0x1B, 0x00, 0xC6,
  0x01, 0xB0, 0x0C, 0x60, 0x1B, 0x01, 0xC6, 0x03, 0x30, 0x18, 0x60, 0x33,
  0x01, 0x86, 0x03, 0x30, 0x18, 0x60, 0x63, 0x03, 0x06, 0x06, 0x30, 0x30,
  0x60, 0xE3, 0x03, 0x06, 0x0C, 0x30, 0x60, 0x60, 0xC3, 0x06, 0x06, 0x1C,
  0x30, 0x60, 0x61, 0x83, 0x0E, 0x06, 0x18, 0x30, 0xC0, 0x63, 0x83, 0x0C,
  0x06, 0x30, 0x30, 0xC0, 0x63, 0x03, 0x18, 0x06, 0x70, 0x31, 0x80, 0x66,
  0x03, 0x18, 0x06, 0x60, 0x33, 0x00, 0x6C, 0x03, 0x30, 0x0E, 0xC0, 0x33,
  0x00, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D,
  0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00,
  0x3B, 0x00, 0x0C, 0xE0, 0x06, 0x18, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x70,
  0x60, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0E,
  0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x07, 0xC0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFD, 0xF8, 0x03, 0xC0, 0x1C,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0x80, 0x0C,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x78,
  0xE0, 0x00, 0xF8, 0x60, 0x01, 0xD8, 0x70, 0x07, 0x98, 0x3F, 0xFE, 0x18,
  0x0F, 0xF8, 0x18, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x3F, 0xE0, 0x0C, 0x7F, 0xF8,
  0x0C, 0xE0, 0x38, 0x0F, 0x80, 0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38,
  0x70, 0x00, 0x30, 0xF0, 0x00, 0x70, 0xD8, 0x00, 0xE0, 0xCC, 0x03, 0xC0,
  0xC7, 0xFF, 0x80, 0xC3, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0x60, 0x03, 0x80,
  0xF0, 0x0E, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x20, 0x0C, 0x00, 0xFF, 0x87, 0x00, 0x7F, 0xF9, 0x80, 0x78, 0x07,
  0x60, 0x3C, 0x00, 0xD8, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x0E, 0x01, 0xD8, 0x01, 0xFF, 0xE6, 0x00, 0x3F, 0xE1, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF8, 0x30, 0x07, 0xFF, 0x98, 0x07,
  0x80, 0x76, 0x03, 0xC0, 0x0D, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78,
  0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x3C, 0x07, 0x00,
  0x1F, 0x00, 0xE0, 0x1D, 0x80, 0x1F, 0xFE, 0x60, 0x03, 0xFE, 0x18, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x7F, 0x80, 0x30, 0xFF, 0xF0, 0x19, 0xE0, 0x38, 0x0D, 0xC0,
  0x0E, 0x0F, 0x80, 0x03, 0x06, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x31, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x03, 0xC1, 0x80,
  0x01, 0xC0, 0x60, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x00, 0xC0, 0x3C, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x63, 0x80, 0x00, 0x19, 0xE0,
  0x00, 0x06, 0xFC, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x38,
  0x1C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x80, 0x31, 0xFC, 0x1F, 0xC0,
  0xDF, 0xF9, 0xFF, 0x83, 0xE0, 0x6E, 0x06, 0x0E, 0x01, 0xE0, 0x1C, 0x38,
  0x07, 0x80, 0x31, 0xC0, 0x1C, 0x00, 0xC6, 0x00, 0x70, 0x03, 0x18, 0x01,
  0x80, 0x1C, 0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01, 0x86, 0x00, 0x60,
  0x06, 0x30, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x00, 0x63, 0x00, 0x30, 0x03,
  0x8C, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00, 0x31, 0xC0, 0x0C, 0x00, 0xC6,
  0x00, 0x70, 0x03, 0x18, 0x01, 0x80, 0x0C, 0x60, 0x06, 0x00, 0x61, 0x80,
  0x18, 0x01, 0x86, 0x00, 0x60, 0x06, 0x38, 0x01, 0x80, 0x18, 0xC0, 0x0E,
  0x00, 0x63, 0x00, 0x30, 0x01, 0x8C, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00,
  0x30, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x07, 0xFC, 0x01,
  0x87, 0xFF, 0x00, 0xCE, 0x01, 0xC0, 0x6E, 0x00, 0x70, 0x7C, 0x00, 0x18,
  0x34, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x78, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x18, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0xC3, 0xFE, 0x00, 0x31, 0xFF, 0xC0, 0x0D, 0xE0, 0x38, 0x03,
  0xE0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x18, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x1C, 0x0D, 0x80, 0x0E, 0x03, 0x70,
  0x0F, 0x00, 0xCF, 0xFF, 0x80, 0x30, 0xFF, 0x80, 0x1C, 0x02, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0x87, 0x01, 0xFF, 0xE6, 0x07, 0x80, 0x76, 0x0F, 0x00, 0x36, 0x0E,
  0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x70,
  0x01, 0xF0, 0x38, 0x07, 0x60, 0x1F, 0xFE, 0x60, 0x0F, 0xF8, 0x60, 0x00,
  0x80, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x38,
  0x1F, 0xF0, 0xC1, 0xFF, 0xC3, 0x1E, 0x00, 0x0C, 0xE0, 0x00, 0x36, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x3C, 0x01, 0xE0, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xE0, 0x07, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x70, 0x03, 0xB0, 0x38, 0x07, 0x30,
  0x3F, 0xFE, 0x60, 0x0F, 0xF8, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x07, 0x00, 0x07, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x6C,
  0x01, 0xE0, 0x0C, 0xC0, 0x1E, 0x00, 0xCC, 0x01, 0xE0, 0x1C, 0xC0, 0x36,
  0x01, 0x8C, 0x03, 0x60, 0x18, 0xC0, 0x66, 0x03, 0x0C, 0x06, 0x60, 0x30,
  0xC0, 0xE6, 0x07, 0x0C, 0x0C, 0x20, 0x60, 0xC0, 0xC3, 0x06, 0x06, 0x18,
  0x30, 0xC0, 0x61, 0x83, 0x0C, 0x06, 0x30, 0x30, 0xC0, 0x63, 0x03, 0x18,
  0x06, 0x30, 0x31, 0x80, 0x66, 0x03, 0x30, 0x06, 0x60, 0x33, 0x00, 0x6C,
  0x03, 0x30, 0x06, 0xC0, 0x36, 0x00, 0x68, 0x03, 0x60, 0x07, 0x80, 0x36,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x07,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xCF, 0x07, 0x00, 0x0C, 0x60, 0x1C, 0x00, 0x66, 0x00, 0x70, 0x06,
  0x30, 0x01, 0xC0, 0x73, 0x00, 0x07, 0x8F, 0x18, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1E, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 38, 31, 11, -38 },
  { 44, 11, 11, 31, 13, -40 },
  { 60, 31, 38, 31, 1, -38 },
  { 208, 26, 48, 31, 3, -43 },
  { 364, 26, 39, 31, 3, -38 },
  { 491, 27, 39, 31, 2, -38 },
  { 623, 4, 11, 31, 15, -40 },
  { 629, 16, 54, 31, 9, -42 },
  { 737, 16, 54, 31, 5, -42 },
  { 845, 22, 22, 31, 7, -38 },
  { 906, 26, 27, 31, 3, -31 },
  { 994, 7, 12, 31, 6, -5 },
  { 1005, 19, 2, 31, 6, -18 },
  { 1010, 4, 4, 31, 12, -4 },
  { 1012, 25, 41, 31, 4, -38 },
  { 1141, 24, 39, 31, 4, -38 },
  { 1258, 14, 38, 31, 8, -38 },
  { 1325, 25, 38, 31, 1, -38 },
  { 1444, 26, 39, 31, 1, -38 },
  { 1571, 26, 38, 31, 1, -38 },
  { 1695, 25, 39, 31, 5, -38 },
  { 1817, 23, 39, 31, 3, -38 },
  { 1930, 24, 38, 31, 6, -38 },
  { 2044, 26, 39, 31, 3, -38 },
  { 2171, 23, 38, 31, 5, -38 },
  { 2281, 8, 27, 31, 13, -27 },
  { 2308, 11, 34, 31, 10, -27 },
  { 2355, 24, 22, 31, 4, -28 },
  { 2421, 24, 13, 31, 4, -24 },
  { 2460, 24, 22, 31, 3, -28 },
  { 2526, 20, 38, 31, 8, -38 },
  { 2621, 30, 38, 31, 1, -38 },
  { 2764, 26, 38, 31, 0, -38 },
  { 2888, 27, 38, 31, 2, -38 },
  { 3017, 26, 39, 31, 3, -38 },
  { 3144, 27, 38, 31, 2, -38 },
  { 3273, 27, 38, 31, 3, -38 },
  { 3402, 28, 38, 31, 3, -38 },
  { 3535, 26, 39, 31, 3, -38 },
  { 3662, 28, 38, 31, 2, -38 },
  { 3795, 28, 38, 31, 2, -38 },
  { 3928, 27, 39, 31, 2, -38 },
  { 4060, 29, 38, 31, 3, -38 },
  { 4198, 22, 38, 31, 3, -38 },
  { 4303, 29, 38, 31, 2, -38 },
  { 4441, 28, 38, 31, 2, -38 },
  { 4574, 26, 39, 31, 3, -38 },
  { 4701, 28, 38, 31, 3, -38 },
  { 4834, 27, 45, 31, 3, -38 },
  { 4986, 26, 38, 31, 3, -38 },
  { 5110, 27, 39, 31, 3, -38 },
  { 5242, 26, 38, 31, 6, -38 },
  { 5366, 28, 39, 31, 3, -38 },
  { 5503, 26, 38, 31, 6, -38 },
  { 5627, 28, 38, 31, 5, -38 },
  { 5760, 32, 38, 31, 0, -38 },
  { 5912, 26, 38, 31, 6, -38 },
  { 6036, 28, 38, 31, 1, -38 },
  { 6169, 16, 51, 31, 8, -43 },
  { 6271, 10, 41, 31, 11, -38 },
  { 6323, 17, 51, 31, 7, -43 },
  { 6432, 18, 21, 31, 7, -38 },
  { 6480, 22, 2, 31, 2, 0 },
  { 6486, 6, 7, 31, 16, -39 },
  { 6492, 24, 30, 31, 3, -29 },
  { 6582, 24, 41, 31, 3, -40 },
  { 6705, 23, 30, 31, 4, -29 },
  { 6792, 26, 41, 31, 4, -40 },
  { 6926, 24, 30, 31, 3, -29 },
  { 7016, 25, 40, 31, 7, -40 },
  { 7141, 26, 40, 31, 2, -29 },
  { 7271, 25, 40, 31, 2, -40 },
  { 7396, 22, 38, 31, 3, -38 },
  { 7501, 24, 49, 31, 0, -38 },
  { 7648, 26, 40, 31, 3, -40 },
  { 7778, 22, 40, 31, 3, -40 },
  { 7888, 30, 29, 31, 0, -29 },
  { 7997, 25, 29, 31, 2, -29 },
  { 8088, 25, 30, 31, 3, -29 },
  { 8182, 26, 40, 31, 1, -29 },
  { 8312, 24, 40, 31, 4, -29 },
  { 8432, 22, 29, 31, 7, -29 },
  { 8512, 23, 30, 31, 4, -29 },
  { 8599, 21, 36, 31, 6, -35 },
  { 8694, 24, 29, 31, 4, -28 },
  { 8781, 25, 28, 31, 5, -28 },
  { 8869, 28, 28, 31, 4, -28 },
  { 8967, 28, 28, 31, 1, -28 },
  { 9065, 32, 39, 31, -1, -28 },
  { 9221, 27, 28, 31, 1, -28 },
  { 9316, 21, 52, 31, 8, -41 },
  { 9453, 9, 46, 31, 11, -38 },
  { 9505, 21, 52, 31, 4, -41 },
  { 9642, 29, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC53PT7B_H_
