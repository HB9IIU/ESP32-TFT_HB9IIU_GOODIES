#ifndef _ROBOTOMONO_EXTRALIGHTITALIC32PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x08, 0x42, 0x31, 0x88, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x45, 0x1C, 0x63, 0x8A, 0x28, 0x80, 0x00, 0x20,
  0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82,
  0x00, 0x20, 0xC0, 0xFF, 0xFF, 0x01, 0x02, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x01, 0x06, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x06, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0x01, 0x06, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x06, 0x00,
  0x20, 0x80, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x0F,
  0xC0, 0x71, 0xC1, 0x80, 0x86, 0x01, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x10, 0x00, 0x30, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x10, 0x02,
  0x30, 0x0C, 0x30, 0x70, 0x3F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x44, 0x01, 0x0C, 0x06, 0x08, 0x28, 0x10, 0x90, 0x63, 0x20,
  0x84, 0x41, 0x10, 0xC4, 0x60, 0xF9, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x47, 0x81, 0x19, 0x86, 0x61, 0x08, 0x82, 0x21, 0x04, 0x82, 0x0B,
  0x0C, 0x14, 0x08, 0x60, 0x11, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0x18,
  0x06, 0x08, 0x04, 0x0C, 0x04, 0x08, 0x04, 0x08, 0x04, 0x18, 0x04, 0x30,
  0x04, 0x60, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x09, 0x80, 0x10, 0x81,
  0x20, 0x41, 0x60, 0x63, 0x40, 0x22, 0x40, 0x36, 0x40, 0x1C, 0x40, 0x08,
  0x60, 0x3C, 0x30, 0x64, 0x1F, 0x82, 0x69, 0x25, 0xA0, 0x00, 0x40, 0x60,
  0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x10, 0x0C, 0x06, 0x02, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x81, 0x07, 0xC4, 0xF1, 0xFE, 0x00, 0xC0, 0x05, 0x00, 0x36, 0x01, 0x8C,
  0x0C, 0x10, 0x60, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x32, 0x22, 0x64, 0x80, 0xFF, 0xE0, 0xF8, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x10,
  0xC0, 0x31, 0x00, 0x26, 0x00, 0x48, 0x01, 0x90, 0x07, 0x60, 0x12, 0xC0,
  0x45, 0x03, 0x1A, 0x0C, 0x34, 0x30, 0x48, 0x80, 0xB2, 0x01, 0x78, 0x06,
  0xE0, 0x0D, 0x80, 0x11, 0x00, 0x62, 0x00, 0x86, 0x02, 0x06, 0x1C, 0x07,
  0xE0, 0x00, 0x01, 0x07, 0x1D, 0xE3, 0x83, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x30, 0xC0, 0x23, 0x00, 0x64, 0x00,
  0xC8, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x0E,
  0x38, 0x30, 0x18, 0xC0, 0x11, 0x00, 0x26, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x01, 0xC0, 0x3E, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0D, 0x00, 0x1A, 0x00, 0x26, 0x00, 0xC4, 0x03,
  0x0E, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xA0, 0x06, 0xC0, 0x09, 0x80, 0x22, 0x00, 0xC4, 0x03, 0x08, 0x0C, 0x10,
  0x10, 0x60, 0x40, 0xC1, 0x01, 0x06, 0x02, 0x18, 0x04, 0x60, 0x08, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x5F, 0xC0, 0xC0, 0xC1, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x09, 0x00, 0x32, 0x00,
  0x44, 0x01, 0x8C, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x23,
  0xC1, 0xB9, 0xC5, 0x01, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0A, 0x00, 0x2C, 0x01, 0x90, 0x04, 0x60, 0x30, 0xC3, 0x81,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x10, 0x02, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x04, 0x18, 0x0C, 0x0E, 0x30, 0x07, 0xE0, 0x18, 0x30, 0x30, 0x08, 0x60,
  0x0C, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x08, 0x40,
  0x18, 0x70, 0x70, 0x1F, 0xC0, 0x07, 0xE0, 0x30, 0xC1, 0x81, 0x8C, 0x02,
  0x60, 0x0D, 0x00, 0x34, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xD0, 0x06, 0x40, 0x39, 0x81, 0xA3, 0xF9, 0x81, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x38, 0x07, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x20, 0xC1,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x20, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00,
  0x80, 0x00, 0x0F, 0x83, 0x8E, 0x60, 0x24, 0x03, 0xC0, 0x38, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x7C, 0x00, 0x71, 0xC0, 0x60, 0x10, 0x30, 0x02, 0x18, 0x00,
  0x84, 0x3E, 0x22, 0x18, 0x8C, 0x8C, 0x23, 0x42, 0x08, 0xD1, 0x04, 0x24,
  0x41, 0x0A, 0x10, 0x42, 0x88, 0x10, 0xA2, 0x08, 0x28, 0x82, 0x12, 0x21,
  0x84, 0x88, 0xA2, 0x21, 0xEF, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x28, 0x00, 0x48, 0x00, 0x48, 0x00, 0xC8, 0x00, 0x8C, 0x01, 0x8C, 0x01,
  0x04, 0x03, 0x04, 0x02, 0x04, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x06, 0x0F,
  0xFE, 0x18, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40,
  0x03, 0xC0, 0x03, 0x0F, 0xF0, 0x0F, 0xFC, 0x08, 0x06, 0x08, 0x03, 0x08,
  0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x03, 0x10, 0x02, 0x10, 0x0C, 0x10,
  0x38, 0x3F, 0xF0, 0x30, 0x0C, 0x20, 0x06, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x0C, 0x40, 0x18, 0x40, 0x70, 0xFF,
  0xC0, 0x01, 0xF0, 0x07, 0x1C, 0x0C, 0x04, 0x18, 0x02, 0x10, 0x02, 0x30,
  0x03, 0x20, 0x03, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04, 0x80,
  0x0C, 0xC0, 0x08, 0x40, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0x80, 0x0F,
  0xE0, 0x04, 0x1C, 0x02, 0x01, 0x81, 0x00, 0x41, 0x80, 0x30, 0xC0, 0x08,
  0x40, 0x04, 0x20, 0x03, 0x10, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x46, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x60, 0x06, 0x30,
  0x02, 0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x06, 0x0F, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x08, 0xFF, 0xF0, 0x0F, 0xFF,
  0x1F, 0xFF, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x1C,
  0x0C, 0x06, 0x18, 0x02, 0x10, 0x02, 0x20, 0x03, 0x20, 0x03, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0xFE, 0x80, 0xFE,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0xC0, 0x0C, 0x40, 0x0C,
  0x60, 0x18, 0x30, 0x30, 0x1F, 0xC0, 0x08, 0x00, 0x84, 0x00, 0x46, 0x00,
  0x23, 0x00, 0x11, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x20, 0x02, 0x30,
  0x01, 0x18, 0x00, 0x88, 0x00, 0xC7, 0xFF, 0xC2, 0x00, 0x21, 0x00, 0x11,
  0x80, 0x08, 0xC0, 0x0C, 0x40, 0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x8C, 0x00, 0x44, 0x00, 0x62, 0x00, 0x30, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x60, 0x06, 0x30, 0x02,
  0x08, 0x03, 0x06, 0x03, 0x01, 0x83, 0x00, 0x7E, 0x00, 0x08, 0x00, 0xC6,
  0x00, 0xC1, 0x80, 0x60, 0x40, 0x30, 0x10, 0x18, 0x04, 0x0C, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x02, 0x60, 0x00, 0xBC, 0x00,
  0x79, 0x00, 0x1C, 0x60, 0x06, 0x08, 0x01, 0x03, 0x00, 0x40, 0x60, 0x10,
  0x08, 0x0C, 0x03, 0x03, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00,
  0xC0, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x03, 0xFF, 0xE0, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x70, 0x0A,
  0x1E, 0x06, 0x85, 0x81, 0x61, 0x20, 0xD8, 0x48, 0x24, 0x12, 0x19, 0x0C,
  0x84, 0x43, 0x32, 0x10, 0x84, 0x8C, 0x21, 0x43, 0x08, 0x70, 0x82, 0x18,
  0x21, 0x86, 0x08, 0x60, 0x06, 0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x10,
  0xC0, 0x04, 0x30, 0x01, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x86, 0x00, 0x47,
  0x00, 0x23, 0x80, 0x31, 0x60, 0x18, 0x90, 0x08, 0x48, 0x04, 0x22, 0x02,
  0x31, 0x01, 0x18, 0xC1, 0x88, 0x20, 0xC4, 0x10, 0x42, 0x0C, 0x21, 0x02,
  0x11, 0x81, 0x08, 0xC0, 0xCC, 0x40, 0x26, 0x20, 0x12, 0x10, 0x05, 0x08,
  0x02, 0x8C, 0x01, 0xC6, 0x00, 0x62, 0x00, 0x30, 0x01, 0xF0, 0x0E, 0x30,
  0x30, 0x10, 0xC0, 0x31, 0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x40, 0x02, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x62, 0x00, 0x86, 0x02, 0x06,
  0x1C, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x04, 0x0E, 0x06, 0x01, 0x83, 0x00,
  0x61, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x30, 0x03, 0x18,
  0x01, 0x08, 0x01, 0x84, 0x01, 0x83, 0xFF, 0x03, 0xFC, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x1C, 0x0C, 0x04, 0x18,
  0x02, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x18, 0x40, 0x30, 0x30,
  0xE0, 0x1F, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x0F,
  0xE0, 0x18, 0x38, 0x18, 0x04, 0x10, 0x06, 0x10, 0x02, 0x10, 0x02, 0x30,
  0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x18, 0x7F,
  0xE0, 0x60, 0x40, 0x40, 0x40, 0x40, 0x60, 0x40, 0x20, 0x40, 0x30, 0xC0,
  0x30, 0xC0, 0x10, 0x80, 0x18, 0x80, 0x18, 0x80, 0x08, 0x01, 0xF0, 0x07,
  0x1C, 0x0C, 0x06, 0x10, 0x02, 0x30, 0x03, 0x20, 0x03, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0xC0,
  0x0C, 0x40, 0x18, 0x70, 0x70, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20,
  0x03, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40,
  0x06, 0x40, 0x06, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0x80,
  0x0C, 0x80, 0x08, 0xC0, 0x18, 0x40, 0x10, 0x60, 0x30, 0x30, 0xE0, 0x1F,
  0x80, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x6C, 0x00, 0x98, 0x03,
  0x10, 0x04, 0x20, 0x18, 0x40, 0x20, 0x80, 0xC1, 0x81, 0x03, 0x06, 0x06,
  0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x23, 0x00, 0x64, 0x00, 0xD8,
  0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x80, 0xE0,
  0x40, 0xF0, 0x60, 0x58, 0x30, 0x2C, 0x18, 0x36, 0x1C, 0x13, 0x0A, 0x09,
  0x85, 0x8C, 0xC6, 0xC4, 0x62, 0x62, 0x31, 0x31, 0x19, 0x19, 0x8C, 0x8C,
  0x86, 0x42, 0x43, 0x41, 0x61, 0xA0, 0xA0, 0xF0, 0x50, 0x70, 0x38, 0x28,
  0x18, 0x14, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x80, 0x08, 0x18, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x04,
  0x00, 0x41, 0x80, 0x0C, 0x60, 0x00, 0x98, 0x00, 0x1A, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x60, 0x00, 0x44, 0x00, 0x18, 0xC0,
  0x06, 0x08, 0x01, 0x81, 0x00, 0x20, 0x30, 0x0C, 0x02, 0x03, 0x00, 0x60,
  0xC0, 0x04, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x00, 0x0B, 0x00, 0x32, 0x00,
  0xC4, 0x01, 0x0C, 0x06, 0x08, 0x18, 0x10, 0x20, 0x30, 0xC0, 0x21, 0x00,
  0x44, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFF, 0x88, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xC3, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x0F, 0x80, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10,
  0x20, 0x60, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC0,
  0x81, 0x02, 0x06, 0x07, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x0F, 0x80, 0x01, 0x00, 0x60, 0x0E, 0x03, 0x40,
  0x48, 0x11, 0x06, 0x30, 0x82, 0x30, 0x44, 0x09, 0x81, 0xA0, 0x38, 0x02,
  0xFF, 0xF8, 0xC4, 0x22, 0x10, 0x07, 0xF0, 0x30, 0x61, 0x00, 0xCC, 0x01,
  0x20, 0x04, 0x00, 0x10, 0x00, 0xC0, 0xFF, 0x1F, 0xF9, 0xC0, 0x24, 0x00,
  0xA0, 0x02, 0x80, 0x1A, 0x00, 0xE8, 0x07, 0x18, 0x34, 0x3F, 0x10, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0xFC, 0x3C, 0x18, 0xE0, 0x23, 0x00, 0xC8, 0x01, 0x20, 0x05, 0x80, 0x16,
  0x00, 0x50, 0x01, 0x40, 0x0D, 0x00, 0x24, 0x00, 0xB0, 0x06, 0xC0, 0x13,
  0x80, 0xCB, 0x0E, 0x27, 0xE0, 0x03, 0xF0, 0x30, 0x61, 0x80, 0xCC, 0x01,
  0x20, 0x05, 0x80, 0x14, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x09, 0x00, 0x66, 0x03, 0x0C, 0x18, 0x1F, 0x80, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x07, 0xE6, 0x0C, 0x34, 0x18, 0x0C, 0x30, 0x0C, 0x20, 0x04, 0x60,
  0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0,
  0x18, 0xC0, 0x18, 0x40, 0x10, 0x60, 0x30, 0x30, 0xD0, 0x1F, 0x90, 0x03,
  0xF0, 0x1C, 0x30, 0x60, 0x31, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x01,
  0x7F, 0xFE, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x06, 0x18, 0x38, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x7F, 0xFC, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x03, 0xF3, 0x06, 0x1B, 0x0C, 0x06, 0x18, 0x06,
  0x10, 0x02, 0x30, 0x06, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x60, 0x04,
  0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x20, 0x08, 0x30, 0x18, 0x18, 0x68,
  0x0F, 0xC8, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0xC0, 0x20, 0x40, 0x60,
  0x3B, 0x80, 0x1E, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x7C, 0x13, 0x0C, 0x28, 0x0C, 0x60,
  0x08, 0x80, 0x13, 0x00, 0x26, 0x00, 0x48, 0x01, 0x90, 0x03, 0x20, 0x04,
  0x40, 0x09, 0x80, 0x13, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x90, 0x02, 0x60,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x03, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x08, 0xE0, 0x1F, 0x00, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x03, 0x10, 0x0C, 0x60, 0x60, 0xC1, 0x81, 0x06, 0x02, 0x18,
  0x04, 0xC0, 0x0B, 0x80, 0x3D, 0x00, 0x73, 0x00, 0x83, 0x01, 0x02, 0x02,
  0x06, 0x04, 0x06, 0x18, 0x04, 0x30, 0x0C, 0x40, 0x0C, 0x0F, 0xE0, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x1F, 0xFF,
  0x17, 0xCF, 0x8E, 0x16, 0x33, 0x06, 0x04, 0xC1, 0x81, 0x20, 0x60, 0x48,
  0x10, 0x32, 0x04, 0x0D, 0x81, 0x02, 0x40, 0x40, 0x90, 0x30, 0x24, 0x08,
  0x09, 0x02, 0x06, 0xC0, 0x81, 0x30, 0x20, 0x48, 0x18, 0x12, 0x06, 0x04,
  0x81, 0x03, 0x00, 0x18, 0xF8, 0x26, 0x18, 0x50, 0x18, 0xC0, 0x11, 0x00,
  0x26, 0x00, 0x4C, 0x00, 0x90, 0x03, 0x20, 0x06, 0x40, 0x08, 0x80, 0x13,
  0x00, 0x26, 0x00, 0x48, 0x01, 0x90, 0x03, 0x20, 0x04, 0xC0, 0x08, 0x07,
  0xE0, 0x18, 0x30, 0x60, 0x21, 0x80, 0x66, 0x00, 0x48, 0x00, 0xB0, 0x01,
  0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x68, 0x00, 0x98,
  0x03, 0x10, 0x0C, 0x18, 0x70, 0x1F, 0x80, 0x0C, 0xFC, 0x0B, 0x0E, 0x0E,
  0x02, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30, 0x06, 0x30, 0x04, 0x30,
  0x08, 0x2C, 0x38, 0x27, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x07, 0xE6, 0x18, 0x68, 0x60,
  0x31, 0x80, 0x62, 0x00, 0x4C, 0x01, 0x90, 0x03, 0x20, 0x04, 0xC0, 0x09,
  0x80, 0x13, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x18,
  0x68, 0x1F, 0x90, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x10, 0xFC, 0x4C, 0x01, 0x40, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x18, 0x30, 0x40, 0x31, 0x80, 0x22, 0x00, 0x66, 0x00, 0x04, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x4C, 0x00, 0x98, 0x01,
  0x10, 0x06, 0x30, 0x38, 0x1F, 0xC0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0xFF, 0xF0, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x0F, 0xC0, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44,
  0x00, 0x98, 0x03, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x01, 0x88, 0x03, 0x10, 0x0C, 0x30, 0x68, 0x3F, 0x90, 0x80, 0x07,
  0x80, 0x0B, 0x00, 0x32, 0x00, 0x44, 0x01, 0x8C, 0x02, 0x08, 0x08, 0x10,
  0x30, 0x20, 0x40, 0x61, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x10, 0x03, 0x40,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x80, 0xE0, 0x40, 0xF0, 0x60,
  0x48, 0x30, 0x24, 0x3C, 0x22, 0x16, 0x11, 0x09, 0x18, 0x88, 0x88, 0x44,
  0x44, 0x24, 0x24, 0x12, 0x12, 0x0B, 0x0B, 0x05, 0x05, 0x02, 0x82, 0x81,
  0x81, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0x10, 0x01, 0x8C, 0x01, 0x83,
  0x01, 0x80, 0x81, 0x80, 0x61, 0x80, 0x11, 0x80, 0x05, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x90, 0x00, 0x84, 0x00, 0x83, 0x00, 0xC0,
  0x80, 0xC0, 0x60, 0xC0, 0x10, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x30, 0x80,
  0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x04, 0x01, 0x80, 0x60, 0x10, 0x06,
  0x03, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00,
  0x11, 0x80, 0x01, 0x10, 0x00, 0x1B, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0xBC, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x08, 0x46, 0x31, 0x08, 0x42, 0x11,
  0x88, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x84, 0x23, 0x10, 0x84, 0x21, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x07,
  0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x08, 0x00,
  0x3E, 0x00, 0xB1, 0x80, 0xF0, 0x60, 0x50, 0x1C, 0x68, 0x03, 0xC0,
};

const GFXglyph RobotoMono_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 6, 7, 19, 8, -24 },
  { 22, 19, 23, 19, 0, -23 },
  { 77, 15, 29, 19, 2, -26 },
  { 132, 15, 23, 19, 2, -23 },
  { 176, 16, 23, 19, 1, -23 },
  { 222, 3, 7, 19, 9, -24 },
  { 225, 10, 32, 19, 5, -25 },
  { 265, 10, 32, 19, 3, -25 },
  { 305, 14, 13, 19, 4, -23 },
  { 328, 15, 17, 19, 2, -19 },
  { 360, 4, 7, 19, 4, -3 },
  { 364, 11, 1, 19, 4, -11 },
  { 366, 3, 2, 19, 7, -2 },
  { 367, 15, 25, 19, 2, -23 },
  { 414, 15, 23, 19, 2, -23 },
  { 458, 8, 23, 19, 5, -23 },
  { 481, 15, 23, 19, 1, -23 },
  { 525, 15, 23, 19, 1, -23 },
  { 569, 15, 23, 19, 1, -23 },
  { 613, 15, 23, 19, 3, -23 },
  { 657, 14, 23, 19, 2, -23 },
  { 698, 14, 23, 19, 4, -23 },
  { 739, 16, 23, 19, 2, -23 },
  { 785, 14, 23, 19, 3, -23 },
  { 826, 5, 16, 19, 8, -16 },
  { 836, 7, 20, 19, 6, -16 },
  { 854, 14, 13, 19, 3, -17 },
  { 877, 15, 7, 19, 2, -14 },
  { 891, 14, 13, 19, 2, -17 },
  { 914, 12, 23, 19, 5, -23 },
  { 949, 18, 23, 19, 1, -23 },
  { 1001, 16, 23, 19, 0, -23 },
  { 1047, 16, 23, 19, 1, -23 },
  { 1093, 16, 23, 19, 2, -23 },
  { 1139, 17, 23, 19, 1, -23 },
  { 1188, 16, 23, 19, 2, -23 },
  { 1234, 16, 23, 19, 2, -23 },
  { 1280, 16, 23, 19, 2, -23 },
  { 1326, 17, 23, 19, 1, -23 },
  { 1375, 17, 23, 19, 1, -23 },
  { 1424, 17, 23, 19, 1, -23 },
  { 1473, 18, 23, 19, 2, -23 },
  { 1525, 13, 23, 19, 2, -23 },
  { 1563, 18, 23, 19, 1, -23 },
  { 1615, 17, 23, 19, 1, -23 },
  { 1664, 15, 23, 19, 2, -23 },
  { 1708, 17, 23, 19, 2, -23 },
  { 1757, 16, 27, 19, 2, -23 },
  { 1811, 16, 23, 19, 2, -23 },
  { 1857, 16, 23, 19, 2, -23 },
  { 1903, 15, 23, 19, 4, -23 },
  { 1947, 16, 23, 19, 2, -23 },
  { 1993, 15, 23, 19, 4, -23 },
  { 2037, 17, 23, 19, 3, -23 },
  { 2086, 19, 23, 19, 0, -23 },
  { 2141, 15, 23, 19, 4, -23 },
  { 2185, 17, 23, 19, 1, -23 },
  { 2234, 10, 31, 19, 5, -26 },
  { 2273, 7, 25, 19, 6, -23 },
  { 2295, 10, 31, 19, 4, -26 },
  { 2334, 11, 13, 19, 4, -23 },
  { 2352, 13, 1, 19, 1, 0 },
  { 2354, 4, 5, 19, 9, -24 },
  { 2357, 14, 17, 19, 2, -17 },
  { 2387, 14, 24, 19, 2, -24 },
  { 2429, 14, 17, 19, 2, -17 },
  { 2459, 16, 24, 19, 2, -24 },
  { 2507, 15, 17, 19, 2, -17 },
  { 2539, 15, 24, 19, 4, -24 },
  { 2584, 16, 24, 19, 1, -17 },
  { 2632, 15, 24, 19, 1, -24 },
  { 2677, 13, 23, 19, 2, -23 },
  { 2715, 15, 30, 19, 0, -23 },
  { 2772, 15, 24, 19, 2, -24 },
  { 2817, 13, 24, 19, 2, -24 },
  { 2856, 18, 17, 19, 0, -17 },
  { 2895, 15, 17, 19, 1, -17 },
  { 2927, 15, 17, 19, 2, -17 },
  { 2959, 16, 24, 19, 0, -17 },
  { 3007, 15, 24, 19, 2, -17 },
  { 3052, 14, 17, 19, 4, -17 },
  { 3082, 15, 17, 19, 2, -17 },
  { 3114, 12, 21, 19, 4, -21 },
  { 3146, 15, 17, 19, 2, -17 },
  { 3178, 15, 17, 19, 3, -17 },
  { 3210, 17, 17, 19, 2, -17 },
  { 3247, 17, 17, 19, 1, -17 },
  { 3284, 20, 24, 19, -1, -17 },
  { 3344, 16, 17, 19, 1, -17 },
  { 3378, 12, 32, 19, 5, -25 },
  { 3426, 5, 28, 19, 7, -23 },
  { 3444, 12, 32, 19, 3, -25 },
  { 3492, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC32PT7B_H_
