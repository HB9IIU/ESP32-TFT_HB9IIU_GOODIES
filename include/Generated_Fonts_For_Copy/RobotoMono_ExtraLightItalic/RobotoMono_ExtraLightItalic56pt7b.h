#ifndef _ROBOTOMONO_EXTRALIGHTITALIC56PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1C,
  0x0F, 0x01, 0xC0, 0x38, 0x33, 0x03, 0x30, 0x73, 0x06, 0x30, 0x63, 0x06,
  0x60, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xE0, 0x18, 0x03, 0x18, 0x03, 0x00, 0xE3, 0x00, 0x60, 0x18,
  0x60, 0x0C, 0x06, 0x0C, 0x01, 0x81, 0xC3, 0x80, 0x70, 0x70, 0x70, 0x0C,
  0x0C, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x60, 0xE0, 0x18, 0x1C, 0x18, 0x01,
  0x87, 0x06, 0x00, 0x3F, 0xC1, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x01, 0xC1, 0xFC, 0x00, 0x30, 0x71, 0xC0, 0x0C, 0x1C,
  0x1C, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x18, 0x38, 0x06, 0x06,
  0x06, 0x00, 0xC1, 0xC0, 0xC0, 0x18, 0x30, 0x18, 0x03, 0x0C, 0x03, 0x00,
  0x63, 0x80, 0x60, 0x0C, 0xE0, 0x0C, 0x03, 0x08, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x30, 0xE0, 0x30, 0x03, 0x1C, 0x03, 0x80, 0x71, 0x80, 0x1C, 0x06, 0x38,
  0x00, 0xC0, 0x63, 0x00, 0x0E, 0x0E, 0x70, 0x00, 0x60, 0xC6, 0x00, 0x07,
  0x1C, 0x60, 0x00, 0x39, 0x86, 0x00, 0x01, 0xB8, 0x60, 0x00, 0x1F, 0x06,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x00, 0x03, 0xF0, 0x38, 0x00,
  0x73, 0x81, 0xE0, 0x1E, 0x38, 0x0F, 0xFF, 0x81, 0xC0, 0x3F, 0xF0, 0x0E,
  0x00, 0x60, 0x00, 0x00, 0x33, 0x33, 0x76, 0x66, 0x66, 0xCC, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x0C, 0x01, 0x70, 0x0C, 0x0F, 0xFE, 0x18, 0x7F, 0x1F, 0x99,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x83, 0x00, 0x07, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x10, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x8E, 0x31, 0xCE, 0x30,
  0x40, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0x80, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xCE,
  0x00, 0x03, 0x33, 0x00, 0x03, 0x9C, 0xC0, 0x01, 0xC7, 0x30, 0x00, 0xE1,
  0xDC, 0x00, 0x70, 0x67, 0x00, 0x38, 0x19, 0x80, 0x38, 0x06, 0x60, 0x1C,
  0x01, 0x98, 0x0E, 0x00, 0xE6, 0x07, 0x00, 0x3B, 0x83, 0x80, 0x0C, 0xE3,
  0x80, 0x03, 0x31, 0xC0, 0x00, 0xCC, 0xE0, 0x00, 0x73, 0x70, 0x00, 0x1C,
  0xF8, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F,
  0xC0, 0xFF, 0x1F, 0x9D, 0xF0, 0x6F, 0x01, 0xB0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00,
  0xE0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x63, 0xFE, 0x00, 0x0D, 0xFF,
  0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x30, 0xFF,
  0xE0, 0x19, 0xE0, 0x78, 0x1D, 0xC0, 0x0E, 0x0D, 0x80, 0x03, 0x87, 0x80,
  0x00, 0xC3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01,
  0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xF0, 0xE0, 0x01,
  0xD8, 0x38, 0x01, 0xDC, 0x0F, 0x07, 0xCC, 0x03, 0xFF, 0x86, 0x00, 0x7F,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x07, 0x83, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x3C,
  0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x70, 0x38, 0x01, 0xC3, 0x80,
  0x07, 0x38, 0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x78, 0x06, 0x07, 0x01, 0xFE,
  0x06, 0x06, 0x03, 0x87, 0x06, 0x0E, 0x07, 0x03, 0x02, 0x0C, 0x0C, 0x03,
  0x02, 0x1C, 0x1C, 0x02, 0x02, 0x18, 0x18, 0x06, 0x02, 0x18, 0x30, 0x06,
  0x06, 0x30, 0x30, 0x06, 0x06, 0x30, 0x30, 0x0C, 0x06, 0x30, 0x60, 0x0C,
  0x06, 0x60, 0x60, 0x0C, 0x06, 0x60, 0x60, 0x08, 0x06, 0x60, 0xC0, 0x18,
  0x0C, 0x60, 0xC0, 0x18, 0x0C, 0x60, 0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x30,
  0x08, 0xC0, 0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x70, 0x18, 0xC0, 0xC0, 0xF0,
  0x30, 0xC0, 0xC1, 0xB0, 0x70, 0x60, 0xE3, 0x98, 0xE0, 0x60, 0x7F, 0x1F,
  0xC0, 0x60, 0x3C, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x30, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x0C, 0x00, 0xFC, 0x01, 0x80, 0x03, 0xC0, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x3C, 0x06,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x81, 0x80, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x0F, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF0, 0x06, 0x00,
  0x0F, 0x00, 0x30, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x40, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7C,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xCE,
  0x00, 0x3F, 0xFC, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x60, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x78,
  0x00, 0x18, 0x01, 0xE0, 0x00, 0x30, 0x07, 0x80, 0x00, 0x60, 0x1E, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x06, 0x07, 0x80, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00,
  0xE7, 0xE0, 0x00, 0x01, 0xDC, 0xC0, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x07,
  0xC1, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x06, 0xC0,
  0x6C, 0x00, 0x1D, 0x80, 0xD8, 0x00, 0x37, 0x03, 0xB0, 0x00, 0xEC, 0x07,
  0x60, 0x01, 0x98, 0x0C, 0xE0, 0x07, 0x30, 0x18, 0xC0, 0x0C, 0x60, 0x31,
  0x80, 0x39, 0xC0, 0x63, 0x00, 0xE3, 0x81, 0xC6, 0x01, 0x86, 0x03, 0x8C,
  0x07, 0x0C, 0x06, 0x1C, 0x0C, 0x18, 0x0C, 0x18, 0x38, 0x30, 0x18, 0x30,
  0x60, 0xE0, 0x30, 0x61, 0xC1, 0x80, 0xE0, 0xC3, 0x03, 0x01, 0xC1, 0xCC,
  0x06, 0x03, 0x01, 0xB8, 0x0C, 0x06, 0x03, 0x60, 0x38, 0x0C, 0x07, 0xC0,
  0x70, 0x18, 0x0F, 0x00, 0xC0, 0x70, 0x1E, 0x01, 0x80, 0xC0, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x3C,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x18, 0x0F, 0x80,
  0x00, 0x60, 0x76, 0x00, 0x01, 0x81, 0xD8, 0x00, 0x06, 0x06, 0x30, 0x00,
  0x38, 0x18, 0xC0, 0x00, 0xE0, 0x63, 0x80, 0x03, 0x01, 0x86, 0x00, 0x0C,
  0x0E, 0x18, 0x00, 0x30, 0x38, 0x70, 0x00, 0xC0, 0xC0, 0xC0, 0x07, 0x03,
  0x03, 0x00, 0x1C, 0x0C, 0x0E, 0x00, 0x60, 0x30, 0x18, 0x01, 0x81, 0xC0,
  0x60, 0x06, 0x07, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xE0, 0x60, 0x0E,
  0x03, 0x81, 0x80, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x38, 0x01, 0xC0,
  0xC0, 0xE0, 0x03, 0x07, 0x03, 0x00, 0x0C, 0x1C, 0x0C, 0x00, 0x18, 0x60,
  0x30, 0x00, 0x61, 0x80, 0xC0, 0x01, 0xC6, 0x07, 0x00, 0x03, 0x18, 0x18,
  0x00, 0x0C, 0xE0, 0x60, 0x00, 0x3B, 0x81, 0x80, 0x00, 0x6C, 0x06, 0x00,
  0x01, 0xB0, 0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0x3C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x1C,
  0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x01, 0xC0,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x60, 0x03, 0xF0, 0x03, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x11, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x1F,
  0x00, 0x38, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80,
  0x38, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x01, 0xF0, 0x01, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x6C, 0x00, 0xF0,
  0x07, 0x60, 0x07, 0x80, 0x33, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x60, 0x1C,
  0xC0, 0x1B, 0x00, 0xC6, 0x01, 0x98, 0x06, 0x30, 0x0C, 0xC0, 0x31, 0x80,
  0x66, 0x03, 0x0C, 0x06, 0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x03, 0x8C,
  0x0E, 0x18, 0x18, 0x60, 0x60, 0xC0, 0xC3, 0x03, 0x06, 0x0E, 0x18, 0x38,
  0x30, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x38, 0x30, 0x60, 0x61,
  0x81, 0x86, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xE0, 0x61, 0x80, 0xC6, 0x03,
  0x1C, 0x06, 0x30, 0x18, 0xC0, 0x33, 0x80, 0xC6, 0x01, 0x98, 0x06, 0x70,
  0x0C, 0xC0, 0x33, 0x00, 0x6E, 0x01, 0x98, 0x03, 0x60, 0x0C, 0xC0, 0x1B,
  0x00, 0x6C, 0x00, 0xF8, 0x03, 0x60, 0x07, 0x80, 0x1B, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x0E, 0x0E, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x03, 0x80,
  0x70, 0x60, 0x0E, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00,
  0x76, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0xE0, 0xE0, 0xC1, 0xC1, 0x83, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x7C, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xC0, 0x06, 0x1F, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x3E, 0x1C, 0x00, 0x3B, 0x0F, 0x00, 0xF1, 0x83, 0xFF,
  0xF0, 0xC0, 0x7F, 0xE0, 0x60, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0xFF,
  0x00, 0x31, 0xFF, 0xC0, 0x19, 0xE0, 0xF0, 0x1D, 0xC0, 0x1C, 0x0D, 0x80,
  0x07, 0x07, 0x80, 0x01, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0x83, 0xC0, 0x01, 0xC3, 0xF0, 0x01, 0xC1, 0xDC, 0x03,
  0xC0, 0xC7, 0xFF, 0xC0, 0x60, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x70, 0x03, 0xC0,
  0x70, 0x00, 0x60, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x73, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x03,
  0x80, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x18, 0x01, 0xFF, 0xC3, 0x00,
  0x78, 0x1C, 0xE0, 0x3C, 0x00, 0xDC, 0x07, 0x00, 0x0F, 0x81, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x76, 0x01,
  0xE0, 0x1D, 0xC0, 0x1F, 0xFF, 0x30, 0x00, 0xFF, 0x86, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x81, 0xE0,
  0x07, 0x80, 0x3C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x04, 0x06,
  0x00, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xE7, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x60, 0x07, 0xFF, 0x0C, 0x01, 0xE0, 0x71, 0x80, 0x70, 0x03, 0x70, 0x1C,
  0x00, 0x3E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0xC0, 0x38, 0x01, 0xD8, 0x07, 0x80, 0x77, 0x00, 0x7F, 0xFC, 0xC0, 0x03,
  0xFE, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x38, 0x0E, 0x00,
  0x06, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x7F, 0x80,
  0x70, 0xFF, 0xE0, 0x38, 0xF0, 0x78, 0x18, 0xC0, 0x0E, 0x0C, 0xC0, 0x03,
  0x86, 0xC0, 0x01, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x31, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0x78, 0x06, 0x00, 0x1C,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xE0,
  0x38, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x07, 0x80, 0x00, 0x61, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x6F, 0xE0, 0x00, 0x0F, 0xCC,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x18,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x1F, 0x80, 0xFC, 0x03, 0x3F, 0xE1, 0xFF, 0x01, 0xB8,
  0x39, 0xC3, 0xC0, 0xF8, 0x0D, 0x80, 0x60, 0x70, 0x07, 0x80, 0x30, 0x38,
  0x03, 0x80, 0x18, 0x18, 0x01, 0xC0, 0x0C, 0x1C, 0x00, 0xE0, 0x06, 0x0C,
  0x00, 0x60, 0x03, 0x06, 0x00, 0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC1,
  0x80, 0x1C, 0x00, 0xE0, 0xC0, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x07, 0x00, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00,
  0x30, 0x60, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x18, 0x30, 0x01, 0x80,
  0x0C, 0x18, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x01, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x07, 0xF8, 0x07, 0x0F, 0xFE,
  0x03, 0x0F, 0x07, 0x81, 0x9C, 0x00, 0xE0, 0xDC, 0x00, 0x30, 0x6C, 0x00,
  0x1C, 0x3C, 0x00, 0x06, 0x3C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x83, 0xF8,
  0x00, 0x31, 0xFF, 0xC0, 0x0E, 0x78, 0x3C, 0x01, 0xB8, 0x01, 0xC0, 0x3E,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x07, 0xC0, 0x01,
  0xC0, 0xF8, 0x00, 0xF0, 0x1D, 0xC0, 0x3C, 0x03, 0x1F, 0xFF, 0x00, 0x61,
  0xFF, 0x80, 0x0C, 0x01, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0x80, 0x7F, 0xF0, 0xC0, 0x78,
  0x1C, 0x60, 0xF0, 0x03, 0x70, 0x70, 0x00, 0xF8, 0x70, 0x00, 0x78, 0x70,
  0x00, 0x1C, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x76, 0x07, 0x80, 0x77, 0x01, 0xFF, 0xF3, 0x00, 0x3F,
  0xE1, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0xFF, 0x06, 0x0F, 0xFF, 0x06, 0x1F, 0x02, 0x06, 0x78,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x1E, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x07, 0x00, 0x1D, 0x80, 0xE0, 0x1E, 0x60, 0x1F, 0xFF, 0x18, 0x03, 0xFF,
  0x0E, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x06, 0x00, 0x0E,
  0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x80, 0x0E,
  0x00, 0x6E, 0x00, 0xF0, 0x03, 0x70, 0x07, 0x80, 0x33, 0x80, 0x6C, 0x01,
  0x9C, 0x03, 0x60, 0x1C, 0xE0, 0x3B, 0x00, 0xC3, 0x01, 0x98, 0x06, 0x18,
  0x0C, 0xC0, 0x70, 0xC0, 0xC6, 0x03, 0x06, 0x06, 0x18, 0x18, 0x30, 0x60,
  0xC1, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0xE0, 0x61, 0x81, 0x86,
  0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xC6, 0x03, 0x18, 0x06,
  0x70, 0x19, 0xC0, 0x33, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x60, 0x0D, 0x80,
  0x36, 0x00, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x05, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x00, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0C, 0x3F, 0xF0, 0x00, 0x31, 0xC1, 0xE0, 0x00, 0xCE, 0x01,
  0xC0, 0x07, 0x70, 0x03, 0x80, 0x19, 0x80, 0x07, 0x00, 0xE6, 0x00, 0x0F,
  0x0F, 0x30, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 10, 40, 33, 11, -40 },
  { 51, 12, 12, 33, 13, -42 },
  { 69, 32, 40, 33, 1, -40 },
  { 229, 27, 52, 33, 4, -46 },
  { 405, 27, 41, 33, 3, -40 },
  { 544, 28, 41, 33, 2, -40 },
  { 688, 4, 12, 33, 16, -42 },
  { 694, 17, 58, 33, 10, -45 },
  { 818, 17, 57, 33, 5, -44 },
  { 940, 24, 23, 33, 7, -40 },
  { 1009, 27, 29, 33, 3, -33 },
  { 1107, 6, 13, 33, 7, -5 },
  { 1117, 20, 2, 33, 6, -19 },
  { 1122, 5, 4, 33, 12, -4 },
  { 1125, 26, 43, 33, 4, -40 },
  { 1265, 26, 41, 33, 4, -40 },
  { 1399, 14, 40, 33, 9, -40 },
  { 1469, 27, 40, 33, 1, -40 },
  { 1604, 28, 41, 33, 1, -40 },
  { 1748, 28, 40, 33, 1, -40 },
  { 1888, 27, 41, 33, 5, -40 },
  { 2027, 25, 41, 33, 3, -40 },
  { 2156, 25, 40, 33, 7, -40 },
  { 2281, 28, 41, 33, 3, -40 },
  { 2425, 25, 40, 33, 5, -40 },
  { 2550, 9, 28, 33, 14, -28 },
  { 2582, 12, 36, 33, 11, -28 },
  { 2636, 25, 22, 33, 4, -29 },
  { 2705, 26, 14, 33, 4, -25 },
  { 2751, 25, 22, 33, 3, -29 },
  { 2820, 21, 40, 33, 9, -40 },
  { 2925, 32, 40, 33, 1, -40 },
  { 3085, 28, 40, 33, 0, -40 },
  { 3225, 27, 40, 33, 3, -40 },
  { 3360, 28, 41, 33, 3, -40 },
  { 3504, 29, 40, 33, 2, -40 },
  { 3649, 29, 40, 33, 3, -40 },
  { 3794, 29, 40, 33, 3, -40 },
  { 3939, 28, 41, 33, 3, -40 },
  { 4083, 30, 40, 33, 2, -40 },
  { 4233, 28, 40, 33, 3, -40 },
  { 4373, 29, 41, 33, 2, -40 },
  { 4522, 31, 40, 33, 3, -40 },
  { 4677, 23, 40, 33, 3, -40 },
  { 4792, 31, 40, 33, 2, -40 },
  { 4947, 30, 40, 33, 2, -40 },
  { 5097, 27, 41, 33, 3, -40 },
  { 5236, 29, 40, 33, 3, -40 },
  { 5381, 28, 47, 33, 3, -40 },
  { 5546, 28, 40, 33, 3, -40 },
  { 5686, 28, 41, 33, 3, -40 },
  { 5830, 28, 40, 33, 6, -40 },
  { 5970, 29, 41, 33, 3, -40 },
  { 6119, 28, 40, 33, 6, -40 },
  { 6259, 29, 40, 33, 6, -40 },
  { 6404, 33, 40, 33, 1, -40 },
  { 6569, 28, 40, 33, 6, -40 },
  { 6709, 30, 40, 33, 1, -40 },
  { 6859, 17, 55, 33, 8, -46 },
  { 6976, 11, 43, 33, 11, -40 },
  { 7036, 17, 55, 33, 8, -46 },
  { 7153, 19, 22, 33, 7, -40 },
  { 7206, 23, 2, 33, 2, 0 },
  { 7212, 7, 7, 33, 16, -41 },
  { 7219, 25, 31, 33, 3, -30 },
  { 7316, 25, 43, 33, 3, -42 },
  { 7451, 25, 31, 33, 4, -30 },
  { 7548, 27, 43, 33, 4, -42 },
  { 7694, 26, 31, 33, 3, -30 },
  { 7795, 27, 43, 33, 7, -43 },
  { 7941, 27, 42, 33, 2, -30 },
  { 8083, 25, 42, 33, 3, -42 },
  { 8215, 23, 40, 33, 3, -40 },
  { 8330, 26, 52, 33, 0, -40 },
  { 8499, 27, 42, 33, 3, -42 },
  { 8641, 23, 42, 33, 3, -42 },
  { 8762, 33, 30, 33, -1, -30 },
  { 8886, 25, 30, 33, 3, -30 },
  { 8980, 26, 31, 33, 3, -30 },
  { 9081, 27, 41, 33, 1, -30 },
  { 9220, 25, 41, 33, 4, -30 },
  { 9349, 24, 30, 33, 7, -30 },
  { 9439, 25, 31, 33, 4, -30 },
  { 9536, 21, 38, 33, 7, -37 },
  { 9636, 26, 31, 33, 4, -30 },
  { 9737, 27, 30, 33, 5, -30 },
  { 9839, 29, 30, 33, 4, -30 },
  { 9948, 30, 30, 33, 1, -30 },
  { 10061, 34, 42, 33, -1, -30 },
  { 10240, 29, 30, 33, 1, -30 },
  { 10349, 21, 56, 33, 9, -44 },
  { 10496, 10, 48, 33, 11, -40 },
  { 10556, 21, 56, 33, 5, -44 },
  { 10703, 30, 9, 33, 1, -21 },
};

const GFXfont RobotoMono_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC56PT7B_H_
