#ifndef _ROBOTOMONO_EXTRALIGHTITALIC42PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x18, 0x00, 0x21, 0xB0, 0xD8, 0x4C, 0x26, 0x32, 0x19, 0x0D,
  0x84, 0xC2, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x1F, 0xFF, 0xFF, 0x00, 0x40, 0x60,
  0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x06, 0x02, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0C, 0x04, 0x00,
  0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0x3C,
  0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0x60, 0x03, 0x03, 0x00, 0x60, 0x3C, 0x3C, 0x00, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x03, 0x18,
  0x00, 0x60, 0x80, 0x04, 0x0C, 0x04, 0xC0, 0xC0, 0xCC, 0x0C, 0x08, 0x80,
  0xC1, 0x88, 0x0C, 0x30, 0x80, 0x86, 0x08, 0x18, 0x40, 0xC1, 0x0C, 0x0C,
  0x71, 0x80, 0x7E, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x7C, 0x03, 0x0C, 0x60, 0x21, 0x82, 0x06, 0x30,
  0x30, 0xC3, 0x03, 0x08, 0x20, 0x31, 0x82, 0x03, 0x30, 0x20, 0x26, 0x06,
  0x02, 0x60, 0x20, 0x60, 0x02, 0x0C, 0x00, 0x31, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0x38, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10,
  0x30, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0xCC, 0x0C,
  0x04, 0xC0, 0x30, 0x66, 0x00, 0xC3, 0x60, 0x06, 0x33, 0x00, 0x19, 0x98,
  0x00, 0xD8, 0xC0, 0x03, 0xC6, 0x00, 0x0C, 0x18, 0x01, 0xE0, 0xE0, 0x1D,
  0x83, 0xC3, 0x86, 0x07, 0xF0, 0x38, 0x2D, 0xB6, 0x96, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x07, 0x82, 0x0F, 0xF1, 0x3E, 0x1F,
  0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xC8, 0x00, 0xC6, 0x00, 0xC1, 0x80,
  0xE0, 0xC0, 0xE0, 0x30, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x18, 0xC6, 0x33, 0x18, 0x8C, 0xC2, 0x00,
  0xFF, 0xFE, 0x6F, 0x60, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1E, 0x38, 0x03, 0x00, 0xC0, 0x60,
  0x0C, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x21, 0x00, 0x02, 0x30,
  0x00, 0x63, 0x00, 0x1E, 0x20, 0x03, 0x26, 0x00, 0x62, 0x60, 0x0C, 0x66,
  0x01, 0x86, 0x60, 0x70, 0x64, 0x0C, 0x06, 0xC1, 0x80, 0x4C, 0x30, 0x04,
  0xC6, 0x00, 0xCC, 0xC0, 0x0C, 0xF8, 0x00, 0xCE, 0x00, 0x08, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x60, 0x06, 0x03, 0x01,
  0xC0, 0x3C, 0x78, 0x00, 0xFE, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0x37,
  0x86, 0x80, 0xE0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00,
  0x00, 0x7F, 0x00, 0x1E, 0x38, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00,
  0x60, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x1C, 0x03, 0x80, 0x60, 0x70,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x11, 0x80, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x03, 0x00,
  0x70, 0x1C, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x31,
  0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x01,
  0x81, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x08, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x1F, 0x80, 0x37, 0xFC, 0x03, 0xC0, 0x60,
  0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x80, 0x01, 0x88, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x06, 0x01, 0xC0, 0x38,
  0x78, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x08, 0xFF, 0x03, 0x70, 0x38, 0x78,
  0x03, 0x0E, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0x4C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x34, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x03, 0x00, 0xE1,
  0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xCF, 0x00, 0x60, 0x1C,
  0x06, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x08, 0x00, 0xC0,
  0x60, 0x0C, 0x01, 0xC1, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x01,
  0x80, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0xE1, 0xE0, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xE3, 0x80, 0xE0, 0x30, 0x60, 0x06, 0x38, 0x01, 0x8C, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1D, 0x80, 0x0E, 0x60,
  0x07, 0x8C, 0x03, 0x61, 0xC7, 0x98, 0x3F, 0x8C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0E, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87,
  0x86, 0x00, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x3E, 0x70, 0xE0,
  0x33, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0xE0,
  0x18, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x0F,
  0x02, 0x08, 0x1F, 0x82, 0x18, 0x30, 0xC2, 0x10, 0x60, 0x82, 0x30, 0xC0,
  0x82, 0x20, 0x80, 0x82, 0x61, 0x81, 0x82, 0x61, 0x01, 0x02, 0x43, 0x01,
  0x06, 0x43, 0x03, 0x06, 0xC2, 0x03, 0x04, 0xC2, 0x02, 0x04, 0xC2, 0x06,
  0x0C, 0x82, 0x06, 0x08, 0x82, 0x0E, 0x18, 0xC2, 0x1A, 0x10, 0xC3, 0xF3,
  0x70, 0xC1, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x02, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x58, 0x00,
  0x06, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x86,
  0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x20, 0x02,
  0x01, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18,
  0x0C, 0x00, 0xC0, 0x7F, 0xFE, 0x06, 0x00, 0x10, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x26,
  0x00, 0x01, 0x60, 0x00, 0x0C, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0x00,
  0x38, 0x08, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0x1C, 0x0C, 0x03, 0xC0, 0x7F, 0xF8, 0x06, 0x01, 0xF0, 0x30,
  0x01, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x02,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC2, 0x00,
  0x06, 0x10, 0x00, 0xE1, 0x80, 0x0E, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x1E, 0x38, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00,
  0x61, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x0C, 0x80, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x38, 0x38,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0x00, 0x70, 0x18,
  0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x11,
  0x80, 0x01, 0x88, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x03, 0x08, 0x00, 0x18, 0x40, 0x01, 0x86, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x80, 0x38, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xCE, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x1F, 0xF2, 0x00, 0xFF, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x4C, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x61, 0x00, 0x02, 0x0C, 0x00, 0x30, 0x30, 0x07, 0x00, 0xE1, 0xF0,
  0x03, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x20, 0x00, 0x30, 0x40, 0x00, 0x41, 0x80, 0x00, 0x83, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x20, 0xC0,
  0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x03, 0x07, 0xFF, 0xFE, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x02, 0x0C,
  0x00, 0x04, 0x18, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x42, 0x00,
  0x06, 0x10, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x38, 0x01, 0x80,
  0xC0, 0x38, 0x03, 0x87, 0x80, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x04, 0x00, 0x30, 0x04, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x08,
  0x0C, 0x00, 0x08, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x19,
  0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x17, 0x60, 0x00, 0x3E, 0x30, 0x00, 0x3C,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x20,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x58, 0x01,
  0x60, 0xB0, 0x06, 0xC3, 0x60, 0x19, 0x06, 0x40, 0x32, 0x0C, 0x80, 0xCC,
  0x19, 0x81, 0x98, 0x23, 0x06, 0x30, 0x46, 0x0C, 0x61, 0x84, 0x30, 0x83,
  0x08, 0x43, 0x06, 0x19, 0x86, 0x0C, 0x36, 0x0C, 0x10, 0x6C, 0x18, 0x20,
  0xF0, 0x20, 0xC0, 0xE0, 0x41, 0x81, 0x81, 0x83, 0x03, 0x03, 0x06, 0x00,
  0x06, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x60, 0x00, 0x20, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x58, 0x00, 0x41, 0xB0, 0x01, 0x83, 0x20, 0x03, 0x06, 0x60, 0x06,
  0x0C, 0xC0, 0x0C, 0x18, 0xC0, 0x18, 0x21, 0x80, 0x20, 0xC1, 0x00, 0xC1,
  0x83, 0x01, 0x83, 0x06, 0x03, 0x06, 0x04, 0x06, 0x0C, 0x0C, 0x08, 0x10,
  0x18, 0x10, 0x60, 0x10, 0x60, 0xC0, 0x30, 0xC1, 0x80, 0x61, 0x83, 0x00,
  0x63, 0x04, 0x00, 0xC4, 0x08, 0x00, 0x88, 0x30, 0x01, 0xB0, 0x60, 0x03,
  0x60, 0xC0, 0x02, 0xC1, 0x80, 0x07, 0x82, 0x00, 0x0E, 0x04, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x1E, 0x78, 0x03, 0x01, 0xC0,
  0x60, 0x0C, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x23, 0x00, 0x03,
  0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00,
  0x06, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x03,
  0x01, 0xC0, 0x3C, 0x78, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30,
  0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x0E,
  0x06, 0x00, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x9E, 0x00,
  0xE0, 0x18, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x60, 0x00,
  0x63, 0x00, 0x03, 0x30, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0,
  0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0x88, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x70, 0x0C, 0x01, 0xE3, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0x80, 0x38, 0x08, 0x00,
  0x60, 0x40, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x07, 0x02, 0x00, 0xE0, 0x1F, 0xFE, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x10, 0x03, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x10, 0x00,
  0x60, 0x80, 0x01, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x80,
  0x0F, 0x8F, 0x00, 0xE0, 0x1C, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x20, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x01, 0xE1,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x31, 0x00, 0x01,
  0x18, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00,
  0x01, 0x88, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x18, 0x01, 0x80, 0xE0, 0x38,
  0x03, 0x87, 0x80, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x03, 0x01, 0x80, 0x30, 0x10,
  0x03, 0x03, 0x00, 0x10, 0x30, 0x01, 0x06, 0x00, 0x18, 0x60, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0xB0, 0x00, 0x0B,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x0D,
  0x00, 0xC0, 0x34, 0x03, 0x00, 0x90, 0x1C, 0x06, 0x40, 0x70, 0x1B, 0x01,
  0x40, 0x6C, 0x0D, 0x01, 0x30, 0x34, 0x0C, 0xC0, 0x90, 0x33, 0x06, 0x40,
  0x8C, 0x19, 0x06, 0x30, 0x46, 0x18, 0xC3, 0x18, 0x43, 0x0C, 0x63, 0x0C,
  0x21, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x18, 0x83, 0x10, 0x66, 0x0C, 0xC1,
  0x98, 0x33, 0x06, 0x40, 0xC8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xA0,
  0x34, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x01, 0x81,
  0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0,
  0x00, 0x66, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x30, 0x03, 0x03,
  0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x00, 0x81, 0x80,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x6C, 0x00, 0x07, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x1F,
  0xC0, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0x03, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x05, 0x80, 0x1B, 0x00, 0x62, 0x00, 0xC4, 0x03, 0x0C, 0x06,
  0x18, 0x18, 0x30, 0x20, 0x20, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03,
  0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE3, 0x0C, 0x61, 0x84, 0x00,
  0x38, 0x00, 0x3F, 0xE0, 0x0E, 0x07, 0x07, 0x00, 0x60, 0xC0, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0xFF, 0x03, 0xFF, 0xE1, 0xE0, 0x0C, 0x70, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x06, 0x40, 0x00, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x03, 0xC6, 0x00,
  0xD8, 0x70, 0xF3, 0x07, 0xF8, 0x60, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x23, 0xFC, 0x04, 0xE1, 0xC1, 0xB0,
  0x0C, 0x38, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x62, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00,
  0x19, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00,
  0xC7, 0x00, 0x30, 0xB0, 0x1C, 0x33, 0x8F, 0x06, 0x3F, 0xC0, 0x00, 0x30,
  0x00, 0x7F, 0x80, 0x70, 0x30, 0x38, 0x06, 0x18, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0xB0, 0x00, 0x44, 0x00, 0x31, 0x80, 0x18, 0x30, 0x0E, 0x07, 0x0E, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x03, 0x03, 0x00, 0xFF, 0x18, 0x0E, 0x0C, 0xC0, 0xC0, 0x34,
  0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x10, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x70, 0x38, 0x0F, 0x80, 0xF1, 0xC8, 0x03,
  0xFC, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1E, 0x0C, 0x07, 0x00, 0xC1,
  0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xEC, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x83, 0x00, 0x60, 0x38, 0x38, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0xE3, 0x03, 0x83, 0x30, 0x60, 0x1B, 0x0C, 0x00, 0xE1, 0x80, 0x06,
  0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00, 0x04, 0x60, 0x00,
  0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x08, 0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x38, 0x38,
  0x0F, 0x81, 0xE3, 0x90, 0x0F, 0xF1, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x08, 0x00, 0xC0, 0xC0, 0x1C, 0x06, 0x03, 0x80,
  0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x80, 0x21, 0xFE, 0x0C, 0xE0, 0xE1, 0xB0, 0x0C,
  0x3C, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x88, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0xFF, 0x80, 0x20, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x01, 0x18, 0x00, 0xE1, 0x80, 0x1C, 0x18, 0x03, 0x81, 0x80,
  0x60, 0x10, 0x1C, 0x03, 0x03, 0x80, 0x30, 0x70, 0x03, 0x0C, 0x00, 0x33,
  0x80, 0x03, 0x70, 0x00, 0x2F, 0x80, 0x07, 0x9C, 0x00, 0x70, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x70, 0x04, 0x03, 0x00, 0x40, 0x18, 0x0C, 0x01, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x08, 0x00, 0x38, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x10, 0x1B, 0xF8, 0xFC, 0x1E, 0x1D, 0x86, 0x1C, 0x0F, 0x02, 0x18, 0x0E,
  0x03, 0x18, 0x0C, 0x03, 0x30, 0x0C, 0x02, 0x30, 0x0C, 0x02, 0x30, 0x08,
  0x06, 0x30, 0x08, 0x06, 0x20, 0x18, 0x06, 0x20, 0x18, 0x06, 0x60, 0x18,
  0x04, 0x60, 0x18, 0x04, 0x60, 0x10, 0x0C, 0x60, 0x10, 0x0C, 0x40, 0x30,
  0x0C, 0x40, 0x30, 0x0C, 0xC0, 0x30, 0x08, 0xC0, 0x30, 0x08, 0xC0, 0x20,
  0x18, 0xC0, 0x20, 0x18, 0x80, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x0F, 0xF0,
  0x67, 0x07, 0x0D, 0x80, 0x61, 0xE0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x32,
  0x00, 0x04, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x03, 0x83, 0x80, 0x60, 0x0C,
  0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x23, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x01, 0x83, 0x00, 0x30, 0x30, 0x06, 0x01, 0xC1, 0xC0, 0x0F, 0xF0, 0x00,
  0x02, 0x0C, 0x00, 0x47, 0xF8, 0x04, 0xC1, 0xC0, 0xF8, 0x06, 0x0E, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0xC3,
  0x80, 0x18, 0x68, 0x07, 0x06, 0xE1, 0xE0, 0x63, 0xF8, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0x8C, 0x1C, 0x19, 0x86, 0x01, 0xA1, 0x80, 0x1C, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x03, 0x87, 0x01, 0xF0, 0x78, 0xE4,
  0x07, 0xF8, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x03, 0x0F, 0xF0, 0xCF, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x3C, 0x0E, 0x0E,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x01, 0x86, 0x00, 0x70, 0x70, 0x3C, 0x07, 0xFE, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0xFF,
  0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x07, 0x04, 0x03, 0xF8, 0x18, 0x00, 0x62, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x04, 0x60, 0x01, 0x88, 0x00, 0x31,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC4,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x18,
  0x00, 0x61, 0x80, 0x1C, 0x30, 0x0D, 0x83, 0x87, 0x30, 0x3F, 0xC4, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01,
  0x86, 0x00, 0x10, 0x20, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0xC0, 0x10, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x08,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x05, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x2C, 0x07, 0x01, 0xB0, 0x14, 0x06, 0xC0, 0xD0, 0x13, 0x03, 0x40, 0xCC,
  0x09, 0x03, 0x30, 0x64, 0x18, 0xC1, 0x10, 0x61, 0x0C, 0x41, 0x04, 0x31,
  0x8C, 0x10, 0x86, 0x30, 0x46, 0x18, 0x81, 0x10, 0x66, 0x04, 0xC1, 0x90,
  0x12, 0x06, 0xC0, 0x58, 0x1B, 0x01, 0x60, 0x28, 0x05, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x60, 0x60, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x06,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x18,
  0x60, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x02, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83,
  0x04, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x82,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0x80, 0x09, 0xC1, 0x80, 0x33, 0x01,
  0x80, 0x6C, 0x01, 0xC1, 0x98, 0x01, 0xFE, 0x10, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoMono_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 30, 25, 9, -30 },
  { 28, 9, 9, 25, 10, -32 },
  { 39, 24, 30, 25, 1, -30 },
  { 129, 20, 38, 25, 3, -34 },
  { 224, 20, 30, 25, 3, -30 },
  { 299, 21, 30, 25, 2, -30 },
  { 378, 3, 9, 25, 12, -32 },
  { 382, 13, 43, 25, 7, -33 },
  { 452, 13, 43, 25, 4, -33 },
  { 522, 17, 17, 25, 6, -30 },
  { 559, 21, 22, 25, 2, -25 },
  { 617, 5, 10, 25, 5, -4 },
  { 624, 15, 1, 25, 5, -14 },
  { 626, 4, 3, 25, 9, -3 },
  { 628, 20, 33, 25, 3, -30 },
  { 711, 20, 30, 25, 3, -30 },
  { 786, 11, 30, 25, 6, -30 },
  { 828, 20, 30, 25, 1, -30 },
  { 903, 20, 30, 25, 1, -30 },
  { 978, 21, 30, 25, 1, -30 },
  { 1057, 20, 30, 25, 4, -30 },
  { 1132, 19, 30, 25, 2, -30 },
  { 1204, 19, 30, 25, 5, -30 },
  { 1276, 21, 30, 25, 2, -30 },
  { 1355, 18, 30, 25, 4, -30 },
  { 1423, 7, 21, 25, 10, -21 },
  { 1442, 9, 27, 25, 8, -21 },
  { 1473, 19, 17, 25, 3, -22 },
  { 1514, 19, 10, 25, 3, -19 },
  { 1538, 19, 17, 25, 2, -22 },
  { 1579, 15, 30, 25, 7, -30 },
  { 1636, 24, 30, 25, 1, -30 },
  { 1726, 21, 30, 25, 0, -30 },
  { 1805, 21, 30, 25, 2, -30 },
  { 1884, 20, 30, 25, 3, -30 },
  { 1959, 21, 30, 25, 2, -30 },
  { 2038, 22, 30, 25, 2, -30 },
  { 2121, 22, 30, 25, 2, -30 },
  { 2204, 21, 30, 25, 2, -30 },
  { 2283, 23, 30, 25, 1, -30 },
  { 2370, 21, 30, 25, 2, -30 },
  { 2449, 21, 30, 25, 2, -30 },
  { 2528, 24, 30, 25, 2, -30 },
  { 2618, 18, 30, 25, 2, -30 },
  { 2686, 23, 30, 25, 1, -30 },
  { 2773, 23, 30, 25, 1, -30 },
  { 2860, 20, 30, 25, 3, -30 },
  { 2935, 22, 30, 25, 2, -30 },
  { 3018, 21, 35, 25, 2, -30 },
  { 3110, 21, 30, 25, 2, -30 },
  { 3189, 21, 30, 25, 2, -30 },
  { 3268, 21, 30, 25, 5, -30 },
  { 3347, 21, 30, 25, 3, -30 },
  { 3426, 20, 30, 25, 5, -30 },
  { 3501, 22, 30, 25, 4, -30 },
  { 3584, 25, 30, 25, 0, -30 },
  { 3678, 20, 30, 25, 5, -30 },
  { 3753, 22, 30, 25, 1, -30 },
  { 3836, 13, 40, 25, 6, -34 },
  { 3901, 9, 33, 25, 8, -30 },
  { 3939, 13, 40, 25, 6, -34 },
  { 4004, 15, 16, 25, 5, -30 },
  { 4034, 18, 2, 25, 1, 0 },
  { 4039, 5, 6, 25, 12, -31 },
  { 4043, 19, 23, 25, 2, -23 },
  { 4098, 19, 32, 25, 2, -32 },
  { 4174, 18, 23, 25, 3, -23 },
  { 4226, 21, 32, 25, 3, -32 },
  { 4310, 19, 23, 25, 3, -23 },
  { 4365, 21, 32, 25, 5, -32 },
  { 4449, 20, 32, 25, 2, -23 },
  { 4529, 19, 32, 25, 2, -32 },
  { 4605, 18, 30, 25, 2, -30 },
  { 4673, 19, 39, 25, 0, -30 },
  { 4766, 20, 32, 25, 3, -32 },
  { 4846, 18, 32, 25, 2, -32 },
  { 4918, 24, 23, 25, 0, -23 },
  { 4987, 19, 23, 25, 2, -23 },
  { 5042, 20, 23, 25, 2, -23 },
  { 5100, 20, 32, 25, 1, -23 },
  { 5180, 19, 32, 25, 3, -23 },
  { 5256, 18, 23, 25, 5, -23 },
  { 5308, 19, 23, 25, 3, -23 },
  { 5363, 16, 28, 25, 5, -28 },
  { 5419, 19, 22, 25, 3, -22 },
  { 5472, 20, 22, 25, 4, -22 },
  { 5527, 22, 22, 25, 3, -22 },
  { 5588, 22, 22, 25, 1, -22 },
  { 5649, 26, 31, 25, -1, -22 },
  { 5750, 21, 22, 25, 1, -22 },
  { 5808, 17, 42, 25, 6, -33 },
  { 5898, 7, 36, 25, 9, -30 },
  { 5930, 16, 42, 25, 4, -33 },
  { 6014, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC42PT7B_H_
