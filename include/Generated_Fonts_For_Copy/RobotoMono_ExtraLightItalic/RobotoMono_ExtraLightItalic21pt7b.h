#ifndef _ROBOTOMONO_EXTRALIGHTITALIC21PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x40, 0x00, 0xC0, 0x59, 0x99, 0x90,
  0x02, 0x10, 0x22, 0x02, 0x20, 0x44, 0x3F, 0xF0, 0x44, 0x08, 0x80, 0x88,
  0x08, 0x81, 0x10, 0xFF, 0xE1, 0x10, 0x22, 0x02, 0x20, 0x42, 0x00, 0x01,
  0x00, 0x80, 0xF8, 0x41, 0x20, 0x48, 0x12, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x02, 0x00, 0xA0, 0x24, 0x09, 0x04, 0x3E, 0x02, 0x00, 0x80, 0x38,
  0x12, 0x08, 0x4E, 0x22, 0x89, 0x22, 0x87, 0x20, 0x10, 0x09, 0x84, 0x91,
  0x24, 0x91, 0x44, 0x51, 0x10, 0x38, 0x0F, 0x04, 0x41, 0x08, 0x44, 0x11,
  0x05, 0x81, 0x80, 0x60, 0x24, 0x51, 0x18, 0x26, 0x06, 0x81, 0xB0, 0xE7,
  0xCC, 0x5A, 0x80, 0x04, 0x21, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x10, 0x20, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x42, 0x08, 0x42,
  0x00, 0x08, 0x04, 0x02, 0x19, 0x73, 0xC0, 0xC0, 0x90, 0x88, 0x82, 0x00,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x24, 0xA8, 0xFF, 0xC0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x0F, 0x84, 0x12, 0x04, 0x81, 0x40, 0xD0, 0x54, 0x25, 0x11, 0x48, 0x64,
  0x1E, 0x0A, 0x02, 0x41, 0x10, 0x43, 0xE0, 0x0C, 0xDC, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81,
  0x00, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0F, 0xF8, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x00, 0x80, 0x20, 0x10, 0x78,
  0x01, 0x00, 0x20, 0x0A, 0x02, 0x81, 0x20, 0x87, 0xC0, 0x00, 0x40, 0x18,
  0x05, 0x01, 0x20, 0x28, 0x09, 0x02, 0x20, 0x84, 0x20, 0x88, 0x11, 0xFF,
  0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xC8, 0x02, 0x00, 0x80, 0x20,
  0x13, 0x07, 0x20, 0x04, 0x00, 0x80, 0x20, 0x0A, 0x04, 0x81, 0x20, 0x87,
  0xC0, 0x03, 0x86, 0x04, 0x04, 0x02, 0x02, 0x71, 0xC4, 0x81, 0x40, 0xC0,
  0x60, 0x30, 0x14, 0x12, 0x08, 0xF8, 0xFF, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x00, 0x0F,
  0x82, 0x08, 0x81, 0x10, 0x12, 0x04, 0x40, 0x84, 0x20, 0xF8, 0x20, 0x88,
  0x12, 0x01, 0x40, 0x28, 0x08, 0x82, 0x0F, 0x80, 0x1E, 0x10, 0x90, 0x28,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x42, 0x9E, 0x80, 0x40, 0x40, 0x60, 0x61,
  0xC0, 0x24, 0x00, 0x00, 0x0B, 0x00, 0x11, 0x00, 0x00, 0x00, 0x06, 0x44,
  0x48, 0x00, 0x83, 0x86, 0x0C, 0x08, 0x03, 0x00, 0x70, 0x06, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC1,
  0xC1, 0x83, 0x80, 0x3E, 0x41, 0x41, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x00, 0x00, 0x00, 0x60, 0x03, 0xC0, 0xC2, 0x10, 0x12, 0x39,
  0x24, 0x94, 0x89, 0x48, 0x94, 0x89, 0x91, 0x19, 0x12, 0x93, 0x24, 0xCC,
  0x40, 0x06, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x40, 0x28, 0x0A, 0x04, 0x81,
  0x20, 0x88, 0x22, 0x10, 0x84, 0x13, 0xFC, 0x81, 0x40, 0x50, 0x18, 0x04,
  0x3F, 0x08, 0x32, 0x04, 0x81, 0x20, 0x48, 0x14, 0x19, 0xFC, 0x40, 0x90,
  0x14, 0x05, 0x02, 0x80, 0xA0, 0x4F, 0xE0, 0x0F, 0x82, 0x08, 0x81, 0x10,
  0x14, 0x02, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x01, 0x40, 0x44,
  0x08, 0x82, 0x0F, 0x80, 0x3F, 0x04, 0x10, 0x81, 0x10, 0x22, 0x02, 0x80,
  0x50, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x01, 0x40, 0x48, 0x11, 0x04, 0x3F,
  0x00, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x03, 0xFC,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x3F, 0xE0, 0x1F, 0xE4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0xFC, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x82, 0x08, 0x81, 0x10,
  0x14, 0x00, 0x80, 0x10, 0x04, 0x00, 0x87, 0xD0, 0x0A, 0x01, 0x40, 0x44,
  0x08, 0x81, 0x0F, 0xC0, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14, 0x04, 0x80,
  0x90, 0x13, 0xFE, 0x40, 0x50, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20,
  0x20, 0x3F, 0xE0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x3F, 0xC0, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x40, 0x48, 0x11, 0x04, 0x1F, 0x00, 0x10, 0x32, 0x04, 0x20, 0x82,
  0x10, 0x22, 0x02, 0x40, 0x48, 0x05, 0x80, 0x64, 0x04, 0x40, 0x42, 0x04,
  0x10, 0x81, 0x08, 0x08, 0x80, 0xC0, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x03, 0xFE, 0x30,
  0x26, 0x0C, 0xC1, 0x98, 0x55, 0x12, 0x92, 0x92, 0x92, 0x52, 0x4C, 0x49,
  0x8A, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x20, 0x26, 0x04, 0xC0,
  0x98, 0x14, 0x84, 0x90, 0x92, 0x12, 0x22, 0x44, 0x48, 0x52, 0x0A, 0x41,
  0x48, 0x19, 0x03, 0x20, 0x60, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40, 0x50,
  0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x41, 0x10, 0x43, 0xE0,
  0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x12, 0x04, 0x7F,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x82, 0x08,
  0x81, 0x20, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x0A, 0x01,
  0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x10, 0x01, 0x00, 0x30, 0x1F, 0x04,
  0x18, 0x81, 0x10, 0x12, 0x04, 0x40, 0x90, 0x12, 0x0C, 0x7E, 0x08, 0x41,
  0x04, 0x20, 0x88, 0x11, 0x01, 0x20, 0x20, 0x0F, 0x82, 0x08, 0x81, 0x10,
  0x12, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0x01, 0x40, 0x28,
  0x08, 0x83, 0x0F, 0x80, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x50, 0x0A, 0x02, 0x40, 0x44, 0x08, 0x82, 0x0F, 0x80, 0x80, 0x68,
  0x09, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x22, 0x04, 0x80,
  0x90, 0x14, 0x02, 0x80, 0x60, 0x04, 0x00, 0x84, 0x30, 0x86, 0x31, 0x46,
  0x28, 0xC5, 0x28, 0xA5, 0x24, 0xA4, 0xA4, 0x94, 0xA2, 0x94, 0x61, 0x8C,
  0x21, 0x84, 0x20, 0x80, 0x10, 0x18, 0x81, 0x82, 0x08, 0x10, 0x80, 0x48,
  0x02, 0xC0, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x48, 0x02, 0x40, 0x21, 0x02,
  0x08, 0x20, 0x23, 0x01, 0x00, 0x80, 0x68, 0x09, 0x02, 0x20, 0x82, 0x10,
  0x44, 0x09, 0x00, 0xA0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0xC0, 0x1E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x07, 0x00, 0x88, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x11, 0x11, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x38, 0x08, 0x30, 0x51, 0x22, 0x48, 0x90,
  0xC1, 0xFF, 0xCC, 0x1F, 0x08, 0x24, 0x04, 0x01, 0x00, 0x8F, 0xE4, 0x0A,
  0x02, 0x81, 0xA0, 0xA7, 0xD8, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0B,
  0xC3, 0x08, 0x82, 0x40, 0x50, 0x14, 0x05, 0x02, 0x40, 0xA0, 0x4C, 0x12,
  0xF8, 0x1F, 0x08, 0x22, 0x05, 0x01, 0x40, 0x10, 0x08, 0x02, 0x00, 0x40,
  0x90, 0x43, 0xE0, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x3E, 0x88,
  0x31, 0x06, 0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x08, 0x82, 0x10, 0xC1,
  0xE8, 0x1F, 0x08, 0x22, 0x05, 0x01, 0x7F, 0xE0, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x63, 0xE0, 0x07, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x1F,
  0x48, 0x32, 0x0D, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x41, 0x90, 0xC3,
  0xD0, 0x04, 0x01, 0x20, 0x87, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0B, 0xE3, 0x09, 0x81, 0x40, 0x50, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x04, 0x03, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x43, 0xFE, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x0F, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x0F, 0x80, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x32, 0x10, 0x88, 0x24, 0x16, 0x06, 0x81, 0x10, 0x44, 0x10,
  0x88, 0x12, 0x06, 0x1F, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x21, 0xFF, 0x3E, 0xE6, 0x31,
  0x42, 0x14, 0x21, 0x42, 0x14, 0x42, 0x84, 0x28, 0x42, 0x84, 0x28, 0x42,
  0x84, 0x40, 0x2F, 0x94, 0x26, 0x05, 0x01, 0x40, 0x90, 0x24, 0x0A, 0x02,
  0x80, 0xA0, 0x28, 0x10, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x17, 0x83, 0x08, 0xC1, 0x10, 0x12,
  0x02, 0x40, 0x88, 0x11, 0x02, 0x40, 0x8C, 0x11, 0x7C, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x00, 0x1F, 0x48, 0x32, 0x05, 0x02, 0x40, 0xA0, 0x28, 0x0A,
  0x02, 0x40, 0x90, 0xC3, 0xD0, 0x04, 0x01, 0x00, 0x40, 0x30, 0x4F, 0xA8,
  0x18, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F,
  0x88, 0x12, 0x04, 0x80, 0x30, 0x03, 0x80, 0x18, 0x02, 0x80, 0x90, 0x63,
  0xE0, 0x10, 0x10, 0x10, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x3C, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x05, 0x02,
  0x83, 0x42, 0x9E, 0x80, 0x80, 0x60, 0x24, 0x11, 0x04, 0x42, 0x10, 0x82,
  0x40, 0x90, 0x28, 0x0C, 0x01, 0x00, 0x88, 0x71, 0x0A, 0x51, 0x4A, 0x49,
  0x49, 0x4A, 0x29, 0x46, 0x28, 0xC6, 0x10, 0xC2, 0x10, 0x00, 0x30, 0x31,
  0x04, 0x08, 0x80, 0x50, 0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x10, 0x82,
  0x08, 0xC0, 0x40, 0x20, 0x12, 0x02, 0x20, 0x21, 0x04, 0x10, 0x81, 0x08,
  0x11, 0x00, 0x90, 0x0A, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0xE0, 0x00, 0x3F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFF, 0x00, 0x03, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x60, 0xC0, 0x20, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x08, 0x11, 0x12, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x18,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0x06, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x38, 0x14, 0x41, 0x43, 0x68,
  0x08,
};

const GFXglyph RobotoMono_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 4, 5, 12, 5, -16 },
  { 12, 12, 15, 12, 0, -15 },
  { 35, 10, 19, 12, 1, -17 },
  { 59, 10, 15, 12, 1, -15 },
  { 78, 10, 15, 12, 1, -15 },
  { 97, 2, 5, 12, 6, -16 },
  { 99, 6, 22, 12, 4, -17 },
  { 116, 6, 22, 12, 2, -17 },
  { 133, 9, 9, 12, 3, -15 },
  { 144, 10, 11, 12, 1, -12 },
  { 158, 3, 5, 12, 2, -2 },
  { 160, 8, 1, 12, 2, -7 },
  { 161, 1, 2, 12, 5, -2 },
  { 162, 9, 16, 12, 2, -15 },
  { 180, 10, 15, 12, 1, -15 },
  { 199, 6, 15, 12, 3, -15 },
  { 211, 10, 15, 12, 0, -15 },
  { 230, 10, 15, 12, 1, -15 },
  { 249, 11, 15, 12, 0, -15 },
  { 270, 10, 15, 12, 2, -15 },
  { 289, 9, 15, 12, 1, -15 },
  { 306, 9, 15, 12, 3, -15 },
  { 323, 11, 15, 12, 1, -15 },
  { 344, 9, 15, 12, 2, -15 },
  { 361, 3, 11, 12, 5, -11 },
  { 366, 4, 14, 12, 4, -11 },
  { 373, 9, 8, 12, 2, -11 },
  { 382, 10, 5, 12, 1, -9 },
  { 389, 10, 8, 12, 1, -11 },
  { 399, 8, 15, 12, 3, -15 },
  { 414, 12, 15, 12, 0, -15 },
  { 437, 10, 15, 12, 0, -15 },
  { 456, 10, 15, 12, 1, -15 },
  { 475, 11, 15, 12, 1, -15 },
  { 496, 11, 15, 12, 1, -15 },
  { 517, 11, 15, 12, 1, -15 },
  { 538, 11, 15, 12, 1, -15 },
  { 559, 11, 15, 12, 1, -15 },
  { 580, 11, 15, 12, 1, -15 },
  { 601, 11, 15, 12, 1, -15 },
  { 622, 11, 15, 12, 1, -15 },
  { 643, 12, 15, 12, 1, -15 },
  { 666, 9, 15, 12, 1, -15 },
  { 683, 11, 15, 12, 1, -15 },
  { 704, 11, 15, 12, 1, -15 },
  { 725, 10, 15, 12, 1, -15 },
  { 744, 11, 15, 12, 1, -15 },
  { 765, 11, 18, 12, 1, -15 },
  { 790, 11, 15, 12, 1, -15 },
  { 811, 11, 15, 12, 1, -15 },
  { 832, 11, 15, 12, 2, -15 },
  { 853, 11, 15, 12, 1, -15 },
  { 874, 11, 15, 12, 2, -15 },
  { 895, 11, 15, 12, 2, -15 },
  { 916, 13, 15, 12, 0, -15 },
  { 941, 11, 15, 12, 2, -15 },
  { 962, 12, 15, 12, 0, -15 },
  { 985, 7, 20, 12, 3, -17 },
  { 1003, 4, 16, 12, 4, -15 },
  { 1011, 6, 20, 12, 3, -17 },
  { 1026, 7, 8, 12, 3, -15 },
  { 1033, 8, 1, 12, 1, 0 },
  { 1034, 3, 2, 12, 6, -15 },
  { 1035, 10, 11, 12, 1, -11 },
  { 1049, 10, 16, 12, 1, -16 },
  { 1069, 10, 11, 12, 1, -11 },
  { 1083, 11, 16, 12, 1, -16 },
  { 1105, 10, 11, 12, 1, -11 },
  { 1119, 10, 16, 12, 3, -16 },
  { 1139, 10, 15, 12, 1, -11 },
  { 1158, 10, 16, 12, 1, -16 },
  { 1178, 9, 15, 12, 1, -15 },
  { 1195, 10, 19, 12, 0, -15 },
  { 1219, 10, 16, 12, 1, -16 },
  { 1239, 9, 16, 12, 1, -16 },
  { 1257, 12, 11, 12, 0, -11 },
  { 1274, 10, 11, 12, 1, -11 },
  { 1288, 10, 11, 12, 1, -11 },
  { 1302, 11, 15, 12, 0, -11 },
  { 1323, 10, 15, 12, 1, -11 },
  { 1342, 9, 11, 12, 3, -11 },
  { 1355, 10, 11, 12, 1, -11 },
  { 1369, 8, 14, 12, 3, -14 },
  { 1383, 9, 11, 12, 2, -11 },
  { 1396, 10, 11, 12, 2, -11 },
  { 1410, 11, 11, 12, 2, -11 },
  { 1426, 12, 11, 12, 0, -11 },
  { 1443, 12, 15, 12, 0, -11 },
  { 1466, 11, 11, 12, 0, -11 },
  { 1482, 8, 20, 12, 3, -16 },
  { 1502, 4, 18, 12, 4, -15 },
  { 1511, 8, 20, 12, 2, -16 },
  { 1531, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC21PT7B_H_
