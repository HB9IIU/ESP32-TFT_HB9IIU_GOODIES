#ifndef _ROBOTOMONO_EXTRALIGHTITALIC20PT7B_H_
#define _ROBOTOMONO_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x48, 0x01, 0x00, 0x99, 0x9A, 0x02, 0x20, 0x22,
  0x04, 0x40, 0x44, 0x3F, 0xF0, 0x88, 0x08, 0x81, 0x10, 0x11, 0x0F, 0xFC,
  0x22, 0x02, 0x20, 0x22, 0x04, 0x40, 0x02, 0x00, 0x80, 0xD8, 0x42, 0x20,
  0x48, 0x12, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x80, 0xA0, 0x24,
  0x10, 0xF8, 0x08, 0x02, 0x00, 0x78, 0x12, 0x28, 0x8A, 0x24, 0x8A, 0x1C,
  0x80, 0x40, 0x20, 0x13, 0x85, 0x12, 0x45, 0x11, 0x44, 0x81, 0xE0, 0x0F,
  0x04, 0x42, 0x10, 0x84, 0x12, 0x07, 0x01, 0x80, 0xA0, 0x44, 0x61, 0x28,
  0x2A, 0x04, 0x83, 0x1F, 0x20, 0xF0, 0x02, 0x08, 0x20, 0x82, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x01, 0x01,
  0x00, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x84, 0x20, 0x80, 0x08, 0x08, 0x89, 0x7E, 0x10, 0x28, 0x44,
  0x84, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x25, 0x28, 0xFE, 0xC0, 0x01, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x00,
  0x0F, 0x84, 0x22, 0x05, 0x01, 0x41, 0xD0, 0x94, 0x45, 0x22, 0x90, 0xB8,
  0x28, 0x09, 0x04, 0x42, 0x0F, 0x00, 0x1B, 0x62, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0x1F, 0x10, 0x50,
  0x28, 0x10, 0x08, 0x08, 0x78, 0x04, 0x01, 0x00, 0xA0, 0x50, 0x28, 0x23,
  0xE0, 0x00, 0xC0, 0x60, 0x28, 0x0A, 0x04, 0x82, 0x21, 0x08, 0x84, 0x21,
  0x1F, 0xF8, 0x10, 0x04, 0x01, 0x00, 0x80, 0x3F, 0xC8, 0x02, 0x00, 0x80,
  0x40, 0x1F, 0x84, 0x20, 0x04, 0x01, 0x00, 0x48, 0x12, 0x08, 0x82, 0x1F,
  0x00, 0x07, 0x84, 0x04, 0x04, 0x04, 0x02, 0xF9, 0x84, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x24, 0x21, 0xE0, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00, 0x0F, 0x84, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x21, 0xF0, 0x84, 0x40, 0xA0, 0x28, 0x0A, 0x02,
  0x41, 0x0F, 0x80, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0C, 0x0A, 0x05, 0x06,
  0x7D, 0x01, 0x00, 0x80, 0x80, 0x87, 0x80, 0x60, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x00, 0x44, 0x48, 0x80, 0x00, 0x81, 0x83, 0x0E, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x38, 0x60, 0xC0, 0x80, 0x00, 0x3E,
  0x42, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x07, 0xC0, 0x82, 0x11, 0x12, 0x69, 0x48, 0x94, 0x89, 0x51, 0x19,
  0x12, 0x91, 0x29, 0x32, 0x9D, 0xC4, 0x00, 0x40, 0x03, 0xF0, 0x01, 0x00,
  0xC0, 0x30, 0x14, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0x8F, 0xE2, 0x09,
  0x01, 0x40, 0x60, 0x10, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x40, 0x90, 0x67,
  0xE1, 0x04, 0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x80, 0x0F, 0x84,
  0x12, 0x05, 0x01, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0A,
  0x04, 0x43, 0x0F, 0x00, 0x3F, 0x08, 0x22, 0x05, 0x01, 0x40, 0x50, 0x14,
  0x05, 0x01, 0x40, 0x60, 0x28, 0x0A, 0x04, 0x82, 0x3F, 0x00, 0x3F, 0xC8,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x07, 0xF1, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x3F, 0xC0, 0x3F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x1F, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00,
  0x0F, 0x8C, 0x12, 0x05, 0x01, 0x40, 0x10, 0x08, 0x02, 0x1E, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x41, 0x8F, 0x80, 0x20, 0x64, 0x09, 0x01, 0x20, 0x24,
  0x04, 0x80, 0x9F, 0xE2, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11,
  0x02, 0x00, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x3F, 0xC0, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x48, 0x12, 0x04, 0x82,
  0x1F, 0x00, 0x20, 0x64, 0x10, 0x84, 0x11, 0x02, 0x40, 0x90, 0x16, 0x03,
  0x40, 0x44, 0x08, 0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xFF,
  0x20, 0x66, 0x18, 0xC3, 0x28, 0xA5, 0x14, 0xA4, 0x92, 0x92, 0x64, 0x4C,
  0x91, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x00, 0x20, 0x64, 0x09, 0x41,
  0x28, 0x24, 0x84, 0x90, 0x92, 0x22, 0x24, 0x84, 0x90, 0x92, 0x0A, 0x41,
  0x48, 0x11, 0x02, 0x00, 0x0F, 0x84, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18,
  0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x1F, 0x84,
  0x08, 0x81, 0x10, 0x12, 0x04, 0x40, 0x90, 0x23, 0xF8, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x00, 0x1F, 0x88, 0x22, 0x05, 0x01, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x3F, 0x88, 0x22, 0x04, 0x81, 0x20, 0x50, 0x24,
  0x19, 0xF8, 0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20, 0x20, 0x1F, 0x88,
  0x12, 0x05, 0x01, 0x20, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x28, 0x0A,
  0x02, 0x41, 0x0F, 0x80, 0xFF, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x00, 0x20, 0x64,
  0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x84, 0x20, 0x78, 0x00, 0x80, 0x60, 0x24, 0x09, 0x04, 0x41,
  0x10, 0x84, 0x21, 0x10, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x00,
  0x84, 0x63, 0x18, 0xC6, 0x32, 0x94, 0xA5, 0x29, 0x4A, 0x94, 0xA5, 0x31,
  0x4C, 0x63, 0x18, 0x86, 0x21, 0x00, 0x10, 0x31, 0x02, 0x08, 0x40, 0x88,
  0x05, 0x00, 0x50, 0x02, 0x00, 0x60, 0x09, 0x00, 0x90, 0x11, 0x02, 0x08,
  0x40, 0x8C, 0x04, 0x80, 0x50, 0x24, 0x11, 0x04, 0x22, 0x09, 0x02, 0x40,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x1F, 0xE0, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0xFF, 0x00, 0x1C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x0E, 0x00, 0x88, 0x84, 0x44, 0x44,
  0x22, 0x22, 0x21, 0x10, 0x1C, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x8E, 0x00, 0x0C, 0x18, 0x50, 0x92, 0x24,
  0x50, 0xC1, 0xFF, 0x94, 0x0E, 0x18, 0xD8, 0x20, 0x10, 0x09, 0xFD, 0x03,
  0x02, 0x81, 0x41, 0x9F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0xE1, 0x89,
  0x82, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x18, 0x16, 0x12, 0xF0, 0x0E, 0x08,
  0x88, 0x28, 0x14, 0x04, 0x02, 0x01, 0x00, 0x41, 0x20, 0x8F, 0x80, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x0E, 0x4C, 0x62, 0x09, 0x02, 0x40, 0xA0, 0x28,
  0x12, 0x04, 0x81, 0x10, 0xC3, 0xD0, 0x0E, 0x08, 0x88, 0x28, 0x14, 0x0F,
  0xFE, 0x01, 0x00, 0x40, 0x20, 0x8F, 0x80, 0x0F, 0x88, 0x04, 0x02, 0x0F,
  0xE1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x0E, 0x98, 0xC8, 0x28, 0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x21, 0x8F,
  0x40, 0x20, 0x24, 0x31, 0xE0, 0x20, 0x10, 0x08, 0x04, 0x02, 0xF2, 0x85,
  0x82, 0x81, 0x40, 0xA0, 0x50, 0x30, 0x18, 0x14, 0x0A, 0x04, 0x02, 0x00,
  0x00, 0x3E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0xFF,
  0x00, 0x80, 0x00, 0x01, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x78, 0x00, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x48, 0x62, 0x21, 0x10, 0x48, 0x1E, 0x04, 0x81, 0x10,
  0x42, 0x20, 0x88, 0x10, 0x1E, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0xFF, 0x5C, 0xCC, 0x65, 0x08, 0xA1,
  0x14, 0x42, 0x88, 0x61, 0x0C, 0x21, 0x84, 0x50, 0x8A, 0x21, 0x00, 0x2F,
  0x28, 0x58, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x40,
  0x0E, 0x18, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21, 0x8F,
  0x00, 0x17, 0x0A, 0x23, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40,
  0x98, 0x45, 0xE1, 0x00, 0x40, 0x20, 0x08, 0x00, 0x0E, 0x98, 0xC8, 0x28,
  0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x21, 0x8F, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x4F, 0x50, 0x60, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0E, 0x18, 0xC8, 0x28, 0x02, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0xA0, 0x8F,
  0x80, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x1E, 0x40, 0xA0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0x82,
  0x43, 0x1E, 0x80, 0x80, 0xC0, 0x60, 0x48, 0x24, 0x22, 0x21, 0x10, 0x50,
  0x28, 0x18, 0x0C, 0x00, 0x84, 0x30, 0x86, 0x11, 0x46, 0x24, 0xC8, 0xA5,
  0x14, 0xA3, 0x18, 0x63, 0x08, 0x41, 0x08, 0x00, 0x20, 0x22, 0x08, 0x42,
  0x04, 0x80, 0x60, 0x08, 0x01, 0x80, 0x48, 0x11, 0x04, 0x13, 0x03, 0x00,
  0x20, 0x12, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x11, 0x01, 0x20,
  0x0A, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0xE0, 0x00, 0x3F,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xFF, 0x00, 0x01, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x20, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x18, 0x12,
  0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x80, 0x20, 0x30, 0x20, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x08, 0x18, 0x40, 0x82, 0x04, 0x08, 0x10, 0x41,
  0x84, 0x00, 0x30, 0x09, 0x85, 0x09, 0xE0, 0xC0,
};

const GFXglyph RobotoMono_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 14, 12, 4, -14 },
  { 7, 4, 4, 12, 5, -15 },
  { 9, 12, 14, 12, 0, -14 },
  { 30, 10, 18, 12, 1, -16 },
  { 53, 10, 14, 12, 1, -14 },
  { 71, 10, 14, 12, 1, -14 },
  { 89, 1, 4, 12, 6, -15 },
  { 90, 7, 21, 12, 3, -16 },
  { 109, 6, 21, 12, 2, -16 },
  { 125, 8, 8, 12, 3, -14 },
  { 133, 10, 11, 12, 1, -12 },
  { 147, 3, 5, 12, 2, -2 },
  { 149, 7, 1, 12, 2, -7 },
  { 150, 2, 1, 12, 4, -1 },
  { 151, 9, 15, 12, 2, -14 },
  { 168, 10, 14, 12, 1, -14 },
  { 186, 5, 14, 12, 3, -14 },
  { 195, 10, 14, 12, 0, -14 },
  { 213, 9, 14, 12, 1, -14 },
  { 229, 10, 14, 12, 0, -14 },
  { 247, 10, 14, 12, 2, -14 },
  { 265, 9, 14, 12, 1, -14 },
  { 281, 9, 14, 12, 2, -14 },
  { 297, 10, 14, 12, 1, -14 },
  { 315, 9, 14, 12, 2, -14 },
  { 331, 3, 10, 12, 5, -10 },
  { 335, 4, 13, 12, 4, -10 },
  { 342, 9, 9, 12, 2, -11 },
  { 353, 10, 5, 12, 1, -9 },
  { 360, 9, 9, 12, 1, -11 },
  { 371, 8, 14, 12, 3, -14 },
  { 385, 12, 14, 12, 0, -14 },
  { 406, 10, 14, 12, 0, -14 },
  { 424, 10, 14, 12, 1, -14 },
  { 442, 10, 14, 12, 1, -14 },
  { 460, 10, 14, 12, 1, -14 },
  { 478, 10, 14, 12, 1, -14 },
  { 496, 11, 14, 12, 1, -14 },
  { 516, 10, 14, 12, 1, -14 },
  { 534, 11, 14, 12, 1, -14 },
  { 554, 10, 14, 12, 1, -14 },
  { 572, 10, 14, 12, 1, -14 },
  { 590, 11, 14, 12, 1, -14 },
  { 610, 8, 14, 12, 1, -14 },
  { 624, 11, 14, 12, 1, -14 },
  { 644, 11, 14, 12, 1, -14 },
  { 664, 10, 14, 12, 1, -14 },
  { 682, 11, 14, 12, 1, -14 },
  { 702, 10, 17, 12, 1, -14 },
  { 724, 10, 14, 12, 1, -14 },
  { 742, 10, 14, 12, 1, -14 },
  { 760, 10, 14, 12, 2, -14 },
  { 778, 11, 14, 12, 1, -14 },
  { 798, 10, 14, 12, 2, -14 },
  { 816, 10, 14, 12, 2, -14 },
  { 834, 12, 14, 12, 0, -14 },
  { 855, 10, 14, 12, 2, -14 },
  { 873, 11, 14, 12, 0, -14 },
  { 893, 6, 19, 12, 3, -16 },
  { 908, 4, 15, 12, 4, -14 },
  { 916, 6, 19, 12, 3, -16 },
  { 931, 7, 8, 12, 2, -14 },
  { 938, 8, 1, 12, 1, 0 },
  { 939, 2, 3, 12, 6, -15 },
  { 940, 9, 11, 12, 1, -11 },
  { 953, 9, 15, 12, 1, -15 },
  { 970, 9, 11, 12, 1, -11 },
  { 983, 10, 15, 12, 1, -15 },
  { 1002, 9, 11, 12, 1, -11 },
  { 1015, 9, 15, 12, 3, -15 },
  { 1032, 9, 15, 12, 1, -11 },
  { 1049, 9, 15, 12, 1, -15 },
  { 1066, 8, 14, 12, 1, -14 },
  { 1080, 9, 18, 12, 0, -14 },
  { 1101, 10, 15, 12, 1, -15 },
  { 1120, 8, 15, 12, 1, -15 },
  { 1135, 11, 11, 12, 0, -11 },
  { 1151, 9, 11, 12, 1, -11 },
  { 1164, 9, 11, 12, 1, -11 },
  { 1177, 10, 15, 12, 0, -11 },
  { 1196, 9, 15, 12, 1, -11 },
  { 1213, 8, 11, 12, 3, -11 },
  { 1224, 9, 11, 12, 1, -11 },
  { 1237, 8, 13, 12, 2, -13 },
  { 1250, 9, 11, 12, 2, -11 },
  { 1263, 9, 11, 12, 2, -11 },
  { 1276, 11, 11, 12, 1, -11 },
  { 1292, 11, 11, 12, 0, -11 },
  { 1308, 12, 15, 12, 0, -11 },
  { 1331, 11, 11, 12, 0, -11 },
  { 1347, 8, 20, 12, 3, -16 },
  { 1367, 4, 17, 12, 4, -14 },
  { 1376, 7, 20, 12, 2, -16 },
  { 1394, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_EXTRALIGHTITALIC20PT7B_H_
