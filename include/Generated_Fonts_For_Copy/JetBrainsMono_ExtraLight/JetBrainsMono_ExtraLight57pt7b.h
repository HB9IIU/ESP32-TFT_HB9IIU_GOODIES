#ifndef _JETBRAINSMONO_EXTRALIGHT57PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0x83, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF,
  0xFE, 0xF8, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x70, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03,
  0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x03, 0xFB, 0xBF, 0x83, 0xE1, 0xC7, 0xC1, 0xE0, 0xE1, 0xF1, 0xE0, 0x70,
  0x78, 0xF0, 0x38, 0x1E, 0x78, 0x1C, 0x0F, 0x38, 0x0E, 0x07, 0x9C, 0x07,
  0x03, 0xCF, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xF0,
  0x70, 0x00, 0x78, 0x38, 0x00, 0x3E, 0x1C, 0x00, 0x0F, 0xCE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3B, 0xF8, 0x00, 0x1C, 0x7C, 0x00, 0x0E, 0x1F,
  0x00, 0x07, 0x07, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x1F, 0xC0, 0x38, 0x0F, 0xE0, 0x1C, 0x07, 0xF8, 0x0E,
  0x03, 0xFC, 0x07, 0x03, 0xDE, 0x03, 0x81, 0xE7, 0x81, 0xC1, 0xF3, 0xE0,
  0xE1, 0xF0, 0xFC, 0x73, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x1F, 0xF8, 0x00, 0x0E,
  0x3F, 0xFC, 0x00, 0x1E, 0x7C, 0x3C, 0x00, 0x1C, 0x78, 0x1E, 0x00, 0x38,
  0x70, 0x0E, 0x00, 0x78, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0xE0,
  0x70, 0x0E, 0x01, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x0E, 0x00,
  0x70, 0x0E, 0x1C, 0x00, 0x78, 0x1E, 0x3C, 0x00, 0x3F, 0xFC, 0x38, 0x00,
  0x1F, 0xF8, 0x70, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x1E, 0x3F, 0xFC,
  0x00, 0x1C, 0x3C, 0x3E, 0x00, 0x38, 0x78, 0x0E, 0x00, 0x78, 0x70, 0x0E,
  0x00, 0x70, 0x70, 0x0F, 0x00, 0xE0, 0x70, 0x0F, 0x01, 0xE0, 0x70, 0x0F,
  0x01, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x0F, 0x07, 0x00, 0x70, 0x0F,
  0x07, 0x00, 0x70, 0x0F, 0x0E, 0x00, 0x70, 0x0F, 0x1C, 0x00, 0x78, 0x0E,
  0x3C, 0x00, 0x78, 0x1E, 0x38, 0x00, 0x3F, 0xFC, 0x70, 0x00, 0x1F, 0xF8,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x3D,
  0xE0, 0xF8, 0x03, 0xCF, 0x03, 0xC0, 0x1C, 0x70, 0x0F, 0x01, 0xE7, 0x80,
  0x3C, 0x1E, 0x3C, 0x01, 0xF0, 0xF1, 0xE0, 0x07, 0x8F, 0x0F, 0x00, 0x1E,
  0x78, 0x78, 0x00, 0x7F, 0x83, 0xC0, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0xFE, 0x07, 0x80, 0x0F, 0x78, 0x3E, 0x00, 0xF1, 0xE0, 0xF8, 0x1F,
  0x0F, 0x87, 0xFF, 0xF8, 0x3C, 0x1F, 0xFF, 0x00, 0xF0, 0x3F, 0xF0, 0x03,
  0xC0, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x1E,
  0x00, 0xE7, 0xE0, 0x78, 0x0F, 0xBF, 0xE0, 0xE1, 0xFF, 0x7F, 0xE3, 0x1F,
  0xF8, 0x3F, 0xED, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0xF0,
  0x00, 0x7E, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x1E, 0x00, 0x7C, 0x0F,
  0x00, 0x38, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x08, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x80, 0x03,
  0xCF, 0x80, 0x0F, 0x8F, 0xC0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x07,
  0x9E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x79, 0xFF, 0xF0, 0x7B, 0xFF,
  0xF8, 0x7F, 0x81, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x3C, 0x00,
  0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xCF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0x7E,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xE7, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x83, 0xF0, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x1F, 0xFF, 0x78, 0x03, 0xFF, 0xBC, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x07,
  0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x70, 0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x07, 0xFF, 0x7F, 0x00,
  0xFC, 0x77, 0xF0, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x1E, 0x00,
  0x7F, 0x01, 0xC0, 0x07, 0xF0, 0x1C, 0x00, 0x7F, 0x01, 0xC0, 0x07, 0xF0,
  0x1C, 0x00, 0x7F, 0x01, 0xC0, 0x07, 0xF0, 0x1C, 0x00, 0x7F, 0x01, 0xC0,
  0x07, 0xF0, 0x1C, 0x00, 0x7F, 0x01, 0xC0, 0x07, 0xF0, 0x1C, 0x00, 0x7F,
  0x01, 0xC0, 0x07, 0xF0, 0x1E, 0x00, 0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x0F,
  0x01, 0xFF, 0x00, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0x00, 0x3F, 0xE7,
  0xF0, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x03,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF0, 0x03,
  0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0xFC, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x1F, 0x87, 0xE0, 0x0F,
  0x8F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0x00, 0x3F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x9E, 0x00, 0x7E, 0x3C, 0x07, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x1F, 0x87, 0xE0, 0x0F,
  0x8F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x3E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xE7, 0x00, 0x77, 0xE7, 0x00,
  0xE7, 0xE7, 0x00, 0xE7, 0xE3, 0x80, 0xE7, 0xE3, 0x81, 0xC7, 0xE3, 0x81,
  0xC7, 0xE1, 0xC1, 0xC7, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE0, 0xE3,
  0x87, 0xE0, 0xE7, 0x07, 0xF0, 0xE7, 0x07, 0xF0, 0x77, 0x07, 0xF0, 0x7E,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0xE0, 0x01, 0xFB,
  0xC0, 0x07, 0xE7, 0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x78, 0x01, 0xF8, 0xE0,
  0x07, 0xE3, 0xC0, 0x1F, 0x87, 0x00, 0x7E, 0x1C, 0x01, 0xF8, 0x78, 0x07,
  0xE0, 0xE0, 0x1F, 0x83, 0x80, 0x7E, 0x0F, 0x01, 0xF8, 0x1C, 0x07, 0xE0,
  0x78, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0F, 0x07, 0xE0, 0x1C,
  0x1F, 0x80, 0x70, 0x7E, 0x01, 0xE1, 0xF8, 0x03, 0x87, 0xE0, 0x0F, 0x1F,
  0x80, 0x1C, 0x7E, 0x00, 0x71, 0xF8, 0x01, 0xE7, 0xE0, 0x03, 0x9F, 0x80,
  0x0F, 0x7E, 0x00, 0x3D, 0xF8, 0x00, 0x77, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x87,
  0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x80,
  0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0xC7, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xCF, 0x00, 0x1F, 0xC7, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xC1, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x80,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x2B,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xE3, 0xC0,
  0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xF1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3,
  0xE0, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xF0, 0x1F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x38,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xFC,
  0x01, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x3D, 0xC0, 0x3B, 0x00, 0xF7, 0x00,
  0xEC, 0x03, 0xDC, 0x03, 0xB0, 0x0E, 0x70, 0x0E, 0xC0, 0x39, 0xE0, 0x33,
  0x80, 0xE7, 0x80, 0xCE, 0x03, 0x9E, 0x03, 0x38, 0x0E, 0x78, 0x1C, 0xE0,
  0x78, 0xE0, 0x71, 0x81, 0xE3, 0x81, 0xC6, 0x07, 0x8E, 0x07, 0x18, 0x1C,
  0x38, 0x18, 0x70, 0x70, 0xE0, 0x61, 0xC1, 0xC3, 0xC1, 0x87, 0x07, 0x0F,
  0x06, 0x1C, 0x1C, 0x3C, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xC3, 0xC1, 0xC3,
  0x83, 0x0F, 0x07, 0x0C, 0x0C, 0x38, 0x1C, 0x30, 0x38, 0xE0, 0x70, 0xC0,
  0xE3, 0x81, 0xE3, 0x03, 0x8E, 0x07, 0x9C, 0x0E, 0x38, 0x1E, 0x70, 0x38,
  0xE0, 0x79, 0xC0, 0x63, 0x80, 0xE7, 0x01, 0x9E, 0x03, 0x98, 0x06, 0x70,
  0x0E, 0x60, 0x1D, 0xC0, 0x39, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xF8, 0x07, 0x70, 0x0F, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x37, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0xE7, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC1, 0xC0, 0x03,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x0F, 0xFB, 0xFC, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x00, 0x07, 0x7C, 0x00, 0x07,
  0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x37, 0x3E, 0x00, 0x77, 0x1F, 0xFF, 0xE7, 0x0F, 0xFF, 0xC7,
  0x07, 0xFF, 0x87, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC1,
  0xF8, 0x07, 0x8F, 0xFE, 0x0F, 0x3F, 0xFE, 0x1E, 0xF0, 0xFE, 0x3F, 0x80,
  0x3E, 0x7E, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0xC0,
  0x01, 0xEF, 0x80, 0x07, 0xDF, 0x80, 0x1F, 0x3F, 0x80, 0x7E, 0x7B, 0xFF,
  0xF8, 0xF3, 0xFF, 0xE1, 0xE3, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xE0, 0x0F,
  0x8F, 0x80, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xF0, 0x1F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x1F, 0x81, 0xC3, 0xFF, 0x87, 0x1F, 0xFF, 0x9C, 0xFE, 0x1E, 0x77,
  0xE0, 0x1D, 0xDE, 0x00, 0x37, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x7D, 0xF0, 0x03, 0x73, 0xE0, 0x1D, 0xCF, 0xFF, 0xE7, 0x1F,
  0xFF, 0x1C, 0x1F, 0xF8, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xC0, 0x0F, 0x8F, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xE0, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x50, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x71, 0xFF, 0xF9, 0xCF, 0xE1, 0xE7, 0x7E,
  0x01, 0xDD, 0xE0, 0x03, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0xDD, 0xF8, 0x07, 0x73,
  0xFC, 0xF9, 0xC7, 0xFF, 0xE7, 0x07, 0xFE, 0x1C, 0x07, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x07, 0xE0, 0x3C, 0x7F, 0xF0, 0xF3, 0xFF, 0xE3, 0xDE, 0x1F, 0xCF, 0xE0,
  0x0F, 0xBF, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE3,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xC0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE0,
  0x3C, 0x3D, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF, 0xFB, 0xF1, 0xF6, 0x3E, 0xF8,
  0x1D, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F,
  0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01,
  0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF,
  0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0x00, 0x7E, 0x03, 0xC7, 0xFF, 0x0F,
  0x3F, 0xFE, 0x3D, 0xE1, 0xFC, 0xFE, 0x00, 0xFB, 0xF0, 0x01, 0xEF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xE0, 0x1F,
  0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x79, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x01,
  0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBC, 0x3F, 0x8F, 0xE0, 0x0F, 0x9F,
  0x80, 0x0F, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x7B,
  0xE0, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0xF0, 0x1F, 0x9E, 0xFF, 0xFE, 0x3C,
  0xFF, 0xF8, 0x78, 0xFF, 0xC0, 0xF0, 0x18, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xF8, 0x71, 0xFF, 0xF9, 0xCF, 0xE1, 0xE7, 0x7E, 0x01, 0xDD,
  0xE0, 0x01, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x07,
  0xDF, 0x00, 0x37, 0x3E, 0x01, 0xDC, 0xFF, 0xFE, 0x71, 0xFF, 0xF1, 0xC1,
  0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x7E, 0x01, 0xE3, 0xFF, 0x83,
  0xCF, 0xFF, 0x87, 0xBC, 0x3F, 0x8F, 0xE0, 0x0F, 0x9F, 0x80, 0x0F, 0xBE,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C,
  0x00, 0x1E, 0x3E, 0x00, 0x7E, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F,
  0x8F, 0xC0, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x1C,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00,
  0x78, 0x03, 0xB8, 0x03, 0xC0, 0x1D, 0xE0, 0x1F, 0x00, 0xEF, 0x01, 0xF8,
  0x07, 0x78, 0x0E, 0xC0, 0x79, 0xC0, 0x76, 0x03, 0xCE, 0x03, 0x30, 0x1C,
  0x70, 0x19, 0xC0, 0xE3, 0xC0, 0xCE, 0x07, 0x1E, 0x0E, 0x70, 0x38, 0xF0,
  0x71, 0x83, 0xC3, 0x83, 0x0C, 0x1E, 0x1C, 0x18, 0x60, 0xE0, 0xE0, 0xC3,
  0x87, 0x07, 0x0E, 0x1C, 0x38, 0x3C, 0x70, 0xE1, 0xC1, 0xE3, 0x83, 0x0E,
  0x07, 0x18, 0x18, 0xF0, 0x38, 0xC0, 0xE7, 0x01, 0xC6, 0x07, 0x38, 0x0E,
  0x70, 0x39, 0xC0, 0x7B, 0x81, 0xCE, 0x03, 0xDC, 0x06, 0x70, 0x0E, 0xC0,
  0x37, 0x80, 0x76, 0x01, 0xF8, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xF3, 0xFF, 0x00, 0x3D,
  0xFF, 0xE0, 0x0F, 0x78, 0x7C, 0x03, 0xDC, 0x07, 0x80, 0xFF, 0x01, 0xF0,
  0x3F, 0xC0, 0x3E, 0x1E, 0xF0, 0x07, 0xFF, 0xBC, 0x00, 0xFF, 0xCF, 0x00,
  0x0F, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 7, 42, 34, 14, -42 },
  { 38, 16, 17, 34, 9, -42 },
  { 72, 30, 42, 34, 2, -42 },
  { 230, 25, 58, 34, 5, -50 },
  { 412, 32, 42, 34, 1, -42 },
  { 580, 29, 43, 34, 3, -42 },
  { 736, 4, 17, 34, 15, -42 },
  { 745, 17, 55, 34, 11, -48 },
  { 862, 16, 55, 34, 7, -48 },
  { 972, 30, 29, 34, 2, -35 },
  { 1081, 26, 26, 34, 4, -32 },
  { 1166, 11, 18, 34, 10, -9 },
  { 1191, 18, 4, 34, 8, -21 },
  { 1200, 8, 9, 34, 13, -8 },
  { 1209, 24, 53, 34, 5, -47 },
  { 1368, 24, 43, 34, 5, -42 },
  { 1497, 25, 42, 34, 5, -42 },
  { 1629, 26, 42, 34, 4, -42 },
  { 1766, 23, 43, 34, 5, -42 },
  { 1890, 23, 42, 34, 5, -42 },
  { 2011, 24, 43, 34, 5, -42 },
  { 2140, 26, 43, 34, 4, -42 },
  { 2280, 25, 42, 34, 5, -42 },
  { 2412, 24, 43, 34, 5, -42 },
  { 2541, 26, 42, 34, 4, -42 },
  { 2678, 8, 33, 34, 13, -32 },
  { 2711, 12, 41, 34, 10, -32 },
  { 2773, 24, 29, 34, 5, -33 },
  { 2860, 24, 16, 34, 5, -27 },
  { 2908, 24, 29, 34, 5, -33 },
  { 2995, 19, 42, 34, 9, -42 },
  { 3095, 28, 52, 34, 3, -42 },
  { 3277, 28, 42, 34, 3, -42 },
  { 3424, 24, 42, 34, 6, -42 },
  { 3550, 23, 43, 34, 6, -42 },
  { 3674, 23, 42, 34, 6, -42 },
  { 3795, 23, 42, 34, 6, -42 },
  { 3916, 24, 42, 34, 6, -42 },
  { 4042, 23, 43, 34, 6, -42 },
  { 4166, 22, 42, 34, 6, -42 },
  { 4282, 22, 42, 34, 6, -42 },
  { 4398, 25, 43, 34, 3, -42 },
  { 4533, 25, 42, 34, 6, -42 },
  { 4665, 23, 42, 34, 7, -42 },
  { 4786, 24, 42, 34, 5, -42 },
  { 4912, 22, 42, 34, 6, -42 },
  { 5028, 23, 43, 34, 6, -42 },
  { 5152, 25, 42, 34, 6, -42 },
  { 5284, 24, 52, 34, 5, -42 },
  { 5440, 25, 42, 34, 6, -42 },
  { 5572, 25, 43, 34, 5, -42 },
  { 5707, 28, 42, 34, 3, -42 },
  { 5854, 22, 43, 34, 6, -42 },
  { 5973, 28, 42, 34, 3, -42 },
  { 6120, 30, 42, 34, 2, -42 },
  { 6278, 28, 42, 34, 3, -42 },
  { 6425, 29, 42, 34, 3, -42 },
  { 6578, 24, 42, 34, 5, -42 },
  { 6704, 13, 53, 34, 12, -47 },
  { 6791, 24, 53, 34, 5, -47 },
  { 6950, 13, 53, 34, 9, -47 },
  { 7037, 24, 23, 34, 5, -42 },
  { 7106, 28, 4, 34, 3, 1 },
  { 7120, 11, 8, 34, 11, -45 },
  { 7131, 24, 33, 34, 4, -32 },
  { 7230, 23, 43, 34, 6, -42 },
  { 7354, 23, 33, 34, 6, -32 },
  { 7449, 22, 43, 34, 6, -42 },
  { 7568, 23, 33, 34, 6, -32 },
  { 7663, 26, 42, 34, 4, -42 },
  { 7800, 22, 42, 34, 6, -32 },
  { 7916, 22, 42, 34, 6, -42 },
  { 8032, 26, 44, 34, 5, -44 },
  { 8175, 21, 54, 34, 5, -44 },
  { 8317, 25, 42, 34, 6, -42 },
  { 8449, 29, 42, 34, 2, -42 },
  { 8602, 26, 32, 34, 4, -32 },
  { 8706, 22, 32, 34, 6, -32 },
  { 8794, 23, 33, 34, 6, -32 },
  { 8889, 23, 42, 34, 6, -32 },
  { 9010, 22, 42, 34, 6, -32 },
  { 9126, 23, 32, 34, 7, -32 },
  { 9218, 24, 33, 34, 5, -32 },
  { 9317, 25, 40, 34, 4, -40 },
  { 9442, 22, 32, 34, 6, -31 },
  { 9530, 26, 31, 34, 4, -31 },
  { 9631, 29, 31, 34, 3, -31 },
  { 9744, 27, 31, 34, 4, -31 },
  { 9849, 26, 41, 34, 4, -31 },
  { 9983, 23, 31, 34, 6, -31 },
  { 10073, 24, 53, 34, 5, -47 },
  { 10232, 4, 53, 34, 15, -47 },
  { 10259, 24, 53, 34, 5, -47 },
  { 10418, 26, 11, 34, 4, -26 },
};

const GFXfont JetBrainsMono_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_EXTRALIGHT57PT7B_H_
