#ifndef _JETBRAINSMONO_EXTRALIGHT33PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F,
  0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE1, 0xB8, 0x6E, 0x19, 0x86, 0x61,
  0x98, 0x60, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x20, 0x0C, 0x18, 0x02,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x61, 0xFF, 0xFF, 0x06, 0x0C, 0x01, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC1, 0x83,
  0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x06, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x10,
  0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1C, 0xCE, 0x63, 0x1B,
  0x8C, 0x7E, 0x30, 0xF8, 0xC0, 0xE3, 0x01, 0x8C, 0x07, 0xB0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x37, 0x80, 0xC6, 0x03, 0x1C, 0x0C, 0x30, 0x30,
  0xF0, 0xC3, 0xC3, 0x0F, 0x8C, 0x77, 0x33, 0x8F, 0xFC, 0x1F, 0xE0, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xDF, 0xC0,
  0x6C, 0x30, 0x13, 0x04, 0x0C, 0xC1, 0x86, 0x30, 0x63, 0x0C, 0x18, 0xC3,
  0x04, 0x60, 0xE3, 0x30, 0x1F, 0x8C, 0x03, 0xC6, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x63, 0xC0, 0x33, 0xF8, 0x18, 0xC7, 0x06, 0x60, 0xC3, 0x18,
  0x31, 0x86, 0x0C, 0x61, 0x83, 0x30, 0x60, 0xD8, 0x0C, 0x36, 0x03, 0xFB,
  0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xF8, 0x0E, 0x0E, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0E, 0x30, 0x36, 0x1C, 0x3B, 0x07, 0x19, 0x81, 0x98,
  0xC0, 0x6C, 0x60, 0x3C, 0x30, 0x0E, 0x18, 0x07, 0x0C, 0x07, 0xC3, 0x07,
  0x71, 0xFF, 0x18, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x70, 0x7C,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x70, 0x3E, 0x07, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC1, 0xC1, 0xC3, 0xC3, 0x81, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x30, 0x6F, 0xCC, 0xFC, 0xFE, 0xFC, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x16,
  0x00, 0x0C, 0xC0, 0x07, 0x38, 0x03, 0x87, 0x01, 0xC0, 0xC0, 0x70, 0x38,
  0x08, 0x04, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x3C, 0xE3, 0x8E,
  0x71, 0xC6, 0x18, 0xE3, 0x00, 0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xF7, 0x80,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x03,
  0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x30, 0xF1, 0xE3, 0xC7, 0x8F, 0x0C, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0, 0x19, 0xC0, 0xE3, 0xFF, 0x07,
  0xF8, 0x07, 0x80, 0x1F, 0x00, 0x76, 0x03, 0xCC, 0x0E, 0x18, 0x18, 0x30,
  0x20, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFF, 0xC7, 0x03, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x03, 0xB8, 0x18, 0xFF, 0xC3, 0xF8, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x06, 0x70, 0x37, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x7F, 0xF9,
  0xFF, 0xE6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x67, 0xC1, 0xBF, 0xC7, 0x87, 0x9C, 0x0E, 0x60, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xF0, 0x06, 0x60, 0x19, 0xC0,
  0xE3, 0xFF, 0x07, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xCE, 0x07, 0xFF, 0x1E,
  0x1E, 0xE0, 0x3B, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xE0, 0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0x98, 0x06, 0x70, 0x38, 0xE1, 0xC1, 0xFE, 0x01,
  0xE0, 0x1F, 0xE0, 0xE1, 0xC6, 0x03, 0xB8, 0x06, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x1D, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0xC7, 0x03, 0xB8, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xD8, 0x0E, 0x78, 0xF8, 0xFF, 0xC0, 0x63,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x7F, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFB, 0xC0, 0x3C, 0xFD, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x06, 0x1C, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x0F, 0xE1,
  0xF0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x78, 0x1F, 0x01, 0xC0, 0x0F, 0xF0, 0x1E, 0x3C, 0x38, 0x0E, 0x70, 0x06,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFB, 0xC1, 0xFF,
  0xC3, 0x87, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03,
  0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x87, 0xC1, 0xFF, 0xC0, 0xFB,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0F, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x3F, 0xFC,
  0x3F, 0xFC, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06,
  0xE0, 0x06, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0xB8, 0x06, 0xE0,
  0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x1B, 0x80, 0xEE, 0x0F, 0x3F,
  0xF0, 0xFF, 0xF3, 0x80, 0xEE, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xEF, 0xFF, 0x3F, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC7, 0x03, 0x98, 0x06, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0x60, 0x19, 0xC0,
  0xE3, 0xFF, 0x07, 0xF8, 0xFF, 0x83, 0xFF, 0x8E, 0x07, 0x38, 0x0E, 0xE0,
  0x1B, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xB8, 0x06, 0xE0, 0x3B, 0x81, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xEF, 0xFF, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xE0,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x07, 0x60, 0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07,
  0x60, 0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x0F, 0xC0, 0x1B, 0x80,
  0x67, 0x00, 0xCE, 0x03, 0x1C, 0x06, 0x38, 0x18, 0x70, 0x30, 0xE0, 0xC1,
  0xC1, 0x83, 0x86, 0x07, 0xFC, 0x0E, 0x18, 0x1C, 0x38, 0x38, 0x30, 0x70,
  0x70, 0xE0, 0x61, 0xC0, 0xE3, 0x80, 0xC7, 0x01, 0xCE, 0x01, 0x9C, 0x03,
  0xB8, 0x03, 0x70, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x80, 0xFF, 0x03,
  0xFC, 0x0B, 0xD0, 0x6F, 0x61, 0xBD, 0x84, 0xF3, 0x33, 0xCC, 0xCF, 0x32,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xB0, 0x3D, 0x81, 0xEC, 0x0F, 0x30,
  0x79, 0x83, 0xC6, 0x1E, 0x30, 0xF1, 0x87, 0x86, 0x3C, 0x31, 0xE0, 0x8F,
  0x06, 0x78, 0x33, 0xC0, 0xDE, 0x06, 0xF0, 0x37, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xE0,
  0x1B, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x06, 0x60, 0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF0, 0xFF, 0xE1,
  0xFF, 0xF3, 0x80, 0xF7, 0x00, 0x6E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x77, 0x03, 0xCF, 0xFF, 0x1F, 0xF0,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x03,
  0x98, 0x06, 0xE0, 0x1B, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x06, 0x60, 0x19, 0xC0, 0xE3, 0xFF, 0x07,
  0xF8, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0xFF, 0xE1, 0xFF, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xDC, 0x01, 0xB8,
  0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0xE7, 0xFF, 0xCF, 0xFE,
  0x1C, 0x30, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xE1, 0xC0, 0xC3, 0x81, 0xC7,
  0x01, 0x8E, 0x03, 0x9C, 0x03, 0x38, 0x07, 0x70, 0x07, 0x1F, 0xE0, 0xFF,
  0xC7, 0x03, 0x98, 0x06, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1D, 0xC0, 0xE3,
  0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x36,
  0x01, 0xB8, 0x1C, 0xFF, 0xC3, 0xFC, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x38, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xC0, 0xC0, 0xF0, 0x30, 0x6C, 0x1E,
  0x19, 0x87, 0x86, 0x61, 0xE1, 0x98, 0x58, 0x66, 0x12, 0x19, 0x84, 0x86,
  0x61, 0x21, 0x98, 0xC8, 0x66, 0x33, 0x30, 0xCC, 0xCC, 0x33, 0x33, 0x0C,
  0x8C, 0xC3, 0x21, 0x30, 0xC8, 0x4C, 0x36, 0x13, 0x0D, 0x86, 0xC3, 0x61,
  0xA0, 0xD8, 0x78, 0x1C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0xE0, 0x07, 0x60, 0x06, 0x70, 0x0C, 0x30, 0x1C, 0x18, 0x18, 0x1C, 0x38,
  0x0C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x1C, 0x38,
  0x18, 0x18, 0x30, 0x1C, 0x30, 0x0C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x07,
  0xE0, 0x01, 0xB0, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE1, 0x80, 0x60, 0xC0,
  0x70, 0x30, 0x30, 0x18, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x00, 0xCC, 0x00,
  0x6E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03,
  0x30, 0x0C, 0xC0, 0x63, 0x81, 0x86, 0x0E, 0x18, 0x30, 0x30, 0xC0, 0xC6,
  0x01, 0x98, 0x06, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC3, 0x87,
  0x0C, 0x0F, 0xF0, 0x7F, 0xE3, 0x81, 0xCC, 0x03, 0x70, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x1F, 0xFC, 0xF0, 0x37, 0x00, 0xD8, 0x03, 0xE0, 0x0F,
  0x80, 0x36, 0x00, 0xDC, 0x07, 0x3F, 0xFC, 0x7F, 0x30, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xFE, 0x3F, 0x3C, 0xF0,
  0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x1B, 0xC0, 0xEF,
  0xFF, 0x3B, 0xF8, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xE0, 0x1F,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x0F, 0x80, 0x76, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x7F, 0x67, 0xBF,
  0x70, 0x3B, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x36, 0x01, 0xB8, 0x1C, 0xFF,
  0xE3, 0xF3, 0x1F, 0xE0, 0xF3, 0xC7, 0x03, 0x98, 0x06, 0xE0, 0x1B, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x76, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0xFE,
  0x07, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0xD9, 0xEF, 0xDC, 0x0E,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0xE1, 0xE7, 0xFB, 0x07, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x7F, 0xC3, 0xF8, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBF, 0x9F, 0x9E, 0xF0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xCF, 0xF8, 0xFE, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03,
  0xF0, 0x0E, 0xE0, 0x39, 0xC0, 0x63, 0x81, 0x87, 0x07, 0x0E, 0x1C, 0x1C,
  0x30, 0x3F, 0xE0, 0x7F, 0xC0, 0xE1, 0xC1, 0xC1, 0xC3, 0x81, 0x87, 0x03,
  0x8E, 0x03, 0x9C, 0x03, 0x38, 0x07, 0x70, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xDF,
  0x3D, 0xA6, 0x9F, 0x86, 0x1F, 0x0C, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x61,
  0xE0, 0xC3, 0xC1, 0x87, 0x83, 0x0F, 0x06, 0x1E, 0x0C, 0x3C, 0x18, 0x78,
  0x30, 0xF0, 0x61, 0xE0, 0xC3, 0xC1, 0x87, 0x83, 0x0C, 0xEF, 0xE7, 0xE7,
  0xBC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xE0, 0x1B,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x00, 0xEF,
  0xE3, 0xF3, 0xCF, 0x03, 0xB8, 0x06, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x6E,
  0x01, 0xBC, 0x0E, 0xFF, 0xF3, 0xBF, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x1F, 0xD9, 0xEF, 0xDC, 0x0E, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x0D, 0x80, 0x6E, 0x07, 0x3F, 0xD8, 0xFC, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xCF, 0xE6, 0xEF, 0xBC,
  0x0D, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xE6, 0x01, 0x98, 0x07, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x3E, 0x01, 0xD8, 0x06, 0x7F, 0xF8, 0x7F, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0x80, 0x6E, 0x06, 0x3F, 0xF0, 0xFE, 0x00,
  0xE0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x30, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xE0, 0xC1, 0xB0, 0x60, 0xD8, 0x70, 0x6C, 0x3C, 0x36, 0x16, 0x1B, 0x09,
  0x08, 0xC4, 0x8C, 0x66, 0x46, 0x33, 0x33, 0x19, 0x99, 0x8C, 0x8C, 0xC6,
  0x42, 0x41, 0x21, 0x60, 0xF0, 0xB0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E,
  0x0E, 0x06, 0x00, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x18, 0x1C, 0x38, 0x0C,
  0x30, 0x0E, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0x60, 0x0C, 0x70, 0x1C, 0x38, 0x18, 0x18, 0x30, 0x1C, 0x70,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x30,
  0x0C, 0x38, 0x18, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x07, 0xF0, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x3F, 0xC0, 0xFF, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0xF8,
  0x3C, 0x60, 0xF0, 0xC3, 0xC1, 0xDF, 0x03, 0xE0, 0x02, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 24, 20, 8, -24 },
  { 13, 10, 10, 20, 5, -24 },
  { 26, 18, 24, 20, 1, -24 },
  { 80, 14, 34, 20, 3, -29 },
  { 140, 18, 24, 20, 1, -24 },
  { 194, 17, 24, 20, 2, -24 },
  { 245, 2, 10, 20, 9, -24 },
  { 248, 10, 32, 20, 6, -28 },
  { 288, 9, 32, 20, 4, -28 },
  { 324, 18, 17, 20, 1, -20 },
  { 363, 15, 16, 20, 2, -19 },
  { 393, 6, 10, 20, 6, -5 },
  { 401, 10, 2, 20, 5, -12 },
  { 404, 5, 5, 20, 7, -5 },
  { 408, 14, 31, 20, 3, -27 },
  { 463, 14, 24, 20, 3, -24 },
  { 505, 15, 24, 20, 3, -24 },
  { 550, 14, 24, 20, 3, -24 },
  { 592, 13, 24, 20, 3, -24 },
  { 631, 13, 24, 20, 3, -24 },
  { 670, 14, 24, 20, 3, -24 },
  { 712, 14, 24, 20, 3, -24 },
  { 754, 14, 24, 20, 3, -24 },
  { 796, 14, 24, 20, 3, -24 },
  { 838, 14, 24, 20, 3, -24 },
  { 880, 5, 18, 20, 7, -18 },
  { 892, 7, 23, 20, 6, -18 },
  { 913, 14, 17, 20, 3, -19 },
  { 943, 14, 10, 20, 3, -16 },
  { 961, 14, 17, 20, 3, -19 },
  { 991, 11, 24, 20, 5, -24 },
  { 1024, 16, 30, 20, 2, -24 },
  { 1084, 16, 24, 20, 2, -24 },
  { 1132, 14, 24, 20, 3, -24 },
  { 1174, 14, 24, 20, 3, -24 },
  { 1216, 14, 24, 20, 3, -24 },
  { 1258, 13, 24, 20, 4, -24 },
  { 1297, 13, 24, 20, 4, -24 },
  { 1336, 14, 24, 20, 3, -24 },
  { 1378, 13, 24, 20, 3, -24 },
  { 1417, 12, 24, 20, 4, -24 },
  { 1453, 14, 24, 20, 2, -24 },
  { 1495, 15, 24, 20, 3, -24 },
  { 1540, 13, 24, 20, 4, -24 },
  { 1579, 14, 24, 20, 3, -24 },
  { 1621, 13, 24, 20, 3, -24 },
  { 1660, 14, 24, 20, 3, -24 },
  { 1702, 15, 24, 20, 3, -24 },
  { 1747, 14, 30, 20, 3, -24 },
  { 1800, 15, 24, 20, 3, -24 },
  { 1845, 14, 24, 20, 3, -24 },
  { 1887, 16, 24, 20, 2, -24 },
  { 1935, 13, 24, 20, 3, -24 },
  { 1974, 16, 24, 20, 2, -24 },
  { 2022, 18, 24, 20, 1, -24 },
  { 2076, 16, 24, 20, 2, -24 },
  { 2124, 17, 24, 20, 1, -24 },
  { 2175, 14, 24, 20, 3, -24 },
  { 2217, 8, 31, 20, 7, -27 },
  { 2248, 14, 31, 20, 3, -27 },
  { 2303, 8, 31, 20, 5, -27 },
  { 2334, 14, 13, 20, 3, -24 },
  { 2357, 16, 2, 20, 2, 1 },
  { 2361, 6, 5, 20, 6, -26 },
  { 2365, 14, 18, 20, 2, -18 },
  { 2397, 14, 24, 20, 3, -24 },
  { 2439, 14, 18, 20, 3, -18 },
  { 2471, 13, 24, 20, 3, -24 },
  { 2510, 14, 18, 20, 3, -18 },
  { 2542, 15, 24, 20, 2, -24 },
  { 2587, 13, 24, 20, 3, -18 },
  { 2626, 13, 24, 20, 3, -24 },
  { 2665, 15, 25, 20, 3, -25 },
  { 2712, 12, 31, 20, 3, -25 },
  { 2759, 15, 24, 20, 3, -24 },
  { 2804, 17, 24, 20, 1, -24 },
  { 2855, 15, 18, 20, 2, -18 },
  { 2889, 13, 18, 20, 3, -18 },
  { 2919, 14, 18, 20, 3, -18 },
  { 2951, 14, 24, 20, 3, -18 },
  { 2993, 13, 24, 20, 3, -18 },
  { 3032, 13, 18, 20, 4, -18 },
  { 3062, 14, 18, 20, 3, -18 },
  { 3094, 15, 23, 20, 2, -23 },
  { 3138, 13, 18, 20, 3, -18 },
  { 3168, 16, 18, 20, 2, -18 },
  { 3204, 17, 18, 20, 1, -18 },
  { 3243, 16, 18, 20, 2, -18 },
  { 3279, 16, 24, 20, 2, -18 },
  { 3327, 14, 18, 20, 3, -18 },
  { 3359, 14, 31, 20, 3, -27 },
  { 3414, 2, 31, 20, 9, -27 },
  { 3422, 14, 31, 20, 3, -27 },
  { 3477, 14, 7, 20, 3, -15 },
};

const GFXfont JetBrainsMono_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_EXTRALIGHT33PT7B_H_
