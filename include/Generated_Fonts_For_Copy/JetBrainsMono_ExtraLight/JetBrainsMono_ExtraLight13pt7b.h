#ifndef _JETBRAINSMONO_EXTRALIGHT13PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0x99, 0x90, 0x12, 0x49, 0xF9, 0x22, 0x56, 0xD2,
  0x24, 0x48, 0x20, 0xC6, 0xA9, 0xA1, 0x81, 0x89, 0x26, 0x97, 0x88, 0x20,
  0x61, 0x92, 0x94, 0x94, 0x68, 0x10, 0x1E, 0x29, 0x49, 0x8E, 0x31, 0x28,
  0x90, 0x42, 0x99, 0x62, 0x8B, 0xD0, 0xE0, 0x2A, 0x49, 0x24, 0x92, 0x32,
  0xC2, 0x11, 0x11, 0x11, 0x11, 0x26, 0x80, 0x10, 0x23, 0x49, 0xE1, 0x84,
  0x89, 0x00, 0x20, 0x8F, 0xC8, 0x20, 0x80, 0x69, 0x40, 0xF0, 0xF0, 0x04,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x31, 0x28, 0x61, 0x86,
  0xD8, 0x61, 0x89, 0xE0, 0x72, 0x41, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x33,
  0x28, 0x41, 0x08, 0x21, 0x08, 0x43, 0xF0, 0xF8, 0x88, 0x60, 0x86, 0x31,
  0x78, 0x18, 0x88, 0x84, 0xC7, 0xE1, 0x08, 0xFA, 0x08, 0x3E, 0x88, 0x10,
  0x62, 0x78, 0x10, 0x84, 0x1C, 0x8A, 0x18, 0x61, 0x78, 0xFE, 0x20, 0x82,
  0x10, 0x41, 0x08, 0x20, 0x31, 0x28, 0x62, 0x59, 0xC8, 0xA1, 0x85, 0xE0,
  0x31, 0x28, 0x61, 0x85, 0xE0, 0x84, 0x10, 0x80, 0xE0, 0x3C, 0x68, 0x00,
  0xD2, 0x80, 0x04, 0x66, 0x20, 0x60, 0x40, 0xC0, 0xFC, 0x00, 0x3F, 0x81,
  0x03, 0x03, 0x19, 0x88, 0x00, 0xF1, 0x11, 0x64, 0x00, 0x40, 0x31, 0x38,
  0x61, 0xBE, 0x9A, 0x69, 0xBE, 0x08, 0x1C, 0x30, 0xC5, 0x12, 0x49, 0xE8,
  0xA1, 0x84, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x61, 0xF8, 0x31, 0x28, 0x60,
  0x82, 0x08, 0x21, 0x85, 0xE0, 0xFA, 0x28, 0x61, 0x86, 0x18, 0x62, 0xF0,
  0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08,
  0x20, 0x80, 0x31, 0x28, 0x60, 0x82, 0x78, 0x61, 0x85, 0xE0, 0x8C, 0x63,
  0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x38,
  0x42, 0x10, 0x86, 0x31, 0x70, 0x86, 0x18, 0xA2, 0x93, 0xC9, 0x22, 0x8A,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xCF, 0x3D, 0x6D, 0xA6, 0x18,
  0x61, 0x84, 0xCE, 0x6B, 0x5A, 0xCE, 0x71, 0x88, 0x31, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x89, 0xE0, 0xFE, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x31,
  0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xE0, 0x83, 0xFA, 0x18, 0x61, 0xFA,
  0x48, 0xA2, 0x84, 0x31, 0x28, 0x60, 0x40, 0xE0, 0x41, 0x85, 0xE0, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x78,
  0x86, 0x14, 0x92, 0x49, 0x43, 0x0C, 0x30, 0x9A, 0xB5, 0x6A, 0xD5, 0xAD,
  0x59, 0xB2, 0x24, 0x8D, 0x25, 0x0C, 0x30, 0xC4, 0xA2, 0x84, 0x86, 0x24,
  0x94, 0x30, 0x82, 0x08, 0x20, 0xF8, 0x21, 0x04, 0x20, 0x84, 0x20, 0xFC,
  0xF2, 0x49, 0x24, 0x92, 0x70, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x20, 0x83, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x30, 0xC4, 0x92, 0x84, 0xFC,
  0x90, 0x7C, 0x42, 0xF8, 0xC5, 0xE0, 0x82, 0x0F, 0xA2, 0x86, 0x18, 0x62,
  0xF8, 0x7A, 0x18, 0x20, 0x82, 0x37, 0x80, 0x08, 0x5F, 0x18, 0xC6, 0x31,
  0x78, 0x7A, 0x28, 0x7F, 0x82, 0x17, 0x80, 0x3C, 0x8F, 0xC8, 0x20, 0x82,
  0x08, 0x20, 0x7C, 0x63, 0x18, 0xA4, 0xE1, 0x78, 0x84, 0x3F, 0x18, 0xC6,
  0x31, 0x88, 0x30, 0x40, 0x1C, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x18, 0x40,
  0xF0, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x82, 0x08, 0x62, 0x93, 0xC9, 0x22,
  0x84, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0xFE, 0x9A, 0x69, 0xA6,
  0x9A, 0x40, 0xFC, 0x63, 0x18, 0xC6, 0x20, 0x7A, 0x28, 0x61, 0x86, 0x27,
  0x80, 0xFA, 0x28, 0x61, 0x86, 0x2F, 0xA0, 0x80, 0x7C, 0x63, 0x18, 0xC5,
  0xE1, 0x08, 0xF4, 0x63, 0x08, 0x42, 0x00, 0x7A, 0x14, 0x0E, 0x06, 0x17,
  0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x3C, 0x8C, 0x63, 0x18, 0xC5,
  0xE0, 0x86, 0x24, 0x92, 0x50, 0xC3, 0x00, 0xA6, 0xDB, 0x6D, 0xD5, 0x24,
  0x80, 0x8D, 0x23, 0x0C, 0x31, 0x28, 0x40, 0x86, 0x24, 0x92, 0x30, 0xC2,
  0x08, 0x60, 0xF8, 0x21, 0x08, 0x21, 0x0F, 0xC0, 0x0C, 0x41, 0x04, 0x10,
  0x4E, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xF0, 0xC0, 0x82, 0x08, 0x20, 0x81,
  0xC8, 0x20, 0x82, 0x38, 0xE6, 0x99, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLight13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 1, 3, 8, 3, -9 },
  { 43, 3, 13, 8, 3, -11 },
  { 48, 4, 13, 8, 1, -11 },
  { 55, 7, 7, 8, 0, -8 },
  { 62, 6, 6, 8, 1, -7 },
  { 67, 3, 4, 8, 2, -2 },
  { 69, 4, 1, 8, 2, -5 },
  { 70, 2, 2, 8, 3, -2 },
  { 71, 6, 12, 8, 1, -11 },
  { 80, 6, 10, 8, 1, -10 },
  { 88, 6, 9, 8, 1, -9 },
  { 95, 6, 10, 8, 1, -10 },
  { 103, 5, 9, 8, 1, -9 },
  { 109, 5, 9, 8, 1, -9 },
  { 115, 6, 9, 8, 1, -9 },
  { 122, 6, 9, 8, 1, -9 },
  { 129, 6, 9, 8, 1, -9 },
  { 136, 6, 10, 8, 1, -10 },
  { 144, 6, 10, 8, 1, -10 },
  { 152, 2, 7, 8, 3, -7 },
  { 154, 3, 9, 8, 2, -7 },
  { 158, 6, 7, 8, 1, -8 },
  { 164, 6, 4, 8, 1, -6 },
  { 167, 6, 7, 8, 1, -8 },
  { 173, 4, 9, 8, 2, -9 },
  { 178, 6, 12, 8, 1, -10 },
  { 187, 6, 9, 8, 1, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 6, 10, 8, 1, -10 },
  { 209, 6, 9, 8, 1, -9 },
  { 216, 6, 9, 8, 1, -9 },
  { 223, 6, 9, 8, 1, -9 },
  { 230, 6, 10, 8, 1, -10 },
  { 238, 5, 9, 8, 1, -9 },
  { 244, 5, 10, 8, 1, -10 },
  { 251, 5, 9, 8, 1, -9 },
  { 257, 6, 10, 8, 1, -10 },
  { 265, 5, 9, 8, 2, -9 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 5, 9, 8, 1, -9 },
  { 284, 6, 10, 8, 1, -10 },
  { 292, 6, 9, 8, 1, -9 },
  { 299, 6, 12, 8, 1, -10 },
  { 308, 6, 9, 8, 1, -9 },
  { 315, 6, 10, 8, 1, -10 },
  { 323, 6, 9, 8, 1, -9 },
  { 330, 5, 9, 8, 1, -9 },
  { 336, 6, 9, 8, 1, -9 },
  { 343, 7, 9, 8, 0, -9 },
  { 351, 6, 9, 8, 1, -9 },
  { 358, 6, 9, 8, 1, -9 },
  { 365, 6, 9, 8, 1, -9 },
  { 372, 3, 12, 8, 3, -11 },
  { 377, 6, 12, 8, 1, -11 },
  { 386, 3, 12, 8, 2, -11 },
  { 391, 6, 5, 8, 1, -9 },
  { 395, 6, 1, 8, 1, 0 },
  { 396, 2, 2, 8, 3, -10 },
  { 397, 5, 7, 8, 1, -7 },
  { 402, 6, 9, 8, 1, -9 },
  { 409, 6, 7, 8, 1, -7 },
  { 415, 5, 9, 8, 1, -9 },
  { 421, 6, 7, 8, 1, -7 },
  { 427, 6, 9, 8, 1, -9 },
  { 434, 5, 9, 8, 1, -7 },
  { 440, 5, 9, 8, 1, -9 },
  { 446, 6, 10, 8, 1, -10 },
  { 454, 5, 12, 8, 1, -10 },
  { 462, 6, 9, 8, 1, -9 },
  { 469, 6, 9, 8, 1, -9 },
  { 476, 6, 7, 8, 1, -7 },
  { 482, 5, 7, 8, 1, -7 },
  { 487, 6, 7, 8, 1, -7 },
  { 493, 6, 9, 8, 1, -7 },
  { 500, 5, 9, 8, 1, -7 },
  { 506, 5, 7, 8, 2, -7 },
  { 511, 6, 7, 8, 1, -7 },
  { 517, 6, 9, 8, 1, -9 },
  { 524, 5, 7, 8, 1, -7 },
  { 529, 6, 7, 8, 1, -7 },
  { 535, 6, 7, 8, 1, -7 },
  { 541, 6, 7, 8, 1, -7 },
  { 547, 6, 9, 8, 1, -7 },
  { 554, 6, 7, 8, 1, -7 },
  { 560, 6, 12, 8, 1, -11 },
  { 569, 1, 12, 8, 3, -11 },
  { 571, 6, 12, 8, 1, -11 },
  { 580, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ExtraLight13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_EXTRALIGHT13PT7B_H_
