#ifndef _JETBRAINSMONO_EXTRALIGHT69PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x07, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x9F, 0x80, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFB, 0xC0, 0x1F,
  0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0x9E, 0x7F, 0x01, 0xF8, 0x78, 0x7E, 0x0F, 0xC1,
  0xE0, 0xFC, 0x3E, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x03, 0xE7, 0xC0, 0x78,
  0x0F, 0x9F, 0x01, 0xE0, 0x3E, 0x7C, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x01,
  0xE7, 0x80, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0xFF,
  0x00, 0x00, 0x78, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x78, 0x07, 0xFC, 0x01,
  0xE0, 0x1F, 0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x1E, 0x01, 0xFF, 0x80, 0x78,
  0x07, 0xFE, 0x01, 0xE0, 0x1E, 0x7C, 0x07, 0x80, 0xF9, 0xF0, 0x1E, 0x07,
  0xE3, 0xF0, 0x78, 0x3F, 0x0F, 0xE1, 0xE1, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x3F,
  0xFC, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xC3, 0xE0, 0x7C, 0x00,
  0x07, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x07, 0xC1, 0xC0, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x01, 0xF8, 0x7E,
  0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0xF0, 0x00,
  0x01, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x7F, 0xFC, 0x00, 0x01, 0xE1, 0xFF,
  0xFC, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x01, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x01,
  0xF0, 0x1F, 0x0F, 0x00, 0x01, 0xF8, 0xFC, 0x3C, 0x00, 0x03, 0xFF, 0xF8,
  0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xF3, 0xE0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x3E, 0x07, 0xE0, 0x03,
  0xC7, 0xC0, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC0, 0x1E, 0x3E, 0x00, 0x7C,
  0x07, 0xC7, 0xC0, 0x0F, 0x80, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x1F, 0x00,
  0x0F, 0x8F, 0x83, 0xE0, 0x00, 0xF9, 0xF0, 0x7C, 0x00, 0x1F, 0x7C, 0x0F,
  0x80, 0x01, 0xFF, 0x81, 0xF0, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xFE, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x07, 0xFC, 0x07, 0xC0,
  0x01, 0xF7, 0xC0, 0xFC, 0x00, 0x7C, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xC1,
  0xFE, 0x3F, 0xC0, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0xFC, 0x00,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x0C,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x47, 0x80,
  0x0F, 0x00, 0x3E, 0xFF, 0x00, 0xF0, 0x1F, 0xEF, 0xFE, 0x0E, 0x07, 0xFE,
  0xFF, 0xF8, 0xE1, 0xFF, 0xF3, 0xFF, 0xCE, 0x7F, 0xF8, 0x07, 0xFF, 0xEF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x3E, 0x01, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F,
  0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x80,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3F, 0x8F, 0x00,
  0x01, 0xFC, 0x3C, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFE, 0x03, 0xC0, 0x03,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0,
  0x03, 0xC0, 0x02, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xC0, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x7F, 0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0x79, 0xFF, 0xFE, 0x03, 0xDF,
  0xFF, 0xFC, 0x1E, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7C, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x7C, 0xFF, 0xE0,
  0x01, 0xF7, 0xFF, 0xF0, 0x03, 0xDF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x83, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xDF,
  0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x06, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0, 0x30, 0x03, 0x80, 0x7F,
  0x87, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE3, 0xFF, 0x1F, 0xF0,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0xCF, 0xF0,
  0x01, 0xFF, 0xFB, 0xFC, 0x00, 0xFE, 0x0E, 0xFF, 0x00, 0x3E, 0x00, 0xFF,
  0xC0, 0x1F, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xE0, 0x01,
  0xFF, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0x80,
  0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1E,
  0x00, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0xFF, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x03, 0xFC,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x1F,
  0xF0, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x01,
  0xFF, 0xC0, 0x0F, 0xFB, 0xEF, 0xF0, 0x01, 0xFF, 0xFB, 0xFC, 0x00, 0x3F,
  0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x7C,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFE,
  0x7C, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C,
  0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x8F, 0x80,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C,
  0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0xFF, 0xDE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7B, 0xFB, 0x80, 0x03, 0xDF, 0xDE, 0x00, 0x1E, 0xFE, 0xF0,
  0x01, 0xE7, 0xF3, 0x80, 0x0F, 0x3F, 0x9E, 0x00, 0x71, 0xFC, 0xF0, 0x07,
  0x9F, 0xE3, 0x80, 0x3C, 0xFF, 0x1E, 0x01, 0xC7, 0xF8, 0xF0, 0x1E, 0x3F,
  0xC3, 0x80, 0xF1, 0xFE, 0x1E, 0x07, 0x0F, 0xF0, 0xF0, 0x78, 0x7F, 0x83,
  0x83, 0xC3, 0xFC, 0x1E, 0x1C, 0x1F, 0xE0, 0xF1, 0xE0, 0xFF, 0x03, 0xCF,
  0x07, 0xF8, 0x1E, 0x70, 0x3F, 0xC0, 0x77, 0x81, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7E, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xE0,
  0x1F, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFD, 0xE0, 0x00, 0x7F, 0xBC,
  0x00, 0x0F, 0xF7, 0xC0, 0x01, 0xFE, 0x78, 0x00, 0x3F, 0xCF, 0x00, 0x07,
  0xF8, 0xF0, 0x00, 0xFF, 0x1E, 0x00, 0x1F, 0xE3, 0xC0, 0x03, 0xFC, 0x3C,
  0x00, 0x7F, 0x87, 0x80, 0x0F, 0xF0, 0x78, 0x01, 0xFE, 0x0F, 0x00, 0x3F,
  0xC1, 0xE0, 0x07, 0xF8, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0x7C,
  0x03, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xFE,
  0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0x00, 0x78,
  0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x00, 0xF0, 0x7F, 0x80, 0x1E, 0x0F, 0xF0,
  0x01, 0xE1, 0xFE, 0x00, 0x3C, 0x3F, 0xC0, 0x07, 0x87, 0xF8, 0x00, 0x78,
  0xFF, 0x00, 0x0F, 0x1F, 0xE0, 0x01, 0xF3, 0xFC, 0x00, 0x1E, 0x7F, 0x80,
  0x03, 0xCF, 0xF0, 0x00, 0x3D, 0xFE, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xFF, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xE8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xFE, 0x3E, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xBF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7B, 0xC0, 0x07, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0x00, 0x1E, 0xF0,
  0x01, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xC0, 0x0F, 0x3C, 0x00, 0xFE, 0x00,
  0x79, 0xE0, 0x07, 0x70, 0x03, 0xCF, 0x80, 0x3B, 0xC0, 0x1E, 0x7C, 0x01,
  0xCE, 0x00, 0xF1, 0xE0, 0x0E, 0x70, 0x07, 0x8F, 0x00, 0x73, 0x80, 0x3C,
  0x78, 0x03, 0x9C, 0x01, 0xE3, 0xC0, 0x1C, 0xE0, 0x1E, 0x1E, 0x01, 0xE7,
  0x00, 0xF0, 0xF0, 0x0E, 0x38, 0x07, 0x87, 0x80, 0x71, 0xE0, 0x3C, 0x3E,
  0x03, 0x87, 0x01, 0xE1, 0xF0, 0x1C, 0x38, 0x0F, 0x07, 0x80, 0xE1, 0xC0,
  0x78, 0x3C, 0x07, 0x0E, 0x03, 0xC1, 0xE0, 0x78, 0x70, 0x1E, 0x0F, 0x03,
  0x83, 0x81, 0xE0, 0x78, 0x1C, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0xF0, 0x78,
  0x1F, 0x07, 0x03, 0x83, 0xC0, 0xF8, 0x38, 0x1C, 0x1E, 0x03, 0xC1, 0xC0,
  0xE0, 0xF0, 0x1E, 0x1E, 0x07, 0x07, 0x80, 0xF0, 0xE0, 0x38, 0x3C, 0x07,
  0x87, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x0E, 0x1E, 0x01, 0xE1, 0xC0, 0x78,
  0xF0, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x7C, 0x70, 0x0E, 0x3C, 0x01, 0xE3,
  0x80, 0x71, 0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x1C, 0x78,
  0x03, 0xCE, 0x00, 0xE3, 0x80, 0x1E, 0x70, 0x07, 0xBC, 0x00, 0xF3, 0x80,
  0x3D, 0xE0, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3C, 0xE0, 0x07, 0x78, 0x00,
  0xFE, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x0E,
  0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xDE, 0x3F, 0xC0, 0x7E, 0xF0,
  0xFF, 0xFF, 0xE7, 0x83, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0x81, 0xE0, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x3F, 0xF8, 0x0F,
  0x8F, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0x0F, 0xBF, 0x0F, 0xF8, 0xFF, 0x80,
  0x1F, 0x8F, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7C,
  0xFF, 0x00, 0x0F, 0xCF, 0xF8, 0x01, 0xF8, 0xFB, 0xF0, 0xFF, 0x8F, 0x9F,
  0xFF, 0xF0, 0xF8, 0xFF, 0xFE, 0x0F, 0x87, 0xFF, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0xF0, 0x1F, 0xFC, 0x1E, 0x0F, 0xFF, 0xC3, 0xC3, 0xFF, 0xFE, 0x78,
  0xFF, 0x07, 0xCF, 0x3F, 0x00, 0x3D, 0xEF, 0xC0, 0x01, 0xFD, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x3B, 0xC7, 0xF8, 0x3F, 0x78,
  0x7F, 0xFF, 0xCF, 0x07, 0xFF, 0xF1, 0xE0, 0x3F, 0xF8, 0x3C, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xFF,
  0xFC, 0xF1, 0xFE, 0x0F, 0x9E, 0x7F, 0x00, 0x7B, 0xDF, 0x80, 0x03, 0x7B,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0x79, 0xFC, 0x01, 0xEF,
  0x1F, 0xFF, 0xF9, 0xE1, 0xFF, 0xFE, 0x3C, 0x1F, 0xFF, 0x87, 0x80, 0xFF,
  0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x83, 0xFF,
  0x81, 0xF1, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0xC7, 0xDF, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0x9F, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0xC1, 0xE3,
  0xFC, 0x1F, 0xE3, 0xCF, 0xFC, 0x7F, 0xE7, 0xBF, 0xF9, 0xFF, 0xEF, 0x61,
  0xFB, 0x07, 0xDF, 0x81, 0xF4, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F,
  0x00, 0x7F, 0x80, 0x1E, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x78,
  0x03, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xC0,
  0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0xFF, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x78, 0x03, 0xFC, 0x00, 0xF0, 0x07,
  0xF8, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x3F,
  0xC0, 0x0F, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xFE,
  0x00, 0x78, 0x03, 0xFC, 0x00, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x0F, 0xF0,
  0x03, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x78, 0x03, 0xFC, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F, 0x07, 0xFF, 0x03, 0xE3, 0xFF,
  0xF0, 0x7C, 0xFF, 0xFF, 0x8F, 0xBF, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0x3F,
  0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x03, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x83, 0xFF, 0x80, 0xF8, 0xFF, 0xFC, 0x0F, 0x9F, 0xFF,
  0xF0, 0xFB, 0xF0, 0xFF, 0x8F, 0xF8, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3E, 0xFE, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0xFC, 0xFF, 0x80,
  0x1F, 0x8F, 0xBF, 0x0F, 0xF8, 0xF9, 0xFF, 0xFF, 0x0F, 0x8F, 0xFF, 0xC0,
  0xF8, 0x7F, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xF8, 0x3C, 0x1F, 0xFF, 0x87, 0x87, 0xFF, 0xFC, 0xF1,
  0xFE, 0x0F, 0x9E, 0x7F, 0x00, 0x7B, 0xDF, 0x80, 0x03, 0xFB, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x77, 0x8F, 0xF0, 0x7C, 0xF0,
  0xFF, 0xFF, 0x9E, 0x0F, 0xFF, 0xE3, 0xC0, 0x7F, 0xF0, 0x78, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x83, 0xFF, 0x80, 0xF8, 0xFF,
  0xFE, 0x0F, 0x9F, 0xFF, 0xF0, 0xFB, 0xF0, 0x7F, 0x8F, 0xB8, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0x8F,
  0xE0, 0x00, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xF0,
  0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x03,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xE0, 0x07, 0xC0, 0x07, 0xBC, 0x00, 0xFC, 0x00, 0xF7, 0x80, 0x1F, 0x80,
  0x1E, 0xF0, 0x07, 0x70, 0x07, 0x9E, 0x00, 0xEE, 0x00, 0xF3, 0xC0, 0x1D,
  0xC0, 0x1E, 0x7C, 0x03, 0x98, 0x03, 0xC7, 0x80, 0x73, 0x80, 0x78, 0xF0,
  0x0E, 0x70, 0x0F, 0x1E, 0x03, 0x8E, 0x03, 0xC3, 0xC0, 0x71, 0xC0, 0x78,
  0x78, 0x0E, 0x38, 0x0F, 0x0F, 0x81, 0xC3, 0x81, 0xE0, 0xF0, 0x38, 0x70,
  0x3C, 0x1E, 0x07, 0x0E, 0x07, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0x78, 0x38,
  0x38, 0x3C, 0x0F, 0x07, 0x07, 0x07, 0x81, 0xE0, 0xE0, 0x70, 0xF0, 0x1E,
  0x1C, 0x0E, 0x1E, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0x78, 0xE0, 0x38, 0x70,
  0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x3C, 0x70, 0x0E,
  0x78, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x0F, 0x70,
  0x07, 0x38, 0x01, 0xEE, 0x00, 0xEF, 0x00, 0x3D, 0xC0, 0x1F, 0xE0, 0x07,
  0xB8, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x3F, 0xF0, 0x00, 0x3C, 0xFF, 0xF8, 0x00, 0x7B, 0xFF, 0xF8, 0x00,
  0xF7, 0xC1, 0xF8, 0x01, 0xEF, 0x01, 0xF0, 0x03, 0xFE, 0x01, 0xF0, 0x07,
  0xFC, 0x01, 0xF0, 0x1F, 0xF8, 0x01, 0xF0, 0x3F, 0xF0, 0x03, 0xFD, 0xFB,
  0xE0, 0x03, 0xFF, 0xF7, 0xC0, 0x01, 0xFF, 0xCF, 0x80, 0x01, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 9, 50, 41, 16, -50 },
  { 58, 19, 20, 41, 11, -50 },
  { 106, 37, 50, 41, 2, -50 },
  { 338, 30, 70, 41, 6, -60 },
  { 601, 39, 51, 41, 1, -51 },
  { 850, 35, 52, 41, 4, -51 },
  { 1078, 5, 20, 41, 18, -50 },
  { 1091, 19, 66, 41, 14, -58 },
  { 1248, 20, 66, 41, 8, -58 },
  { 1413, 36, 35, 41, 3, -42 },
  { 1571, 32, 32, 41, 5, -39 },
  { 1699, 13, 21, 41, 12, -10 },
  { 1734, 22, 4, 41, 10, -25 },
  { 1745, 11, 11, 41, 15, -10 },
  { 1761, 29, 65, 41, 6, -57 },
  { 1997, 29, 52, 41, 6, -51 },
  { 2186, 30, 50, 41, 7, -50 },
  { 2374, 31, 51, 41, 5, -51 },
  { 2572, 28, 51, 41, 6, -50 },
  { 2751, 28, 50, 41, 6, -50 },
  { 2926, 29, 51, 41, 6, -50 },
  { 3111, 31, 51, 41, 5, -50 },
  { 3309, 31, 50, 41, 6, -50 },
  { 3503, 29, 52, 41, 6, -51 },
  { 3692, 31, 51, 41, 5, -51 },
  { 3890, 11, 40, 41, 15, -39 },
  { 3945, 13, 50, 41, 13, -39 },
  { 4027, 29, 35, 41, 6, -40 },
  { 4154, 29, 20, 41, 6, -33 },
  { 4227, 29, 35, 41, 6, -40 },
  { 4354, 23, 50, 41, 11, -50 },
  { 4498, 34, 63, 41, 4, -51 },
  { 4766, 33, 50, 41, 4, -50 },
  { 4973, 29, 50, 41, 7, -50 },
  { 5155, 28, 52, 41, 7, -51 },
  { 5337, 28, 50, 41, 7, -50 },
  { 5512, 27, 50, 41, 8, -50 },
  { 5681, 29, 50, 41, 7, -50 },
  { 5863, 28, 52, 41, 7, -51 },
  { 6045, 27, 50, 41, 7, -50 },
  { 6214, 26, 50, 41, 8, -50 },
  { 6377, 30, 51, 41, 4, -50 },
  { 6569, 31, 50, 41, 7, -50 },
  { 6763, 29, 50, 41, 8, -50 },
  { 6945, 29, 50, 41, 6, -50 },
  { 7127, 27, 50, 41, 7, -50 },
  { 7296, 28, 52, 41, 7, -51 },
  { 7478, 30, 50, 41, 7, -50 },
  { 7666, 29, 63, 41, 7, -51 },
  { 7895, 30, 50, 41, 7, -50 },
  { 8083, 30, 52, 41, 6, -51 },
  { 8278, 33, 50, 41, 4, -50 },
  { 8485, 27, 51, 41, 7, -50 },
  { 8658, 33, 50, 41, 4, -50 },
  { 8865, 37, 50, 41, 2, -50 },
  { 9097, 35, 50, 41, 3, -50 },
  { 9316, 35, 50, 41, 3, -50 },
  { 9535, 29, 50, 41, 6, -50 },
  { 9717, 16, 65, 41, 15, -57 },
  { 9847, 29, 65, 41, 6, -57 },
  { 10083, 16, 65, 41, 11, -57 },
  { 10213, 29, 27, 41, 6, -50 },
  { 10311, 33, 4, 41, 4, 2 },
  { 10328, 13, 10, 41, 13, -54 },
  { 10345, 29, 40, 41, 5, -39 },
  { 10490, 28, 51, 41, 7, -50 },
  { 10669, 28, 40, 41, 7, -39 },
  { 10809, 27, 51, 41, 7, -50 },
  { 10982, 28, 40, 41, 7, -39 },
  { 11122, 31, 50, 41, 5, -50 },
  { 11316, 27, 51, 41, 7, -39 },
  { 11489, 27, 50, 41, 7, -50 },
  { 11658, 31, 53, 41, 6, -53 },
  { 11864, 25, 65, 41, 6, -53 },
  { 12068, 30, 50, 41, 7, -50 },
  { 12256, 35, 50, 41, 3, -50 },
  { 12475, 31, 39, 41, 5, -39 },
  { 12627, 27, 39, 41, 7, -39 },
  { 12759, 28, 40, 41, 7, -39 },
  { 12899, 28, 51, 41, 7, -39 },
  { 13078, 27, 51, 41, 7, -39 },
  { 13251, 28, 39, 41, 8, -39 },
  { 13388, 29, 40, 41, 6, -39 },
  { 13533, 31, 49, 41, 4, -49 },
  { 13723, 27, 39, 41, 7, -38 },
  { 13855, 32, 38, 41, 5, -38 },
  { 14007, 35, 38, 41, 3, -38 },
  { 14174, 33, 38, 41, 4, -38 },
  { 14331, 32, 50, 41, 5, -38 },
  { 14531, 28, 38, 41, 7, -38 },
  { 14664, 29, 65, 41, 6, -57 },
  { 14900, 5, 65, 41, 18, -57 },
  { 14941, 29, 65, 41, 6, -57 },
  { 15177, 31, 13, 41, 5, -31 },
};

const GFXfont JetBrainsMono_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_EXTRALIGHT69PT7B_H_
