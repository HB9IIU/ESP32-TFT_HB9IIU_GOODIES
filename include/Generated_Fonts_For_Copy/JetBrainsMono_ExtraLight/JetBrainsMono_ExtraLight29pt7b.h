#ifndef _JETBRAINSMONO_EXTRALIGHT29PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x40, 0x00, 0xEF, 0xE0,
  0xC7, 0xC7, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x20, 0x20, 0x40, 0x41, 0x81, 0x83, 0x1F, 0xFF, 0x86, 0x08,
  0x0C, 0x10, 0x10, 0x60, 0x20, 0xC0, 0xC1, 0x81, 0x82, 0x03, 0x04, 0x3F,
  0xFF, 0x08, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x01, 0x02, 0x02, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xFC, 0x1D, 0xF9, 0xCC,
  0xCC, 0x63, 0x63, 0x1B, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0xB0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x03, 0x30, 0x18, 0xC0, 0xC6, 0x06, 0x3C, 0x31, 0xB1,
  0x8D, 0x8C, 0xC7, 0xFE, 0x1F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x7C, 0x03, 0xC6, 0x06, 0xC2, 0x0C, 0x82, 0x08, 0x82, 0x18, 0x82,
  0x30, 0xC2, 0x20, 0xC6, 0x60, 0x7C, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x10, 0x06, 0x7E, 0x04, 0xC6, 0x0C, 0xC3, 0x18, 0xC3, 0x10, 0xC3, 0x30,
  0xC3, 0x60, 0xC2, 0x40, 0x66, 0xC0, 0x7C, 0x1F, 0x80, 0xE7, 0x07, 0x06,
  0x18, 0x18, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xF0,
  0x0E, 0xE0, 0x31, 0x83, 0xC3, 0x1B, 0x06, 0xCC, 0x1F, 0x30, 0x38, 0xC0,
  0x63, 0x03, 0xCC, 0x1F, 0x1D, 0xE6, 0x3E, 0x0C, 0xFF, 0xFF, 0xC0, 0x03,
  0x0F, 0x1C, 0x30, 0x70, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x1C,
  0x0F, 0x07, 0xE0, 0x78, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x3C, 0x38, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x1C, 0x31, 0xFF, 0x4F, 0x8F, 0xF8,
  0x01, 0x80, 0x05, 0x80, 0x1B, 0x00, 0x63, 0x01, 0xC3, 0x07, 0x07, 0x04,
  0x04, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83,
  0xFF, 0xE0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x3C, 0xE3, 0x1C, 0x71, 0x86, 0x30, 0xC0, 0xFF, 0x80, 0x73, 0xFE, 0xE0,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x87, 0x9C, 0xE0, 0x6C, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0xE3, 0xCE, 0x3C, 0x63, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0x67, 0xFC, 0x3F,
  0x80, 0x0F, 0x01, 0xF0, 0x73, 0x0E, 0x30, 0xC3, 0x08, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC1, 0xC7,
  0x98, 0x0C, 0xC0, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x07, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x00, 0x1C, 0x01, 0xC0, 0x36, 0x03, 0x60,
  0x73, 0xDE, 0x1F, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xC0, 0x38, 0x06, 0x0D, 0x81, 0xB0, 0x3C, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xFF, 0xEF, 0xFE,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xCE, 0x0E,
  0xE0, 0x6C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x06,
  0xE0, 0x67, 0xBC, 0x3F, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x37, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0,
  0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x01, 0xDC, 0x0C,
  0x7B, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0x60, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x00, 0x1F, 0xC1, 0xC7, 0x1C, 0x0C, 0xC0, 0x66, 0x01, 0xB0,
  0x0D, 0x80, 0xC6, 0x06, 0x18, 0xE0, 0x7C, 0x03, 0xE0, 0x31, 0xC3, 0x07,
  0x30, 0x19, 0x80, 0x78, 0x03, 0x40, 0x1B, 0x00, 0xDC, 0x0C, 0x7B, 0xE1,
  0xFC, 0x00, 0x1F, 0xC1, 0xC7, 0x1C, 0x0C, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x60, 0x1B, 0x01, 0xDC, 0x1C, 0x7F, 0x60, 0xF6, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x77, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3F, 0xEE, 0x3D,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x38, 0xE3, 0x0C, 0x71,
  0x86, 0x10, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0xE0, 0x08, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0C,
  0x00, 0x80, 0x00, 0xFC, 0x7F, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x83, 0x8F, 0x87, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x07, 0x00, 0x1F, 0xE0, 0xE1, 0xC6, 0x01, 0x98, 0x06, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x7B, 0x83, 0xBE, 0x18, 0x38, 0x60, 0xE1, 0x83,
  0x86, 0x0E, 0x18, 0x38, 0x60, 0xE1, 0x83, 0x86, 0x0E, 0x0C, 0x78, 0x3E,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x58, 0x03, 0x60, 0x0D, 0x80, 0x32, 0x00,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0x61, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0xC3, 0xFF, 0x18, 0x0C, 0x60, 0x11, 0x80, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x0C, 0xFF, 0x8F, 0xFC, 0xC0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x2C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0xCC, 0x0E, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6F, 0xFC, 0xFF, 0x80, 0x3F, 0x87,
  0x1C, 0xE0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x3C,
  0x07, 0x60, 0x67, 0xBC, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0xC0, 0xEC, 0x06,
  0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xCF, 0xFC,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x87, 0x1C, 0xE0, 0x6C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0xFC, 0x7F,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x60, 0x67, 0xBC,
  0x1F, 0x80, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xFF, 0xFF, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x7F, 0xFF, 0xFE,
  0x07, 0xF0, 0x7F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x67, 0xBE, 0x3F, 0x80, 0xC0, 0x3E, 0x01, 0xB0,
  0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x06, 0x18, 0x30, 0xC3, 0x07, 0xF8,
  0x3F, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0xE6,
  0x03, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0x81, 0xF4, 0x1F, 0xA0, 0xFD, 0x85, 0xE4,
  0x6F, 0x23, 0x79, 0x93, 0xC5, 0x9E, 0x38, 0xF1, 0xC7, 0x86, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0x80, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1D, 0x03, 0xB0, 0x76, 0x0E,
  0x41, 0xCC, 0x38, 0x87, 0x18, 0xE3, 0x1C, 0x23, 0x86, 0x70, 0xCE, 0x0D,
  0xC1, 0xB8, 0x17, 0x03, 0xE0, 0x7C, 0x06, 0x3F, 0x87, 0x1C, 0xE0, 0x6C,
  0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06, 0x60, 0x67,
  0xBC, 0x3F, 0x80, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xBF, 0xF9, 0xFF, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x3F, 0x87, 0x1C, 0xE0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0x67, 0xBC, 0x3F, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0xFF, 0x87, 0xFF, 0x30, 0x19, 0x80, 0x6C,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x76, 0x07, 0x3F, 0xF1, 0xFE,
  0x0C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x19,
  0x80, 0x6C, 0x03, 0x80, 0x1F, 0xC1, 0xC7, 0x9C, 0x0C, 0xC0, 0x36, 0x01,
  0xB0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x1B, 0x00, 0xDC, 0x0C, 0x7B,
  0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0D, 0x81, 0xBD, 0xE3, 0xF8, 0xC0, 0x0F, 0x00,
  0x6C, 0x01, 0x98, 0x06, 0x60, 0x31, 0x80, 0xC3, 0x03, 0x0C, 0x0C, 0x30,
  0x60, 0xC1, 0x81, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x00, 0xCC, 0x03,
  0x20, 0x0D, 0x80, 0x36, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0xC1, 0x83,
  0x87, 0x0F, 0x0E, 0x1E, 0x14, 0x34, 0x28, 0x68, 0x58, 0xD8, 0xB1, 0xB1,
  0x22, 0x62, 0x44, 0xCC, 0x89, 0x99, 0x33, 0x22, 0x62, 0x46, 0xC4, 0x8D,
  0x89, 0x1B, 0x1A, 0x16, 0x3C, 0x28, 0x78, 0x50, 0xE0, 0xA1, 0xC1, 0xC3,
  0x83, 0x80, 0x60, 0x0E, 0x60, 0x18, 0xC0, 0x60, 0xC0, 0xC1, 0x83, 0x01,
  0x8C, 0x01, 0x98, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x6C, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x18, 0x18, 0x30, 0x60, 0x30,
  0xC0, 0x73, 0x00, 0x6E, 0x00, 0x60, 0xE0, 0x06, 0xC0, 0x18, 0xC0, 0x31,
  0x80, 0xC1, 0x81, 0x83, 0x06, 0x03, 0x0C, 0x06, 0x30, 0x06, 0x60, 0x0D,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFF,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xF8, 0x0E,
  0x00, 0xE0, 0x0B, 0x01, 0x90, 0x19, 0x83, 0x18, 0x30, 0xC6, 0x0C, 0x60,
  0x6C, 0x06, 0xC0, 0x70, 0xFF, 0xFC, 0xC3, 0x1C, 0x70, 0x0F, 0xC3, 0xFE,
  0x30, 0x36, 0x03, 0x00, 0x10, 0x01, 0x00, 0x11, 0xFF, 0x78, 0x16, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x36, 0x03, 0x79, 0xD3, 0xF9, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xFB, 0xCE, 0x06, 0xC0, 0x6C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06,
  0xE0, 0x6F, 0x9C, 0xDF, 0x80, 0x1F, 0x87, 0xFC, 0x60, 0x6C, 0x06, 0xC0,
  0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0,
  0x66, 0x06, 0x7F, 0xC3, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x7E, 0x5E, 0xEF, 0x05, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xBD, 0xF3, 0xF6, 0x1F, 0x87,
  0xBC, 0x60, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x76, 0x06, 0x79, 0xC3, 0xF8, 0x03, 0xF8,
  0x3F, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3F, 0x6F, 0x7F,
  0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x36, 0x0A, 0xFF, 0xC7, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x9F,
  0xF3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x9F, 0x3E, 0xF7,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x07, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0xBF, 0xCF, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x1F, 0x01, 0xD8, 0x0C, 0xC0, 0xC6, 0x0C, 0x30, 0xE1, 0x86,
  0x0F, 0xE0, 0x7F, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0xC6, 0x06, 0x30, 0x19,
  0x80, 0xEC, 0x03, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0xDE, 0xF7, 0x35, 0xF0,
  0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18,
  0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xCF, 0x9F,
  0x7B, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x1F, 0x87, 0xFC, 0x60,
  0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x66, 0x06, 0x7B, 0xC3, 0xF8, 0xCF, 0x8F, 0xBC, 0xE0,
  0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x6E, 0x06, 0xF9, 0xCD, 0xF8, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x6F, 0x7F, 0x83, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0x5E,
  0xE9, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x9F, 0x97, 0x7B,
  0x03, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x3F, 0xC7, 0xFE, 0xE0, 0x6C,
  0x03, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0xC0, 0x3C, 0x07, 0x79, 0xE3, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xFE, 0x07, 0xF0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x06, 0xC1, 0xDE,
  0xF1, 0xFC, 0xC0, 0x1E, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03, 0x18, 0x18,
  0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC6, 0x02, 0x30, 0x19, 0x80, 0xD8, 0x02,
  0xC0, 0x1C, 0x00, 0xE0, 0xC1, 0x86, 0x87, 0x0D, 0x0E, 0x1B, 0x14, 0x36,
  0x28, 0x4C, 0x58, 0x98, 0x93, 0x13, 0x26, 0x26, 0x4C, 0x68, 0x98, 0xD1,
  0xA1, 0xA3, 0x43, 0x43, 0x83, 0x87, 0x06, 0x0E, 0x0C, 0x1C, 0xE0, 0x19,
  0x80, 0xC3, 0x07, 0x06, 0x18, 0x18, 0xC0, 0x36, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x36, 0x00, 0xCC, 0x06, 0x30, 0x30, 0x60, 0xC0, 0xC6, 0x03,
  0x30, 0x07, 0xC0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x63, 0x03, 0x18, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x0B, 0x00, 0x78, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x3F, 0x03, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x0F, 0xC0, 0x1E, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x3F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x3F, 0x0F, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x1B, 0xF0, 0xF1, 0xC7, 0x87,
  0x3C, 0x1F, 0x60, 0x20,
};

const GFXglyph JetBrainsMono_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 21, 17, 7, -21 },
  { 12, 8, 9, 17, 5, -21 },
  { 21, 15, 21, 17, 1, -21 },
  { 61, 13, 29, 17, 2, -25 },
  { 109, 16, 21, 17, 1, -21 },
  { 151, 14, 21, 17, 2, -21 },
  { 188, 2, 9, 17, 8, -21 },
  { 191, 8, 27, 17, 6, -24 },
  { 218, 9, 27, 17, 3, -24 },
  { 249, 15, 15, 17, 1, -18 },
  { 278, 13, 13, 17, 2, -16 },
  { 300, 6, 9, 17, 5, -4 },
  { 307, 9, 1, 17, 4, -10 },
  { 309, 5, 4, 17, 6, -4 },
  { 312, 12, 27, 17, 3, -24 },
  { 353, 12, 21, 17, 3, -21 },
  { 385, 12, 21, 17, 3, -21 },
  { 417, 13, 21, 17, 2, -21 },
  { 452, 12, 21, 17, 2, -21 },
  { 484, 11, 21, 17, 3, -21 },
  { 513, 12, 21, 17, 3, -21 },
  { 545, 13, 21, 17, 2, -21 },
  { 580, 13, 21, 17, 2, -21 },
  { 615, 13, 21, 17, 2, -21 },
  { 650, 13, 21, 17, 2, -21 },
  { 685, 5, 16, 17, 6, -16 },
  { 695, 6, 21, 17, 5, -16 },
  { 711, 12, 15, 17, 3, -17 },
  { 734, 12, 9, 17, 3, -14 },
  { 748, 12, 15, 17, 3, -17 },
  { 771, 9, 21, 17, 5, -21 },
  { 795, 14, 26, 17, 2, -21 },
  { 841, 14, 21, 17, 2, -21 },
  { 878, 12, 21, 17, 3, -21 },
  { 910, 12, 21, 17, 3, -21 },
  { 942, 12, 21, 17, 3, -21 },
  { 974, 12, 21, 17, 3, -21 },
  { 1006, 12, 21, 17, 3, -21 },
  { 1038, 12, 21, 17, 3, -21 },
  { 1070, 11, 21, 17, 3, -21 },
  { 1099, 11, 21, 17, 3, -21 },
  { 1128, 12, 21, 17, 2, -21 },
  { 1160, 13, 21, 17, 3, -21 },
  { 1195, 12, 21, 17, 3, -21 },
  { 1227, 13, 21, 17, 2, -21 },
  { 1262, 11, 21, 17, 3, -21 },
  { 1291, 12, 21, 17, 3, -21 },
  { 1323, 13, 21, 17, 3, -21 },
  { 1358, 12, 26, 17, 3, -21 },
  { 1397, 13, 21, 17, 3, -21 },
  { 1432, 13, 21, 17, 2, -21 },
  { 1467, 14, 21, 17, 2, -21 },
  { 1504, 11, 21, 17, 3, -21 },
  { 1533, 14, 21, 17, 2, -21 },
  { 1570, 15, 21, 17, 1, -21 },
  { 1610, 15, 21, 17, 1, -21 },
  { 1650, 15, 21, 17, 1, -21 },
  { 1690, 12, 21, 17, 3, -21 },
  { 1722, 7, 27, 17, 6, -24 },
  { 1746, 12, 27, 17, 3, -24 },
  { 1787, 7, 27, 17, 4, -24 },
  { 1811, 12, 11, 17, 3, -21 },
  { 1828, 14, 1, 17, 2, 1 },
  { 1830, 5, 4, 17, 6, -23 },
  { 1833, 12, 16, 17, 2, -16 },
  { 1857, 12, 21, 17, 3, -21 },
  { 1889, 12, 16, 17, 3, -16 },
  { 1913, 11, 21, 17, 3, -21 },
  { 1942, 12, 16, 17, 3, -16 },
  { 1966, 13, 21, 17, 2, -21 },
  { 2001, 11, 21, 17, 3, -16 },
  { 2030, 11, 21, 17, 3, -21 },
  { 2059, 13, 22, 17, 3, -22 },
  { 2095, 10, 27, 17, 3, -22 },
  { 2129, 13, 21, 17, 3, -21 },
  { 2164, 15, 21, 17, 1, -21 },
  { 2204, 13, 16, 17, 2, -16 },
  { 2230, 11, 16, 17, 3, -16 },
  { 2252, 12, 16, 17, 3, -16 },
  { 2276, 12, 21, 17, 3, -16 },
  { 2308, 11, 21, 17, 3, -16 },
  { 2337, 11, 16, 17, 4, -16 },
  { 2359, 12, 16, 17, 3, -16 },
  { 2383, 13, 20, 17, 2, -20 },
  { 2416, 11, 16, 17, 3, -16 },
  { 2438, 13, 16, 17, 2, -16 },
  { 2464, 15, 16, 17, 1, -16 },
  { 2494, 14, 16, 17, 2, -16 },
  { 2522, 13, 21, 17, 2, -16 },
  { 2557, 12, 16, 17, 3, -16 },
  { 2581, 12, 27, 17, 3, -24 },
  { 2622, 2, 27, 17, 8, -24 },
  { 2629, 12, 27, 17, 3, -24 },
  { 2670, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_EXTRALIGHT29PT7B_H_
