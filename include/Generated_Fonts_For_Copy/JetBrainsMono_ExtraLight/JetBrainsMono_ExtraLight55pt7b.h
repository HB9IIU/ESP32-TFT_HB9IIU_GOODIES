#ifndef _JETBRAINSMONO_EXTRALIGHT55PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xBE,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x70, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x38,
  0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x3C,
  0x00, 0x1C, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xE3, 0x8F, 0x81, 0xE1, 0xC3, 0xE1,
  0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x3C, 0x70, 0x38, 0x1E, 0x38, 0x1C, 0x0F,
  0x3C, 0x0E, 0x07, 0x8E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3E, 0x38, 0x00, 0x0F, 0xDC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x73, 0xF0, 0x00, 0x38, 0x7C, 0x00,
  0x1C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x78, 0x00, 0xE0, 0x3F, 0xC0, 0x70, 0x1E, 0xE0, 0x38, 0x0F,
  0x70, 0x1C, 0x07, 0x3C, 0x0E, 0x07, 0x9F, 0x07, 0x03, 0xC7, 0xC3, 0x83,
  0xC1, 0xF1, 0xC7, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x7F, 0xF0, 0x00, 0x38, 0xFB, 0xF0,
  0x00, 0xE3, 0xC0, 0xE0, 0x03, 0x87, 0x01, 0xE0, 0x07, 0x0E, 0x01, 0xC0,
  0x1C, 0x3C, 0x03, 0x80, 0x70, 0x78, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x03,
  0x81, 0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0x38, 0x3C, 0x07, 0x80, 0x70, 0x70,
  0x07, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0x87, 0x80, 0x1E, 0x0F, 0x0E, 0x00,
  0x1F, 0xFC, 0x38, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x0F, 0xC1, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xF8, 0x00, 0x0F, 0x1F, 0xF8, 0x00,
  0x1C, 0x7F, 0xF8, 0x00, 0x70, 0xF0, 0x78, 0x01, 0xC3, 0xC0, 0x70, 0x03,
  0x87, 0x00, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0xC0, 0x70,
  0x38, 0x07, 0x81, 0xC0, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0x1E, 0x1E, 0x01,
  0xC0, 0x3C, 0x38, 0x03, 0x80, 0x70, 0xE0, 0x07, 0x80, 0xE3, 0xC0, 0x07,
  0x83, 0xC7, 0x00, 0x0F, 0xFF, 0x1C, 0x00, 0x0F, 0xFC, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x78, 0x00, 0x07, 0xC7, 0xC0, 0x1E, 0x78, 0x3C, 0x01, 0xE7, 0x01, 0xE0,
  0x3C, 0xF0, 0x0F, 0x03, 0xCF, 0x00, 0xF8, 0x78, 0xF0, 0x07, 0x87, 0x8F,
  0x00, 0x3C, 0xF0, 0xF0, 0x01, 0xEE, 0x0F, 0x00, 0x1F, 0xE0, 0xF0, 0x00,
  0xFC, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0,
  0x70, 0x00, 0xFE, 0x07, 0x80, 0x1E, 0xF0, 0x78, 0x03, 0xE7, 0x87, 0xC0,
  0x7C, 0x78, 0x3F, 0xFF, 0x83, 0xC1, 0xFF, 0xF0, 0x1E, 0x07, 0xFC, 0x00,
  0xF0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xE7,
  0x39, 0xCE, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x38, 0x03, 0x9F, 0x81,
  0xC0, 0xFD, 0xFF, 0x0E, 0x1F, 0xF7, 0xFE, 0x73, 0xFF, 0x07, 0xFD, 0x7F,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x07,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x8F, 0x80, 0x0F, 0x9E, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xF0, 0x7F, 0x83,
  0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x1C,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0xC0, 0x07, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x1E, 0x00, 0x7E,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x60, 0x1E, 0x00, 0x80,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7,
  0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x3F, 0xE0, 0x3C, 0xFF, 0xF0, 0x7B, 0xFF, 0xF0, 0xFE, 0x03,
  0xF1, 0xF8, 0x01, 0xE3, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xE0,
  0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x7F, 0xE0,
  0x0F, 0x7F, 0xF8, 0x07, 0x7F, 0xFE, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x03,
  0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0xC1,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0xBF, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xF1, 0xF8, 0x0F, 0x80,
  0xF8, 0x3E, 0x00, 0xF8, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xF7, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7,
  0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xFC,
  0x07, 0xF0, 0x3F, 0xFF, 0x70, 0x0F, 0xFF, 0x78, 0x01, 0xFE, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1C, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xF9,
  0xFC, 0x10, 0x0F, 0x83, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x3F, 0x80, 0x3F,
  0xE7, 0xF0, 0x0F, 0xFE, 0xFE, 0x03, 0xF0, 0xFF, 0xC0, 0x78, 0x07, 0xF8,
  0x0E, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xE0, 0x78, 0x01, 0xFC, 0x0F, 0x00,
  0x3F, 0x81, 0xE0, 0x07, 0xF0, 0x3C, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0xC0,
  0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x7F, 0x03, 0xC0, 0x0F, 0xE0, 0x78, 0x01,
  0xFC, 0x0F, 0x00, 0x3F, 0x81, 0xE0, 0x07, 0xF0, 0x1C, 0x01, 0xFE, 0x03,
  0xC0, 0x3F, 0xC0, 0x7C, 0x1F, 0xF8, 0x07, 0xFF, 0x7F, 0x00, 0x7F, 0xCF,
  0xE0, 0x03, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x01, 0xE0, 0x03, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87,
  0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00,
  0x78, 0xE0, 0x01, 0xF1, 0xC0, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1C, 0x00, 0x7E, 0x38, 0x00, 0x3E, 0x70, 0x00, 0x3C,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x00, 0x07, 0xCE, 0x00,
  0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x0F,
  0x87, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xE0, 0x1F, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38, 0x03, 0xF0, 0xE0, 0x03,
  0xE3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x1F, 0x38,
  0x00, 0xF8, 0xE0, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x0F,
  0x87, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xE0, 0x1F, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0,
  0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x1E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x80, 0xE0,
  0x07, 0x80, 0xE0, 0x07, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFD, 0xC0, 0x1D, 0xFB, 0x80, 0x3B, 0xF7,
  0x00, 0x77, 0xE7, 0x01, 0xCF, 0xCE, 0x03, 0x9F, 0x8C, 0x07, 0x3F, 0x1C,
  0x1C, 0x7E, 0x38, 0x38, 0xFC, 0x38, 0x71, 0xF8, 0x71, 0xC3, 0xF0, 0xE3,
  0x87, 0xE0, 0xE6, 0x0F, 0xC1, 0xDC, 0x1F, 0x83, 0xB8, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xB8, 0x00, 0xFD, 0xC0, 0x07, 0xE7, 0x00, 0x3F, 0x38, 0x01,
  0xF9, 0xE0, 0x0F, 0xC7, 0x00, 0x7E, 0x38, 0x03, 0xF1, 0xE0, 0x1F, 0x87,
  0x00, 0xFC, 0x38, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x3C, 0x0F,
  0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x3C, 0x1F, 0x80, 0xE0, 0xFC, 0x07,
  0x87, 0xE0, 0x1C, 0x3F, 0x00, 0xE1, 0xF8, 0x07, 0x8F, 0xC0, 0x1C, 0x7E,
  0x00, 0xE3, 0xF0, 0x03, 0x9F, 0x80, 0x1C, 0xFC, 0x00, 0xF7, 0xE0, 0x03,
  0xBF, 0x00, 0x1D, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x87, 0x80, 0x0F,
  0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xF8, 0xE0, 0x00, 0x7C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3E, 0xE0,
  0x00, 0x7C, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0x87, 0x80,
  0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1D, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x2F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x00, 0x1F, 0x8E, 0x00,
  0x0F, 0x9C, 0x00, 0x0F, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D,
  0xC0, 0x01, 0xF3, 0x80, 0x07, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xC0,
  0x1E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x00, 0xF1, 0xC0, 0x01,
  0xE3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x07, 0xDC, 0x00, 0x07,
  0xB8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE3, 0xE0,
  0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xE0, 0x3E, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x38, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0xE0,
  0x1F, 0x00, 0xFF, 0x00, 0xD8, 0x07, 0xB8, 0x06, 0xC0, 0x39, 0xC0, 0x37,
  0x01, 0xCE, 0x01, 0xB8, 0x0E, 0x70, 0x1D, 0xC0, 0x73, 0x80, 0xEE, 0x03,
  0x9E, 0x07, 0x30, 0x1C, 0xF0, 0x31, 0x81, 0xE7, 0x81, 0x8C, 0x0F, 0x1C,
  0x0C, 0x60, 0x70, 0xE0, 0x63, 0x83, 0x87, 0x07, 0x1C, 0x1C, 0x38, 0x38,
  0xE0, 0xE1, 0xC1, 0xC3, 0x07, 0x0E, 0x0E, 0x18, 0x38, 0x78, 0x60, 0xC1,
  0xC3, 0xC3, 0x06, 0x1E, 0x1E, 0x18, 0x38, 0xF0, 0x71, 0xC1, 0xC7, 0x03,
  0x8E, 0x0E, 0x38, 0x1C, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0x8E, 0x07, 0x18,
  0x0C, 0x70, 0x3C, 0xC0, 0x63, 0x81, 0xE6, 0x03, 0x1C, 0x0F, 0x30, 0x1D,
  0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xDC, 0x07, 0x70, 0x0E, 0xE0, 0x3B, 0x80,
  0x76, 0x00, 0xDC, 0x03, 0xB0, 0x06, 0xE0, 0x1D, 0x80, 0x37, 0x00, 0xEC,
  0x01, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07,
  0x80, 0x1E, 0x07, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x1C,
  0x07, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x70, 0x00, 0x71,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC1, 0xF0, 0x07, 0xC3,
  0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x78, 0x00,
  0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xF9, 0xF0, 0x07, 0x73, 0xFE, 0xFC, 0xE3, 0xFF, 0xF1, 0xC1,
  0xFF, 0xC3, 0x80, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x81, 0xF0, 0x0E, 0x1F, 0xF8, 0x39,
  0xFF, 0xF0, 0xEF, 0x8F, 0xE3, 0xB0, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3B,
  0xC0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x3C, 0xEE, 0x01, 0xF3, 0xBF,
  0xFF, 0x8E, 0x7F, 0xFC, 0x38, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x0F,
  0x87, 0x80, 0x0F, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0xF0, 0x01, 0xF1, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x70, 0x7F, 0xE1,
  0xC3, 0xFF, 0xE7, 0x1F, 0xC7, 0xDC, 0xF8, 0x03, 0x73, 0xC0, 0x07, 0xDE,
  0x00, 0x1F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x01, 0xDC,
  0x7F, 0xFF, 0x70, 0xFF, 0xF9, 0xC0, 0xFF, 0x87, 0x00, 0x30, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFE, 0x1F, 0x83, 0xE0,
  0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00,
  0x1D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0,
  0x00, 0x78, 0xF0, 0x01, 0xF1, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x70, 0xFF, 0xF9, 0xC7, 0xF1, 0xF7, 0x3E,
  0x00, 0xDC, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0x70, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0xDC, 0x7E, 0x0F, 0x70,
  0xFF, 0xF9, 0xC1, 0xFF, 0xC7, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x38, 0xFF, 0xE1, 0xCF, 0xFF,
  0x8E, 0xF8, 0xFE, 0x76, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xF0,
  0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x80,
  0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x3E, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1F, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0xC0, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF8,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x01, 0xC0, 0x78, 0x73,
  0xF8, 0x7F, 0x3B, 0xFE, 0x7F, 0xDD, 0x8F, 0x61, 0xEF, 0x03, 0xE0, 0x7F,
  0x80, 0xE0, 0x3F, 0xC0, 0x70, 0x1F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03,
  0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0,
  0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C,
  0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01,
  0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E,
  0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0E, 0x00, 0x7C, 0x07,
  0x1F, 0xFC, 0x39, 0xFF, 0xF1, 0xDF, 0x1F, 0xCE, 0xC0, 0x1F, 0x7C, 0x00,
  0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x7F, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F,
  0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xB8, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x01,
  0xE1, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x7C, 0x03, 0x87, 0xFE, 0x0E, 0x7F, 0xFC, 0x3B,
  0xE3, 0xF8, 0xEC, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x7B,
  0xE0, 0x01, 0xEF, 0x80, 0x0F, 0x3B, 0x80, 0x7C, 0xEF, 0xFF, 0xE3, 0x9F,
  0xFF, 0x0E, 0x1F, 0xF0, 0x38, 0x04, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x70, 0xFF, 0xF9, 0xC7, 0xF1, 0xF7, 0x3E, 0x00, 0xDC, 0xF0, 0x01,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDC,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x80,
  0x77, 0x1F, 0xFF, 0x9C, 0x3F, 0xFE, 0x70, 0x3F, 0xE1, 0xC0, 0x0C, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x7C, 0x03, 0x8F, 0xFE, 0x0E, 0x7F, 0xFC, 0x3B, 0xE1, 0xF8,
  0xEC, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x07, 0x9E, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xF0, 0x03, 0xE3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x80, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01,
  0xC0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x7B, 0x80, 0x7C, 0x03, 0x9C,
  0x03, 0xE0, 0x1C, 0xE0, 0x1B, 0x00, 0xE7, 0x80, 0xD8, 0x07, 0x3C, 0x06,
  0xC0, 0x78, 0xE0, 0x37, 0x03, 0x87, 0x03, 0xB8, 0x1C, 0x38, 0x1C, 0xC0,
  0xE1, 0xC0, 0xC6, 0x07, 0x0E, 0x06, 0x30, 0x38, 0x78, 0x31, 0x83, 0xC1,
  0xC3, 0x8E, 0x1C, 0x0E, 0x1C, 0x70, 0xE0, 0x70, 0xE1, 0x87, 0x03, 0x86,
  0x0C, 0x38, 0x1C, 0x30, 0x61, 0xC0, 0xF1, 0x83, 0x8E, 0x03, 0x9C, 0x1C,
  0xE0, 0x1C, 0xE0, 0xE7, 0x00, 0xE6, 0x03, 0x38, 0x07, 0x30, 0x19, 0xC0,
  0x39, 0x80, 0xCE, 0x01, 0xDC, 0x07, 0x70, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x8F,
  0x00, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x0E,
  0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9C, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x07, 0x8F, 0xF0,
  0x03, 0xCF, 0xFC, 0x01, 0xEF, 0x9F, 0x00, 0xF7, 0x07, 0xC0, 0x7F, 0x81,
  0xF0, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x1F, 0x1E, 0xF0, 0x07, 0xFF, 0x78,
  0x01, 0xFF, 0x3C, 0x00, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 7, 40, 33, 13, -40 },
  { 36, 15, 16, 33, 9, -40 },
  { 66, 29, 40, 33, 2, -40 },
  { 211, 25, 56, 33, 4, -48 },
  { 386, 31, 40, 33, 1, -40 },
  { 541, 28, 42, 33, 3, -41 },
  { 688, 5, 16, 33, 14, -40 },
  { 698, 16, 53, 33, 11, -46 },
  { 804, 16, 53, 33, 6, -46 },
  { 910, 29, 29, 33, 2, -34 },
  { 1016, 25, 26, 33, 4, -31 },
  { 1098, 10, 17, 33, 10, -8 },
  { 1120, 17, 3, 33, 8, -20 },
  { 1127, 9, 9, 33, 12, -8 },
  { 1138, 23, 52, 33, 5, -46 },
  { 1288, 23, 42, 33, 5, -41 },
  { 1409, 24, 40, 33, 5, -40 },
  { 1529, 25, 41, 33, 4, -41 },
  { 1658, 22, 41, 33, 5, -40 },
  { 1771, 22, 40, 33, 5, -40 },
  { 1881, 23, 41, 33, 5, -40 },
  { 1999, 25, 41, 33, 4, -40 },
  { 2128, 24, 40, 33, 5, -40 },
  { 2248, 23, 42, 33, 5, -41 },
  { 2369, 25, 41, 33, 4, -41 },
  { 2498, 9, 32, 33, 12, -31 },
  { 2534, 11, 40, 33, 10, -31 },
  { 2589, 23, 28, 33, 5, -32 },
  { 2670, 23, 16, 33, 5, -26 },
  { 2716, 23, 28, 33, 5, -32 },
  { 2797, 18, 40, 33, 9, -40 },
  { 2887, 27, 51, 33, 3, -41 },
  { 3060, 27, 40, 33, 3, -40 },
  { 3195, 23, 40, 33, 6, -40 },
  { 3310, 23, 42, 33, 5, -41 },
  { 3431, 22, 40, 33, 6, -40 },
  { 3541, 22, 40, 33, 6, -40 },
  { 3651, 23, 40, 33, 6, -40 },
  { 3766, 23, 42, 33, 5, -41 },
  { 3887, 21, 40, 33, 6, -40 },
  { 3992, 21, 40, 33, 6, -40 },
  { 4097, 24, 41, 33, 3, -40 },
  { 4220, 24, 40, 33, 6, -40 },
  { 4340, 23, 40, 33, 6, -40 },
  { 4455, 23, 40, 33, 5, -40 },
  { 4570, 21, 40, 33, 6, -40 },
  { 4675, 23, 42, 33, 5, -41 },
  { 4796, 24, 40, 33, 6, -40 },
  { 4916, 23, 51, 33, 5, -41 },
  { 5063, 23, 40, 33, 6, -40 },
  { 5178, 25, 42, 33, 4, -41 },
  { 5310, 27, 40, 33, 3, -40 },
  { 5445, 21, 41, 33, 6, -40 },
  { 5553, 27, 40, 33, 3, -40 },
  { 5688, 29, 40, 33, 2, -40 },
  { 5833, 27, 40, 33, 3, -40 },
  { 5968, 29, 40, 33, 2, -40 },
  { 6113, 23, 40, 33, 5, -40 },
  { 6228, 13, 52, 33, 12, -46 },
  { 6313, 23, 52, 33, 5, -46 },
  { 6463, 13, 52, 33, 8, -46 },
  { 6548, 23, 21, 33, 5, -40 },
  { 6609, 27, 4, 33, 3, 1 },
  { 6623, 10, 8, 33, 11, -43 },
  { 6633, 23, 32, 33, 4, -31 },
  { 6725, 22, 41, 33, 6, -40 },
  { 6838, 23, 32, 33, 5, -31 },
  { 6930, 22, 41, 33, 5, -40 },
  { 7043, 23, 32, 33, 5, -31 },
  { 7135, 25, 40, 33, 4, -40 },
  { 7260, 22, 41, 33, 5, -31 },
  { 7373, 21, 40, 33, 6, -40 },
  { 7478, 25, 42, 33, 5, -42 },
  { 7610, 20, 52, 33, 5, -42 },
  { 7740, 24, 40, 33, 6, -40 },
  { 7860, 28, 40, 33, 2, -40 },
  { 8000, 25, 31, 33, 4, -31 },
  { 8097, 21, 31, 33, 6, -31 },
  { 8179, 23, 32, 33, 5, -31 },
  { 8271, 22, 41, 33, 6, -31 },
  { 8384, 22, 41, 33, 5, -31 },
  { 8497, 22, 31, 33, 7, -31 },
  { 8583, 23, 32, 33, 5, -31 },
  { 8675, 24, 39, 33, 4, -39 },
  { 8792, 21, 31, 33, 6, -30 },
  { 8874, 25, 30, 33, 4, -30 },
  { 8968, 29, 30, 33, 2, -30 },
  { 9077, 25, 30, 33, 4, -30 },
  { 9171, 25, 40, 33, 4, -30 },
  { 9296, 23, 30, 33, 5, -30 },
  { 9383, 23, 52, 33, 5, -46 },
  { 9533, 3, 52, 33, 15, -46 },
  { 9553, 23, 52, 33, 5, -46 },
  { 9703, 25, 11, 33, 4, -25 },
};

const GFXfont JetBrainsMono_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_EXTRALIGHT55PT7B_H_
