#ifndef _JETBRAINSMONO_EXTRALIGHT49PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0xFF, 0xFF, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00,
  0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x06, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC0, 0x60, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x01, 0x80,
  0x07, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x03, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x38,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0x8C, 0x78, 0x78, 0x61, 0xE7,
  0x83, 0x07, 0x38, 0x18, 0x3D, 0xC0, 0xC0, 0xEE, 0x06, 0x07, 0x70, 0x30,
  0x03, 0x81, 0x80, 0x1E, 0x0C, 0x00, 0x70, 0x60, 0x03, 0xC3, 0x00, 0x0F,
  0x18, 0x00, 0x7E, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x67, 0xC0, 0x03, 0x0F, 0x00, 0x18, 0x3C, 0x00,
  0xC1, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x81, 0xF8, 0x0C, 0x0F,
  0xC0, 0x60, 0x7F, 0x03, 0x03, 0xB8, 0x18, 0x3D, 0xE0, 0xC1, 0xE7, 0x86,
  0x3E, 0x1F, 0xBF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x73, 0xFE, 0x00, 0x0E, 0x7F,
  0xF0, 0x01, 0xC7, 0x07, 0x80, 0x38, 0x60, 0x38, 0x03, 0x8E, 0x03, 0x80,
  0x70, 0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0xC0, 0xE0, 0x38, 0x1C, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x38, 0x30, 0x0E, 0x03, 0x87, 0x00, 0x70, 0x38,
  0xE0, 0x07, 0x87, 0x0C, 0x00, 0x3F, 0xF1, 0xC0, 0x01, 0xFC, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x7F, 0x00, 0x03, 0x8F, 0xF8, 0x00, 0x71, 0xF7,
  0xC0, 0x06, 0x1C, 0x0E, 0x00, 0xE3, 0x80, 0xE0, 0x1C, 0x38, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38,
  0x0E, 0x0C, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x0E, 0x38, 0x01, 0xC0, 0xE3,
  0x00, 0x1F, 0x3C, 0x70, 0x00, 0xFF, 0x8E, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x3C, 0x01, 0xDE, 0x0E, 0x01,
  0xCF, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0xE3, 0x80, 0x78, 0xF1, 0xC0, 0x1C,
  0x70, 0xE0, 0x0F, 0x78, 0x70, 0x03, 0xF8, 0x38, 0x00, 0xFC, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x83, 0xC0, 0x0F, 0xE1, 0xE0,
  0x0F, 0x70, 0x78, 0x0F, 0x3C, 0x3F, 0xBF, 0x0F, 0x0F, 0xFF, 0x03, 0x81,
  0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0, 0x00,
  0x0C, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xC0, 0x03,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x3F, 0x80, 0xF8, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x80, 0x38, 0x01, 0x70, 0x1C,
  0x07, 0xFF, 0x0E, 0x1F, 0xFF, 0xE3, 0x3F, 0xE3, 0xFD, 0xBF, 0xC0, 0x3F,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x01,
  0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x06, 0x07,
  0xF0, 0xF8, 0x3F, 0x87, 0xC1, 0xFC, 0x3E, 0x0F, 0xE1, 0xF0, 0x7F, 0x03,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00,
  0x3D, 0xE0, 0x01, 0xC7, 0x80, 0x1E, 0x3E, 0x01, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0x70, 0x01, 0xF3, 0x80, 0x3E, 0x1C, 0x03, 0xE0, 0xE0, 0x1E,
  0x07, 0x00, 0xC0, 0x38, 0x04, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0x80, 0xF8, 0x78, 0x00, 0xF1, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00,
  0xF7, 0x80, 0x1E, 0x3C, 0x03, 0xE1, 0xFD, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0xF0, 0x03, 0xBC, 0x00,
  0x77, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x30, 0x0F,
  0x3F, 0xE0, 0xF7, 0xFF, 0x8F, 0xFB, 0xFC, 0xFC, 0x03, 0xCF, 0x80, 0x1E,
  0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x00, 0x1E, 0x78,
  0x03, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE7, 0xE0, 0x07, 0x7F, 0xE0, 0x3B, 0xFF, 0xC0, 0xFC, 0x0F, 0x87, 0xC0,
  0x1F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x3E, 0x01, 0xE0, 0x7F, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C,
  0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xCE, 0x00, 0x0F,
  0x70, 0x00, 0x7B, 0x80, 0x03, 0xDE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0xC0,
  0x0F, 0x0E, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0xF9, 0xF0, 0x03, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0x1F, 0x01, 0xE0, 0x3C, 0x1E, 0x00,
  0xF1, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x01,
  0xEF, 0x00, 0x1E, 0x3C, 0x01, 0xF0, 0xFE, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x80,
  0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xF0, 0x03, 0xC3, 0xE0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xE7, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x1F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3F, 0x87,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x03, 0x87, 0xE0, 0x1F, 0xF7, 0xE0, 0x3F, 0xF7, 0xE0,
  0x3C, 0x1F, 0xE0, 0x78, 0x0F, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x70, 0x07, 0xE0, 0x70, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x3E, 0x3F, 0xE0,
  0x1F, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1E,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70,
  0x03, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x70, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x70, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x1F, 0x8E,
  0x00, 0x3C, 0x70, 0x00, 0xF3, 0x80, 0x03, 0x9C, 0x00, 0x1E, 0xE0, 0x00,
  0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x70,
  0x00, 0xF3, 0x80, 0x0F, 0x1C, 0x00, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0x80,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00,
  0x3C, 0xE0, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xC0, 0x3C, 0x78, 0x01,
  0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xFB,
  0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0E, 0x01, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE,
  0x00, 0x3C, 0xE0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x80,
  0x1E, 0x7C, 0x03, 0xC3, 0xFB, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x01,
  0xE1, 0xFC, 0x7E, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x1E,
  0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x38, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00,
  0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xBE, 0xC0, 0x1D, 0xF7, 0x00, 0xEF, 0xB8, 0x06,
  0xFC, 0xC0, 0x77, 0xE7, 0x03, 0xBF, 0x38, 0x19, 0xF8, 0xC1, 0xCF, 0xC7,
  0x0C, 0x7E, 0x38, 0xE3, 0xF0, 0xC7, 0x1F, 0x87, 0x30, 0xFC, 0x39, 0x87,
  0xE0, 0xDC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFB, 0x80, 0x3F, 0x70, 0x07,
  0xE7, 0x00, 0xFC, 0xE0, 0x1F, 0x9C, 0x03, 0xF1, 0xC0, 0x7E, 0x38, 0x0F,
  0xC3, 0x01, 0xF8, 0x70, 0x3F, 0x0E, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x38, 0x7E, 0x07, 0x0F, 0xC0, 0x61, 0xF8, 0x0E, 0x3F,
  0x01, 0xC7, 0xE0, 0x1C, 0xFC, 0x03, 0x9F, 0x80, 0x73, 0xF0, 0x07, 0x7E,
  0x00, 0xEF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3B, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xC0, 0x7C, 0x78, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x01,
  0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x01, 0xF8,
  0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0xE0, 0x01, 0xF3,
  0x80, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87,
  0xC0, 0x7C, 0x78, 0x01, 0xCF, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x80, 0x1E,
  0x7C, 0x03, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xC0, 0x1F, 0xCE, 0x00, 0x1E, 0x70, 0x00,
  0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x03,
  0xDC, 0x00, 0x1E, 0xE0, 0x03, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x78, 0x1C, 0x03, 0xC0,
  0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00,
  0x3C, 0x70, 0x01, 0xE3, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0xE0, 0x00, 0xF7,
  0x00, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x03, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x39,
  0xC0, 0x01, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x3C, 0x01, 0xF1, 0xFE,
  0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x0E, 0x3C,
  0x03, 0xC7, 0xF7, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCF,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E,
  0x01, 0xE0, 0x3B, 0x80, 0x78, 0x0E, 0xE0, 0x3E, 0x03, 0xB8, 0x0D, 0x80,
  0xEE, 0x03, 0x70, 0x39, 0xC0, 0xDC, 0x0E, 0x70, 0x33, 0x03, 0x9C, 0x0C,
  0xC0, 0xE7, 0x03, 0x30, 0x31, 0xC1, 0xCC, 0x1C, 0x70, 0x73, 0x07, 0x1C,
  0x18, 0xC1, 0xC7, 0x06, 0x38, 0x70, 0xC1, 0x8E, 0x1C, 0x38, 0x61, 0x87,
  0x0E, 0x18, 0x61, 0xC3, 0x86, 0x18, 0x70, 0xE3, 0x86, 0x18, 0x38, 0xC1,
  0x8E, 0x0E, 0x30, 0x63, 0x83, 0x8C, 0x1C, 0xE0, 0xE3, 0x07, 0x38, 0x1C,
  0xC0, 0xCE, 0x07, 0x30, 0x33, 0x81, 0xDC, 0x0C, 0xE0, 0x76, 0x03, 0x30,
  0x1D, 0x80, 0xCC, 0x07, 0x60, 0x37, 0x01, 0xD8, 0x0F, 0xC0, 0x76, 0x03,
  0xF0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x83,
  0x80, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x78,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0xE0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x01, 0xC0,
  0x78, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x0E, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00,
  0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0, 0x1E, 0x38, 0x00, 0xF7,
  0x80, 0x07, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7E, 0x00,
  0x77, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x1F, 0x7F,
  0x0F, 0x73, 0xFF, 0xE7, 0x0F, 0xFC, 0x70, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1F, 0xE0, 0xE7, 0xFF, 0x0E, 0xF9,
  0xF8, 0xEC, 0x03, 0xCF, 0x80, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x00,
  0xEF, 0x80, 0x1E, 0xEC, 0x03, 0xCE, 0xF9, 0xF8, 0xE7, 0xFF, 0x8E, 0x3F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xC0, 0x3C, 0x78,
  0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0xC0,
  0x3C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F,
  0xDF, 0x77, 0xC0, 0x3E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80,
  0x0F, 0x7C, 0x03, 0xE7, 0xE3, 0xDC, 0x7F, 0xF3, 0x87, 0xFC, 0x70, 0x07,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0x9F, 0x87, 0xC0, 0x3C, 0x70, 0x01, 0xEF,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0xC0, 0x3C, 0x3F,
  0x9F, 0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xF8, 0xE3, 0xFF, 0x9C, 0xFE, 0xFB, 0xBE, 0x01,
  0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0xCF, 0xFF, 0xB8, 0xFF, 0xE7,
  0x07, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x7F, 0xC3, 0x9F, 0xFC, 0x77, 0xCF, 0xCE, 0xC0, 0x3D,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xEE, 0x00,
  0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x3C,
  0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38,
  0x0F, 0x00, 0xE0, 0x78, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x38, 0x1E,
  0x00, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x38, 0x03, 0xC0,
  0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0xCF, 0xC3, 0xF3, 0x7F, 0x9F, 0xED, 0x9F, 0xC7, 0xB4,
  0x1E, 0x0E, 0xE0, 0x70, 0x3F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C,
  0x07, 0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07,
  0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0,
  0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70,
  0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F,
  0x81, 0xC0, 0x7E, 0x07, 0x01, 0xC0, 0xE3, 0xFE, 0x1C, 0xFF, 0xE3, 0xBE,
  0x7E, 0x76, 0x01, 0xEF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x07,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xBF, 0x87, 0xC0, 0x3C, 0x78, 0x01, 0xEF,
  0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0xC0, 0x3C, 0x3F,
  0xBF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xE1, 0xFE, 0x0E, 0x7F, 0xF0,
  0xEF, 0x9F, 0x8E, 0xC0, 0x3C, 0xF8, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xF8, 0x01, 0xEE, 0xC0, 0x3C, 0xEF, 0x9F, 0x8E, 0x7F, 0xF0,
  0xE3, 0xFE, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xF8, 0xE3, 0xFF, 0x9C, 0xFE, 0xFB, 0xBE, 0x01, 0xF7, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x1F, 0x3F, 0x1E,
  0xE3, 0xFF, 0x9C, 0x3F, 0xE3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0xE3, 0xFE, 0x0E, 0x7F, 0xF0, 0xEF, 0x9F, 0x8E, 0xC0,
  0x3C, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x7F,
  0x0F, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x03,
  0xDE, 0x00, 0x71, 0xE0, 0x1E, 0x3F, 0xBF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x0F,
  0x01, 0xDC, 0x07, 0x80, 0xEE, 0x07, 0xC0, 0x77, 0x03, 0x60, 0x3B, 0x81,
  0xB0, 0x39, 0xC0, 0xD8, 0x1C, 0xE0, 0x66, 0x0E, 0x30, 0x33, 0x07, 0x1C,
  0x39, 0x83, 0x8E, 0x18, 0xC1, 0x87, 0x0C, 0x60, 0xC3, 0x86, 0x38, 0xE1,
  0xC3, 0x0C, 0x70, 0x61, 0x86, 0x38, 0x39, 0xC3, 0x1C, 0x1C, 0xC1, 0x8C,
  0x0E, 0x60, 0xC6, 0x07, 0x30, 0x77, 0x03, 0x98, 0x1B, 0x80, 0xDC, 0x0D,
  0xC0, 0x6C, 0x06, 0xE0, 0x3E, 0x03, 0x60, 0x1F, 0x01, 0xB0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0xCE,
  0x00, 0x03, 0xBC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xEF, 0x00, 0x03, 0x8F, 0x00,
  0x0F, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x1C, 0x07,
  0x80, 0x3C, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x71, 0xC0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x0F,
  0x00, 0x78, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x1D, 0xFF, 0x00, 0x77, 0xFE, 0x01, 0xF8, 0x3C,
  0x07, 0xE0, 0x70, 0x1F, 0x81, 0xE0, 0xEE, 0x03, 0xE7, 0xB8, 0x07, 0xFE,
  0xE0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 6, 36, 29, 12, -36 },
  { 28, 14, 15, 29, 8, -36 },
  { 55, 26, 36, 29, 2, -36 },
  { 172, 21, 50, 29, 4, -43 },
  { 304, 28, 36, 29, 1, -36 },
  { 430, 25, 36, 29, 3, -36 },
  { 543, 4, 15, 29, 13, -36 },
  { 551, 14, 47, 29, 10, -41 },
  { 634, 14, 47, 29, 6, -41 },
  { 717, 25, 25, 29, 2, -30 },
  { 796, 23, 23, 29, 3, -28 },
  { 863, 9, 15, 29, 9, -7 },
  { 880, 16, 3, 29, 7, -18 },
  { 886, 7, 7, 29, 11, -7 },
  { 893, 21, 46, 29, 4, -41 },
  { 1014, 21, 36, 29, 4, -36 },
  { 1109, 21, 36, 29, 5, -36 },
  { 1204, 22, 36, 29, 4, -36 },
  { 1303, 20, 36, 29, 4, -36 },
  { 1393, 19, 36, 29, 5, -36 },
  { 1479, 20, 36, 29, 5, -36 },
  { 1569, 22, 36, 29, 4, -36 },
  { 1668, 22, 36, 29, 4, -36 },
  { 1767, 21, 36, 29, 4, -36 },
  { 1862, 22, 36, 29, 4, -36 },
  { 1961, 7, 27, 29, 11, -27 },
  { 1985, 10, 35, 29, 9, -27 },
  { 2029, 21, 25, 29, 4, -29 },
  { 2095, 21, 14, 29, 4, -23 },
  { 2132, 21, 25, 29, 4, -29 },
  { 2198, 16, 36, 29, 8, -36 },
  { 2270, 24, 45, 29, 3, -36 },
  { 2405, 23, 36, 29, 3, -36 },
  { 2509, 21, 36, 29, 5, -36 },
  { 2604, 20, 36, 29, 5, -36 },
  { 2694, 20, 36, 29, 5, -36 },
  { 2784, 20, 36, 29, 5, -36 },
  { 2874, 21, 36, 29, 5, -36 },
  { 2969, 20, 36, 29, 5, -36 },
  { 3059, 19, 36, 29, 5, -36 },
  { 3145, 18, 36, 29, 6, -36 },
  { 3226, 21, 36, 29, 3, -36 },
  { 3321, 22, 36, 29, 5, -36 },
  { 3420, 20, 36, 29, 6, -36 },
  { 3510, 21, 36, 29, 4, -36 },
  { 3605, 19, 36, 29, 5, -36 },
  { 3691, 20, 36, 29, 5, -36 },
  { 3781, 22, 36, 29, 5, -36 },
  { 3880, 20, 45, 29, 5, -36 },
  { 3993, 21, 36, 29, 5, -36 },
  { 4088, 21, 36, 29, 4, -36 },
  { 4183, 24, 36, 29, 3, -36 },
  { 4291, 19, 36, 29, 5, -36 },
  { 4377, 23, 36, 29, 3, -36 },
  { 4481, 26, 36, 29, 2, -36 },
  { 4598, 25, 36, 29, 2, -36 },
  { 4711, 25, 36, 29, 2, -36 },
  { 4824, 21, 36, 29, 4, -36 },
  { 4919, 12, 46, 29, 10, -41 },
  { 4988, 21, 46, 29, 4, -41 },
  { 5109, 12, 46, 29, 7, -41 },
  { 5178, 20, 19, 29, 5, -36 },
  { 5226, 23, 3, 29, 3, 1 },
  { 5235, 10, 6, 29, 9, -38 },
  { 5243, 20, 27, 29, 4, -27 },
  { 5311, 20, 36, 29, 5, -36 },
  { 5401, 20, 27, 29, 5, -27 },
  { 5469, 19, 36, 29, 5, -36 },
  { 5555, 20, 27, 29, 5, -27 },
  { 5623, 23, 36, 29, 3, -36 },
  { 5727, 19, 36, 29, 5, -27 },
  { 5813, 19, 36, 29, 5, -36 },
  { 5899, 23, 38, 29, 4, -38 },
  { 6009, 18, 47, 29, 4, -38 },
  { 6115, 22, 36, 29, 5, -36 },
  { 6214, 25, 36, 29, 2, -36 },
  { 6327, 22, 27, 29, 4, -27 },
  { 6402, 19, 27, 29, 5, -27 },
  { 6467, 20, 27, 29, 5, -27 },
  { 6535, 20, 36, 29, 5, -27 },
  { 6625, 19, 36, 29, 5, -27 },
  { 6711, 20, 27, 29, 6, -27 },
  { 6779, 20, 27, 29, 5, -27 },
  { 6847, 22, 35, 29, 3, -35 },
  { 6944, 19, 27, 29, 5, -27 },
  { 7009, 23, 27, 29, 3, -27 },
  { 7087, 25, 27, 29, 2, -27 },
  { 7172, 23, 27, 29, 3, -27 },
  { 7250, 23, 36, 29, 3, -27 },
  { 7354, 20, 27, 29, 5, -27 },
  { 7422, 20, 46, 29, 5, -41 },
  { 7537, 3, 46, 29, 13, -41 },
  { 7555, 20, 46, 29, 5, -41 },
  { 7670, 22, 9, 29, 4, -22 },
};

const GFXfont JetBrainsMono_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_EXTRALIGHT49PT7B_H_
