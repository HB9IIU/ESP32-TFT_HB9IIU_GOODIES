#ifndef _JETBRAINSMONO_EXTRALIGHT56PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xF1, 0x8F, 0x81, 0xF0, 0xC3, 0xE1, 0xF0, 0x60, 0xF8, 0xF0, 0x30,
  0x3C, 0x78, 0x18, 0x1E, 0x38, 0x0C, 0x07, 0x1C, 0x06, 0x03, 0xCE, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0xC0, 0xC0, 0x01, 0xE0, 0x60, 0x00, 0xF8,
  0x30, 0x00, 0x3E, 0x18, 0x00, 0x0F, 0x8C, 0x00, 0x07, 0xF6, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x37, 0xF0, 0x00, 0x18, 0xFC, 0x00, 0x0C, 0x1E, 0x00, 0x06, 0x07,
  0x80, 0x03, 0x03, 0xC0, 0x01, 0x80, 0xF0, 0x00, 0xC0, 0x78, 0x00, 0x60,
  0x3E, 0x00, 0x30, 0x1E, 0xE0, 0x18, 0x0F, 0x70, 0x0C, 0x07, 0xBC, 0x06,
  0x03, 0xDE, 0x03, 0x01, 0xE7, 0x81, 0x81, 0xE3, 0xE0, 0xC1, 0xF0, 0xFC,
  0x63, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x1E, 0x3F, 0xFC, 0x00,
  0x1C, 0x78, 0x1C, 0x00, 0x38, 0x70, 0x1E, 0x00, 0x78, 0x70, 0x0E, 0x00,
  0x70, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07,
  0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x78, 0x1E, 0x3C,
  0x00, 0x3E, 0x7C, 0x38, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x0F, 0xF0, 0xF0,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0xF0, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x1C, 0x3E, 0xFC, 0x00, 0x38, 0x78,
  0x1C, 0x00, 0x78, 0x70, 0x1E, 0x00, 0x70, 0xF0, 0x0E, 0x00, 0xE0, 0xF0,
  0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x03, 0x80, 0xF0,
  0x0E, 0x07, 0x00, 0xF0, 0x0E, 0x07, 0x00, 0xF0, 0x0E, 0x0E, 0x00, 0x70,
  0x0E, 0x1C, 0x00, 0x70, 0x1E, 0x3C, 0x00, 0x78, 0x1C, 0x38, 0x00, 0x3F,
  0xFC, 0x70, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3E, 0x1E, 0x00, 0x79, 0xE0, 0x78, 0x07, 0x8E, 0x03, 0xE0, 0x3C,
  0xF0, 0x0F, 0x03, 0xC7, 0x80, 0x3C, 0x1C, 0x3C, 0x00, 0xF1, 0xE1, 0xE0,
  0x07, 0xDE, 0x0F, 0x00, 0x1E, 0xF0, 0x78, 0x00, 0x7F, 0x03, 0xC0, 0x01,
  0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xF0,
  0x1C, 0x00, 0x3F, 0xC0, 0xF0, 0x01, 0xFE, 0x07, 0xC0, 0x3E, 0x78, 0x1F,
  0x03, 0xE1, 0xE0, 0xFF, 0xFE, 0x07, 0x83, 0xFF, 0xE0, 0x3C, 0x07, 0xFC,
  0x00, 0xF8, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xDE, 0xF7, 0xBD, 0xEE, 0x70, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x07, 0x80, 0x13, 0xC0, 0x38, 0x07,
  0xDF, 0xC1, 0xC0, 0xFF, 0xFF, 0x86, 0x3F, 0xF3, 0xFF, 0x33, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E,
  0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x18, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0xE0, 0x00,
  0xFC, 0x70, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x1C, 0x00, 0x78, 0x0E, 0x00,
  0x30, 0x07, 0x00, 0x10, 0x03, 0x80, 0x10, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7E, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0xC0, 0x07, 0x87, 0xC0, 0x3F, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0xC0, 0x3C, 0x7F, 0xF0, 0x7B, 0xFF, 0xF0, 0xFF, 0xCF, 0xF1, 0xFC, 0x03,
  0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x01, 0xE3, 0xC0, 0x07, 0xC7, 0xE0, 0x1F, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x1F, 0xC0,
  0x07, 0xBF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x83, 0xF0, 0x03,
  0xE1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE1,
  0xE0, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xF0, 0x07, 0xC7, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x83,
  0xE0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xF0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xC7, 0xC0, 0x03,
  0xE1, 0xF0, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x78, 0x07, 0xFF,
  0x78, 0x00, 0xFE, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xF7,
  0xFB, 0xFD, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x3F, 0x3F,
  0xDF, 0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x10, 0x0F, 0xC3, 0xFC, 0xFF, 0x9F,
  0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0xE7, 0xF0, 0x0F, 0xFF,
  0x7F, 0x01, 0xF0, 0x37, 0xF0, 0x1E, 0x01, 0xFF, 0x01, 0xE0, 0x0F, 0xF0,
  0x1C, 0x00, 0xFF, 0x01, 0xC0, 0x0F, 0xF0, 0x1C, 0x00, 0xFF, 0x01, 0xC0,
  0x0F, 0xF0, 0x1C, 0x00, 0xFF, 0x01, 0xC0, 0x0F, 0xF0, 0x1C, 0x00, 0xFF,
  0x01, 0xC0, 0x0F, 0xF0, 0x1C, 0x00, 0xFF, 0x01, 0xC0, 0x0F, 0xF0, 0x1C,
  0x00, 0xFF, 0x01, 0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x01, 0xE0, 0x1F,
  0xF0, 0x0F, 0x83, 0x7F, 0x00, 0xFF, 0xF7, 0xF0, 0x07, 0xFE, 0x7F, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x0F,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x07,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1E,
  0x00, 0xE0, 0x03, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x1E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x87, 0x00, 0xFF, 0x8E, 0x00, 0x1F, 0x1C, 0x00, 0x1F,
  0x38, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8,
  0x00, 0x0F, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0xF9, 0xC0, 0x03, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x38, 0x00,
  0x7E, 0x70, 0x00, 0x3E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7,
  0x00, 0x03, 0xEE, 0x00, 0x0F, 0x9C, 0x00, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38, 0x1F, 0xF8, 0xE0, 0x03,
  0xF3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8,
  0x00, 0x3C, 0xE0, 0x03, 0xF3, 0x80, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0xF8,
  0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3,
  0x80, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x3C,
  0x03, 0x80, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x0F,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0x00,
  0xF0, 0x03, 0x80, 0x7C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x70,
  0x03, 0xC0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3E, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF8,
  0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0xE7, 0xEF, 0x00, 0xE7,
  0xE7, 0x00, 0xE7, 0xE7, 0x01, 0xC7, 0xE3, 0x81, 0xCF, 0xE3, 0x81, 0xCF,
  0xE3, 0x83, 0x8F, 0xE1, 0xC3, 0x8F, 0xE1, 0xC3, 0x8F, 0xE1, 0xC7, 0x0F,
  0xE0, 0xE7, 0x0F, 0xE0, 0xE7, 0x0F, 0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0xE0, 0x03, 0xFB, 0xC0,
  0x0F, 0xE7, 0x00, 0x3F, 0x9C, 0x00, 0xFE, 0x78, 0x03, 0xF8, 0xE0, 0x0F,
  0xE3, 0x80, 0x3F, 0x8F, 0x00, 0xFE, 0x1C, 0x03, 0xF8, 0x78, 0x0F, 0xE0,
  0xE0, 0x3F, 0x83, 0x80, 0xFE, 0x0F, 0x03, 0xF8, 0x1C, 0x0F, 0xE0, 0x70,
  0x3F, 0x80, 0xE0, 0xFE, 0x03, 0x83, 0xF8, 0x0F, 0x0F, 0xE0, 0x1C, 0x3F,
  0x80, 0x70, 0xFE, 0x01, 0xE3, 0xF8, 0x03, 0x8F, 0xE0, 0x0F, 0x3F, 0x80,
  0x1C, 0xFE, 0x00, 0x73, 0xF8, 0x01, 0xEF, 0xE0, 0x03, 0xBF, 0x80, 0x0E,
  0xFE, 0x00, 0x3D, 0xF8, 0x00, 0x77, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x07, 0x87, 0x80,
  0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x73, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x3F, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0xF8, 0xE0, 0x00, 0x7C,
  0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0xF8, 0xE0, 0x00, 0xF8,
  0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3E,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xFC, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0,
  0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x7C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1F,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE3, 0xE0, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x00,
  0xF0, 0xF8, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0xF8, 0x03, 0xBC, 0x03, 0xF0,
  0x0E, 0xF0, 0x0F, 0xC0, 0x39, 0xC0, 0x3F, 0x00, 0xE7, 0x00, 0xDC, 0x03,
  0x9C, 0x03, 0x30, 0x1E, 0x70, 0x0C, 0xC0, 0x79, 0xC0, 0x33, 0x01, 0xE7,
  0x81, 0xCC, 0x07, 0x1E, 0x07, 0x38, 0x1C, 0x78, 0x1C, 0xE0, 0x70, 0xE0,
  0x73, 0x81, 0xC3, 0x81, 0x8E, 0x07, 0x0E, 0x06, 0x18, 0x1C, 0x38, 0x18,
  0x60, 0xF0, 0xE0, 0xE1, 0x83, 0xC3, 0xC3, 0x86, 0x0E, 0x0F, 0x0E, 0x1C,
  0x38, 0x3C, 0x38, 0x70, 0xE0, 0xF0, 0xC1, 0xC3, 0x81, 0xC3, 0x07, 0x0E,
  0x07, 0x0C, 0x0C, 0x38, 0x1C, 0x30, 0x30, 0xE0, 0x71, 0xC0, 0xC7, 0x81,
  0xC7, 0x03, 0x1E, 0x07, 0x9C, 0x0E, 0x70, 0x1E, 0x60, 0x39, 0xC0, 0x79,
  0x80, 0xE7, 0x00, 0xE6, 0x03, 0x9C, 0x03, 0x98, 0x06, 0x70, 0x0E, 0xE0,
  0x19, 0xC0, 0x3B, 0x80, 0x67, 0x00, 0xEE, 0x01, 0xBC, 0x03, 0xB0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0x70, 0xE0, 0x00,
  0xF3, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x80,
  0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0xFF, 0x3F, 0xFF,
  0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x0F, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x0F, 0xF0, 0x38, 0xFF, 0xF0, 0xE7, 0xFF, 0xE3, 0xBC, 0x0F,
  0xCE, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x1E, 0xEC, 0x00, 0xFB, 0xB8, 0x07, 0xCE, 0x7F, 0xFE, 0x38, 0xFF, 0xF0,
  0xE1, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x9E,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xDC, 0x00, 0x03,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x78, 0xF8, 0x01, 0xF0,
  0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0xF8, 0x78, 0x3F, 0xFC,
  0xF1, 0xFF, 0xFD, 0xE3, 0xE0, 0x3B, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x1F,
  0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xF3, 0xC0, 0x07,
  0xE7, 0xE0, 0x3F, 0xC7, 0xFF, 0xF7, 0x87, 0xFF, 0xCF, 0x03, 0xFE, 0x1E,
  0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x07, 0x3C,
  0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x78, 0xF0, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFE, 0x1E, 0x0F, 0xFF, 0x3C, 0x7F, 0xFF, 0x78, 0xF8, 0x0E,
  0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x9E, 0x00, 0x3F, 0x3E, 0x00,
  0xFE, 0x3F, 0x87, 0xBC, 0x3F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0, 0x0F, 0xC1,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x0F, 0xF0, 0x38, 0xFF, 0xF0, 0xE7, 0xFF, 0xE3, 0xBC,
  0x0F, 0xCE, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0,
  0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0xE3,
  0xF0, 0xFE, 0x73, 0xFC, 0xFF, 0xBB, 0xFF, 0x7F, 0xDD, 0x07, 0xE0, 0xFF,
  0x01, 0xE0, 0x7F, 0x80, 0xF0, 0x1F, 0xC0, 0x70, 0x0F, 0xE0, 0x38, 0x07,
  0xF0, 0x1C, 0x03, 0xF8, 0x0E, 0x01, 0xFC, 0x07, 0x00, 0xFE, 0x03, 0x80,
  0x7F, 0x01, 0xC0, 0x3F, 0x80, 0xE0, 0x1F, 0xC0, 0x70, 0x0F, 0xE0, 0x38,
  0x07, 0xF0, 0x1C, 0x03, 0xF8, 0x0E, 0x01, 0xFC, 0x07, 0x00, 0xFE, 0x03,
  0x80, 0x7F, 0x01, 0xC0, 0x3F, 0x80, 0xE0, 0x1F, 0xC0, 0x70, 0x0F, 0xE0,
  0x38, 0x07, 0xF0, 0x1C, 0x03, 0xF8, 0x0E, 0x01, 0xFC, 0x07, 0x00, 0xFE,
  0x03, 0x80, 0x7F, 0x01, 0xC0, 0x3F, 0x80, 0xE0, 0x1F, 0xC0, 0x70, 0x0E,
  0xE0, 0xFF, 0x03, 0x8F, 0xFF, 0x0E, 0x7F, 0xFE, 0x3B, 0xC0, 0xFC, 0xEC,
  0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x1C, 0xF8, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xE0, 0xFF,
  0x03, 0x8F, 0xFF, 0x0E, 0x7F, 0xFE, 0x3B, 0xC0, 0xFC, 0xEC, 0x00, 0xFB,
  0xE0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xEE, 0xC0, 0x0F,
  0xBB, 0x80, 0x7C, 0xE7, 0xFF, 0xE3, 0x8F, 0xFF, 0x0E, 0x1F, 0xF8, 0x38,
  0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x1E, 0x0F, 0xFF, 0x3C, 0x7F, 0xFF, 0x78,
  0xF8, 0x0E, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xBC,
  0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF0, 0x01, 0xF9, 0xF8, 0x0F, 0xF1,
  0xFF, 0xFD, 0xE1, 0xFF, 0xF3, 0xC0, 0xFF, 0x87, 0x80, 0x10, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0xE0, 0xFF, 0x03, 0x8F, 0xFF, 0x0E, 0x7F, 0xFE, 0x3B, 0x80, 0x7C,
  0xEC, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0x00, 0xFC, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x0F, 0x80, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x78,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3B, 0x80, 0x3C, 0x01, 0xDC, 0x01, 0xE0,
  0x1E, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x07, 0x3C, 0x06, 0xE0, 0x38,
  0xE0, 0x37, 0x01, 0xC7, 0x01, 0x98, 0x0E, 0x38, 0x0C, 0xC0, 0x71, 0xC0,
  0xE6, 0x07, 0x8E, 0x07, 0x30, 0x38, 0x78, 0x31, 0xC1, 0xC3, 0xC1, 0x8E,
  0x0E, 0x0E, 0x0C, 0x30, 0x70, 0x70, 0xE1, 0x83, 0x83, 0x87, 0x0C, 0x3C,
  0x1C, 0x38, 0x71, 0xC0, 0xF1, 0x83, 0x8E, 0x07, 0x8C, 0x1C, 0x70, 0x1C,
  0x60, 0x63, 0x80, 0xE7, 0x03, 0x1C, 0x07, 0x38, 0x19, 0xE0, 0x39, 0x80,
  0xEE, 0x01, 0xEC, 0x07, 0x70, 0x0F, 0x60, 0x3B, 0x80, 0x3F, 0x00, 0xDC,
  0x01, 0xF8, 0x06, 0xE0, 0x0F, 0xC0, 0x37, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x9F, 0xF0, 0x01, 0xDF, 0xFE, 0x00, 0xEF, 0x0F, 0x00, 0x7F, 0x03,
  0xC0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x3C, 0x1F, 0xE0, 0x0F, 0xBF, 0xF0,
  0x03, 0xFF, 0x78, 0x00, 0xFF, 0x3C, 0x00, 0x1C, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 41, 34, 13, -41 },
  { 42, 16, 17, 34, 9, -41 },
  { 76, 30, 41, 34, 2, -41 },
  { 230, 25, 57, 34, 4, -49 },
  { 409, 32, 41, 34, 1, -41 },
  { 573, 29, 42, 34, 3, -41 },
  { 726, 5, 17, 34, 14, -41 },
  { 737, 16, 54, 34, 11, -47 },
  { 845, 17, 54, 34, 6, -47 },
  { 960, 29, 28, 34, 2, -34 },
  { 1062, 26, 27, 34, 4, -32 },
  { 1150, 10, 17, 34, 10, -8 },
  { 1172, 18, 3, 34, 8, -20 },
  { 1179, 9, 9, 34, 12, -8 },
  { 1190, 24, 52, 34, 5, -46 },
  { 1346, 24, 42, 34, 5, -41 },
  { 1472, 25, 41, 34, 5, -41 },
  { 1601, 26, 41, 34, 4, -41 },
  { 1735, 23, 42, 34, 5, -41 },
  { 1856, 23, 41, 34, 5, -41 },
  { 1974, 23, 42, 34, 5, -41 },
  { 2095, 25, 42, 34, 4, -41 },
  { 2227, 25, 41, 34, 5, -41 },
  { 2356, 24, 42, 34, 5, -41 },
  { 2482, 25, 41, 34, 4, -41 },
  { 2611, 9, 32, 34, 12, -31 },
  { 2647, 11, 40, 34, 10, -31 },
  { 2702, 24, 29, 34, 5, -33 },
  { 2789, 24, 17, 34, 5, -27 },
  { 2840, 24, 29, 34, 5, -33 },
  { 2927, 19, 41, 34, 9, -41 },
  { 3025, 28, 51, 34, 3, -41 },
  { 3204, 27, 41, 34, 3, -41 },
  { 3343, 23, 41, 34, 6, -41 },
  { 3461, 24, 42, 34, 5, -41 },
  { 3587, 22, 41, 34, 6, -41 },
  { 3700, 23, 41, 34, 6, -41 },
  { 3818, 23, 41, 34, 6, -41 },
  { 3936, 24, 42, 34, 5, -41 },
  { 4062, 22, 41, 34, 6, -41 },
  { 4175, 21, 41, 34, 6, -41 },
  { 4283, 24, 42, 34, 3, -41 },
  { 4409, 25, 41, 34, 6, -41 },
  { 4538, 23, 41, 34, 7, -41 },
  { 4656, 24, 41, 34, 5, -41 },
  { 4779, 22, 41, 34, 6, -41 },
  { 4892, 23, 42, 34, 5, -41 },
  { 5013, 24, 41, 34, 6, -41 },
  { 5136, 24, 51, 34, 5, -41 },
  { 5289, 24, 41, 34, 6, -41 },
  { 5412, 25, 42, 34, 4, -41 },
  { 5544, 27, 41, 34, 3, -41 },
  { 5683, 22, 42, 34, 6, -41 },
  { 5799, 27, 41, 34, 3, -41 },
  { 5938, 30, 41, 34, 2, -41 },
  { 6092, 28, 41, 34, 3, -41 },
  { 6236, 29, 41, 34, 2, -41 },
  { 6385, 24, 41, 34, 5, -41 },
  { 6508, 13, 52, 34, 12, -46 },
  { 6593, 24, 52, 34, 5, -46 },
  { 6749, 13, 52, 34, 9, -46 },
  { 6834, 23, 22, 34, 5, -41 },
  { 6898, 27, 4, 34, 3, 1 },
  { 6912, 10, 8, 34, 11, -44 },
  { 6922, 24, 32, 34, 4, -31 },
  { 7018, 22, 42, 34, 6, -41 },
  { 7134, 23, 32, 34, 5, -31 },
  { 7226, 23, 42, 34, 5, -41 },
  { 7347, 23, 32, 34, 5, -31 },
  { 7439, 26, 41, 34, 4, -41 },
  { 7573, 23, 41, 34, 5, -31 },
  { 7691, 22, 41, 34, 6, -41 },
  { 7804, 25, 43, 34, 5, -43 },
  { 7939, 20, 53, 34, 5, -43 },
  { 8072, 24, 41, 34, 6, -41 },
  { 8195, 28, 41, 34, 2, -41 },
  { 8339, 25, 31, 34, 4, -31 },
  { 8436, 22, 31, 34, 6, -31 },
  { 8522, 23, 32, 34, 5, -31 },
  { 8614, 22, 41, 34, 6, -31 },
  { 8727, 23, 41, 34, 5, -31 },
  { 8845, 22, 31, 34, 7, -31 },
  { 8931, 24, 32, 34, 5, -31 },
  { 9027, 25, 39, 34, 4, -39 },
  { 9149, 22, 32, 34, 6, -31 },
  { 9237, 26, 31, 34, 4, -31 },
  { 9338, 29, 31, 34, 2, -31 },
  { 9451, 26, 31, 34, 4, -31 },
  { 9552, 26, 41, 34, 4, -31 },
  { 9686, 23, 31, 34, 5, -31 },
  { 9776, 23, 52, 34, 5, -46 },
  { 9926, 4, 52, 34, 15, -46 },
  { 9952, 23, 52, 34, 5, -46 },
  { 10102, 25, 11, 34, 4, -25 },
};

const GFXfont JetBrainsMono_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_EXTRALIGHT56PT7B_H_
