#ifndef _JETBRAINSMONO_EXTRALIGHT12PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x45, 0x3F, 0x24,
  0x48, 0x23, 0xAB, 0x4A, 0x38, 0xA5, 0xAB, 0xC8, 0x40, 0x63, 0x2A, 0x53,
  0x41, 0x05, 0x8A, 0xA5, 0x8E, 0x72, 0x48, 0x90, 0xC6, 0xA9, 0xA6, 0xEC,
  0xF0, 0x34, 0x48, 0x88, 0x88, 0x44, 0x30, 0xC2, 0x11, 0x11, 0x11, 0x12,
  0xC0, 0x11, 0x25, 0xF0, 0x82, 0x88, 0x80, 0x21, 0x09, 0xF2, 0x10, 0x5A,
  0xF0, 0xB0, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x74, 0x63, 0x1A,
  0xC6, 0x31, 0x70, 0x23, 0x28, 0x42, 0x10, 0x84, 0xF8, 0x74, 0x62, 0x10,
  0x88, 0x88, 0xF8, 0xF8, 0x84, 0x41, 0x84, 0x31, 0x70, 0x10, 0x88, 0x84,
  0xC7, 0xE1, 0x08, 0xFC, 0x21, 0x6C, 0x84, 0x31, 0x70, 0x11, 0x10, 0x8F,
  0xC6, 0x31, 0x70, 0xFC, 0x62, 0x21, 0x08, 0x84, 0x60, 0x74, 0x62, 0x93,
  0x66, 0x31, 0x70, 0x74, 0x63, 0x19, 0xB4, 0x44, 0x60, 0xB0, 0x2C, 0x4C,
  0x00, 0x94, 0x80, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83, 0x06,
  0x36, 0x40, 0xE1, 0x11, 0x64, 0x40, 0xC0, 0x72, 0x28, 0x6F, 0xA6, 0x9A,
  0x6B, 0x92, 0x07, 0x00, 0x21, 0x14, 0xA5, 0x27, 0xF1, 0x88, 0xF4, 0x63,
  0x1F, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x42, 0x11, 0x70, 0xF4, 0x63,
  0x18, 0xC6, 0x31, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC, 0x21,
  0x0F, 0xC2, 0x10, 0x80, 0x74, 0x63, 0x08, 0x5E, 0x31, 0x70, 0x8C, 0x63,
  0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x38, 0x42,
  0x10, 0x84, 0x31, 0xF0, 0x8A, 0x29, 0x24, 0xE2, 0x49, 0x22, 0x8C, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x8E, 0xF7, 0xBA, 0xC6, 0x31, 0x88, 0x8E,
  0x73, 0x5A, 0xD6, 0x73, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF4,
  0x63, 0x1F, 0xC2, 0x10, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x82,
  0xF4, 0x63, 0x1F, 0xCA, 0x51, 0x88, 0x74, 0x61, 0x07, 0x04, 0x31, 0x78,
  0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x70, 0x8C, 0x62, 0x95, 0x29, 0x46, 0x20, 0x93, 0x25, 0x4B, 0x56, 0xCD,
  0x9B, 0x36, 0x64, 0x8A, 0x25, 0x14, 0x21, 0x45, 0x22, 0x8C, 0x86, 0x24,
  0x94, 0x30, 0x82, 0x08, 0x20, 0xF8, 0x44, 0x22, 0x11, 0x10, 0xF8, 0xEA,
  0xAA, 0xAC, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0xE4, 0x92, 0x49,
  0x27, 0x80, 0x21, 0x94, 0x98, 0x80, 0xF8, 0xE0, 0x74, 0x42, 0xF8, 0xC7,
  0xE0, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x45, 0xC0,
  0x08, 0x5F, 0x18, 0xC6, 0x31, 0x78, 0x74, 0x63, 0xF8, 0x45, 0xC0, 0x39,
  0x09, 0xF2, 0x10, 0x84, 0x20, 0x7C, 0x63, 0x18, 0xEC, 0xA1, 0x78, 0x84,
  0x2D, 0x98, 0xC6, 0x31, 0x88, 0x30, 0x0E, 0x08, 0x20, 0x82, 0x08, 0xFC,
  0x10, 0xF1, 0x11, 0x11, 0x11, 0xF0, 0x84, 0x23, 0x19, 0x72, 0x51, 0x88,
  0xE0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1E, 0xDD, 0x6B, 0x5A, 0xD6,
  0xA0, 0xB6, 0x63, 0x18, 0xC6, 0x20, 0x74, 0x63, 0x18, 0xC5, 0xC0, 0xB6,
  0x63, 0x18, 0xC7, 0xD0, 0x80, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0xB6,
  0x63, 0x08, 0x42, 0x00, 0x74, 0x60, 0xE0, 0xC5, 0xE0, 0x27, 0xC8, 0x42,
  0x10, 0x87, 0x8C, 0x63, 0x18, 0xC5, 0xC0, 0x8C, 0x62, 0xA5, 0x28, 0x80,
  0xA6, 0x9A, 0xB6, 0xDB, 0x64, 0x80, 0x8A, 0x54, 0x45, 0x2A, 0x20, 0x8C,
  0x52, 0xA5, 0x10, 0x84, 0x40, 0xF8, 0x44, 0x44, 0x23, 0xE0, 0x19, 0x08,
  0x41, 0x70, 0x82, 0x21, 0x06, 0xFF, 0xE0, 0xC1, 0x08, 0x42, 0x1C, 0x84,
  0x21, 0x30, 0xEC, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 4, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 12, 7, 1, -10 },
  { 21, 7, 9, 7, 0, -9 },
  { 29, 6, 9, 7, 1, -9 },
  { 36, 1, 4, 7, 3, -9 },
  { 37, 4, 11, 7, 2, -10 },
  { 43, 4, 11, 7, 1, -10 },
  { 49, 7, 6, 7, 0, -7 },
  { 55, 5, 6, 7, 1, -7 },
  { 59, 2, 4, 7, 2, -2 },
  { 60, 4, 1, 7, 2, -4 },
  { 61, 2, 2, 7, 3, -2 },
  { 62, 5, 11, 7, 1, -10 },
  { 69, 5, 9, 7, 1, -9 },
  { 75, 5, 9, 7, 1, -9 },
  { 81, 5, 9, 7, 1, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 5, 9, 7, 1, -9 },
  { 99, 5, 9, 7, 1, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 2, 7, 7, 3, -7 },
  { 131, 3, 9, 7, 2, -7 },
  { 135, 5, 6, 7, 1, -7 },
  { 139, 5, 4, 7, 1, -6 },
  { 142, 5, 6, 7, 1, -7 },
  { 146, 4, 9, 7, 2, -9 },
  { 151, 6, 11, 7, 1, -9 },
  { 160, 5, 9, 7, 1, -9 },
  { 166, 5, 9, 7, 1, -9 },
  { 172, 5, 9, 7, 1, -9 },
  { 178, 5, 9, 7, 1, -9 },
  { 184, 5, 9, 7, 1, -9 },
  { 190, 5, 9, 7, 1, -9 },
  { 196, 5, 9, 7, 1, -9 },
  { 202, 5, 9, 7, 1, -9 },
  { 208, 5, 9, 7, 1, -9 },
  { 214, 5, 9, 7, 1, -9 },
  { 220, 6, 9, 7, 1, -9 },
  { 227, 5, 9, 7, 1, -9 },
  { 233, 5, 9, 7, 1, -9 },
  { 239, 5, 9, 7, 1, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 5, 11, 7, 1, -9 },
  { 264, 5, 9, 7, 1, -9 },
  { 270, 5, 9, 7, 1, -9 },
  { 276, 6, 9, 7, 1, -9 },
  { 283, 5, 9, 7, 1, -9 },
  { 289, 5, 9, 7, 1, -9 },
  { 295, 7, 9, 7, 0, -9 },
  { 303, 6, 9, 7, 1, -9 },
  { 310, 6, 9, 7, 1, -9 },
  { 317, 5, 9, 7, 1, -9 },
  { 323, 2, 11, 7, 3, -10 },
  { 326, 5, 11, 7, 1, -10 },
  { 333, 3, 11, 7, 2, -10 },
  { 338, 5, 5, 7, 1, -9 },
  { 342, 5, 1, 7, 1, 0 },
  { 343, 3, 1, 7, 2, -9 },
  { 344, 5, 7, 7, 1, -7 },
  { 349, 5, 9, 7, 1, -9 },
  { 355, 5, 7, 7, 1, -7 },
  { 360, 5, 9, 7, 1, -9 },
  { 366, 5, 7, 7, 1, -7 },
  { 371, 5, 9, 7, 1, -9 },
  { 377, 5, 9, 7, 1, -7 },
  { 383, 5, 9, 7, 1, -9 },
  { 389, 6, 9, 7, 1, -9 },
  { 396, 4, 11, 7, 1, -9 },
  { 402, 5, 9, 7, 1, -9 },
  { 408, 7, 9, 7, 0, -9 },
  { 416, 5, 7, 7, 1, -7 },
  { 421, 5, 7, 7, 1, -7 },
  { 426, 5, 7, 7, 1, -7 },
  { 431, 5, 9, 7, 1, -7 },
  { 437, 5, 9, 7, 1, -7 },
  { 443, 5, 7, 7, 1, -7 },
  { 448, 5, 7, 7, 1, -7 },
  { 453, 5, 8, 7, 1, -8 },
  { 458, 5, 7, 7, 1, -7 },
  { 463, 5, 7, 7, 1, -7 },
  { 468, 6, 7, 7, 1, -7 },
  { 474, 5, 7, 7, 1, -7 },
  { 479, 5, 9, 7, 1, -7 },
  { 485, 5, 7, 7, 1, -7 },
  { 490, 5, 11, 7, 1, -10 },
  { 497, 1, 11, 7, 3, -10 },
  { 499, 5, 11, 7, 1, -10 },
  { 506, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_EXTRALIGHT12PT7B_H_
