#ifndef _JETBRAINSMONO_EXTRALIGHT40PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0x00, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF6, 0x07, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x70,
  0x18, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x60,
  0x38, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x3C, 0xCF, 0x0E, 0x30, 0xE7, 0x0C, 0x39, 0xC3,
  0x06, 0x70, 0xC1, 0x9C, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x38, 0xC0,
  0x0F, 0x30, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x0C, 0xF0, 0x03, 0x1E, 0x00, 0xC3, 0x80, 0x30, 0x70, 0x0C, 0x1C, 0x03,
  0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x77, 0x0C, 0x39, 0xC3, 0x0E, 0x3C, 0xCF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x0D, 0xFF, 0x00,
  0x6E, 0x0C, 0x03, 0x38, 0x30, 0x1C, 0xC0, 0xE0, 0x63, 0x03, 0x83, 0x0C,
  0x0E, 0x1C, 0x30, 0x38, 0x60, 0xC0, 0xE3, 0x03, 0x83, 0x1C, 0x07, 0x1C,
  0x60, 0x1F, 0xE3, 0x00, 0x1F, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE3, 0xF0, 0x03, 0x1F, 0xE0, 0x18, 0xE1, 0x80,
  0xE3, 0x07, 0x03, 0x1C, 0x0C, 0x18, 0x70, 0x30, 0xC1, 0xC0, 0xC3, 0x07,
  0x03, 0x18, 0x1C, 0x0C, 0xC0, 0x30, 0x77, 0x00, 0xE1, 0x98, 0x01, 0xFE,
  0xC0, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3C,
  0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x38, 0x00, 0x70, 0xE0, 0x73,
  0x07, 0x07, 0x38, 0x1C, 0x39, 0xC0, 0x73, 0x8E, 0x01, 0xD8, 0x70, 0x0F,
  0xC3, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0xE0, 0x0F, 0x03, 0x00, 0x7C, 0x1C,
  0x07, 0x70, 0xF0, 0xF1, 0xC3, 0xFF, 0x06, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF,
  0xFF, 0x6D, 0xB0, 0x00, 0x20, 0x1C, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0x08, 0x80, 0x1C, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x81,
  0xC0, 0x20, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x60, 0x7F, 0xC6, 0x3F, 0x7F,
  0x6F, 0xE0, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x39, 0xC0, 0x07, 0x9C, 0x00, 0x70, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0x78,
  0x1C, 0x03, 0x80, 0x80, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x1F, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0xE0,
  0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0x83,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0x70, 0x0E, 0x7C, 0x3E, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xE0, 0x03, 0xF0,
  0x07, 0xB8, 0x07, 0x9C, 0x07, 0x8E, 0x07, 0x07, 0x03, 0x03, 0x81, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x70, 0x07, 0x9C, 0x00, 0xEE,
  0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x07, 0x38,
  0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x7F, 0xFE, 0x7F, 0xFE, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE7, 0xF0, 0xEF, 0xFC, 0xFC, 0x3E, 0xF0, 0x0E, 0xF0, 0x07,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E,
  0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x73, 0xC0, 0x3B, 0xFC, 0x0F, 0xCF, 0xC7,
  0x80, 0x71, 0xC0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x03,
  0x8E, 0x01, 0xC3, 0xC0, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0,
  0x3C, 0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x06, 0x70, 0x03,
  0x9C, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x1E, 0x1E, 0x03, 0xEF, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x3C, 0x07, 0x03, 0x83, 0x80, 0x71, 0xC0,
  0x0E, 0x60, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01,
  0x9C, 0x00, 0xE7, 0x80, 0x78, 0xF0, 0x3C, 0x1F, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9C,
  0x00, 0xE6, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x38, 0xF0, 0x3E,
  0x1F, 0xFF, 0x03, 0xFD, 0xC0, 0x38, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD,
  0xE0, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x07, 0xC1, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81,
  0xE0, 0x3C, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07,
  0x60, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF3, 0xE0, 0x7F,
  0xBE, 0x0E, 0x0F, 0xE0, 0xE0, 0x7E, 0x0C, 0x07, 0xE0, 0xC0, 0x3E, 0x0C,
  0x03, 0xE0, 0xC0, 0x3E, 0x0C, 0x03, 0xE0, 0xC0, 0x3E, 0x0C, 0x03, 0xE0,
  0xC0, 0x7E, 0x0C, 0x07, 0xE0, 0xE0, 0x7E, 0x07, 0x9B, 0xE0, 0x7F, 0xBE,
  0x01, 0xE0, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0x98, 0x00, 0x19, 0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0,
  0x00, 0x70, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x0F, 0x9C, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xCE, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xF1, 0xC0, 0x3C,
  0xE0, 0x0F, 0x70, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x1F, 0x9F,
  0xFF, 0x8F, 0xFF, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0x03,
  0xC7, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0x9C,
  0x03, 0x87, 0x83, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xE0, 0xFF, 0xF8,
  0xE0, 0x7C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF3,
  0xFF, 0xF9, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0x03, 0xC7, 0x00, 0xF7, 0x00, 0x3B, 0x80,
  0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x06, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x03, 0x87, 0x83, 0xC3, 0xFF, 0xC0,
  0x7F, 0x80, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x07, 0x70, 0x03, 0xBC, 0x03, 0x8F, 0x03,
  0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x38, 0x38, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xC0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF6,
  0x01, 0xBF, 0x80, 0x7F, 0xE0, 0x1F, 0xEC, 0x0D, 0xFB, 0x03, 0x7E, 0xC0,
  0xDF, 0x98, 0x67, 0xE6, 0x19, 0xF9, 0xC6, 0x7E, 0x33, 0x1F, 0x8C, 0xC7,
  0xE3, 0xB1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xD8, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xEC, 0x07, 0xEE, 0x07, 0xE6, 0x07, 0xE6, 0x07, 0xE7,
  0x07, 0xE3, 0x07, 0xE3, 0x07, 0xE3, 0x87, 0xE1, 0x87, 0xE1, 0xC7, 0xE0,
  0xC7, 0xE0, 0xC7, 0xE0, 0xE7, 0xE0, 0x67, 0xE0, 0x77, 0xE0, 0x37, 0xE0,
  0x37, 0xE0, 0x3F, 0xE0, 0x1B, 0xE0, 0x1B, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8E, 0x01, 0xF3, 0x80, 0x1C, 0xE0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x07, 0xF8, 0x0F,
  0xFF, 0x0F, 0x03, 0xC7, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0x9C, 0x03, 0x8F, 0x03, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x0F, 0x9C, 0x00, 0xEE, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x01, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF0,
  0x3C, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x19, 0xC0, 0x06, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xDC, 0x00, 0xE7, 0x80, 0x38, 0xF0, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x3F, 0xFC, 0x0F, 0xF0, 0xE0,
  0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0xE0, 0x70, 0x0E, 0x07,
  0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x30,
  0xC0, 0x03, 0x8C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0x80, 0x01,
  0xD8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x78, 0x1D, 0x81, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x60,
  0x78, 0x19, 0xC1, 0xA0, 0x67, 0x04, 0xC3, 0x9C, 0x13, 0x0E, 0x70, 0xCC,
  0x38, 0xC3, 0x30, 0xC3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x30, 0xCC, 0x30,
  0xC3, 0x10, 0xC3, 0x88, 0x63, 0x0E, 0x61, 0x9C, 0x39, 0x86, 0x70, 0xE6,
  0x19, 0xC1, 0x98, 0x66, 0x06, 0x61, 0x98, 0x19, 0x86, 0x60, 0x64, 0x09,
  0x81, 0x90, 0x36, 0x07, 0xC0, 0xD8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0E, 0x03, 0xC0, 0xF0, 0x00, 0xF7, 0x00,
  0x0E, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x80, 0xE0, 0x30, 0x0E,
  0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x07, 0x06,
  0x00, 0xE0, 0x70, 0x0C, 0x03, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x76,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x18,
  0x1C, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E,
  0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F,
  0xFF, 0xF8, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38,
  0x18, 0x18, 0x38, 0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0x03, 0xC7, 0x00, 0xE7, 0x00, 0x3B, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF7, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xF3, 0xFF, 0xB8, 0xFF, 0x9C, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0E, 0xF8, 0x1E, 0xEF, 0xFC, 0xE7, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7C, 0x1E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x7C,
  0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x1F, 0xE7, 0x3F, 0xF7, 0x78,
  0x1F, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x78, 0x1F, 0x3F,
  0xF7, 0x1F, 0xE7, 0x0F, 0xF0, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE7, 0x3F, 0xF7, 0x78, 0x1F, 0x70,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x0F, 0x78, 0x1F, 0x3F, 0xF7, 0x1F, 0xE7, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x1F,
  0xFC, 0x1F, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0xFF, 0xC3, 0xFE, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F,
  0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x38,
  0x0E, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0x70,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0xCF, 0x9F, 0x37, 0xEF, 0xEE, 0x1E, 0x1F, 0x83, 0x07, 0xC0, 0xC0,
  0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C,
  0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03,
  0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0,
  0xF0, 0x30, 0x30, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x0F,
  0xF0, 0x3F, 0xFC, 0x38, 0x1C, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70,
  0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0xE7, 0xF8, 0xEF, 0xFC, 0xF8,
  0x1E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0E, 0xF8, 0x1E, 0xEF,
  0xFC, 0xE7, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xE7, 0x3F, 0xF7, 0x78, 0x1F, 0x70,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x78, 0x1F, 0x3F, 0xF7, 0x1F,
  0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xC7, 0xF0, 0xCF, 0xFC, 0xD8, 0x1E, 0xF0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x1F,
  0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0x78, 0x0F, 0x3F, 0xFE, 0x1F, 0xF8, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x3F,
  0xF8, 0x0F, 0xF0, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x0E,
  0x70, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x18, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x61,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xCC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xC0, 0x60, 0x3C, 0x0F, 0x03, 0xE0, 0xF0,
  0x7E, 0x0F, 0x07, 0x60, 0xF0, 0x66, 0x09, 0x06, 0x60, 0x90, 0x66, 0x19,
  0x86, 0x71, 0x98, 0x67, 0x19, 0x8E, 0x71, 0x98, 0xC3, 0x10, 0x8C, 0x33,
  0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0xB0, 0xDC, 0x1B, 0x0D, 0x81,
  0xA0, 0x58, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0xF0, 0x01, 0xDC, 0x00, 0xE3, 0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x0E, 0x03,
  0x87, 0x00, 0x61, 0xC0, 0x1C, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x70,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x71, 0xC0, 0x0E, 0x70, 0x03, 0xB8,
  0x00, 0x70, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x70,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x03,
  0x80, 0xE0, 0xC0, 0x38, 0x70, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80,
  0x0E, 0xE0, 0x03, 0xB0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xDF, 0xC0, 0x7F, 0x38,
  0x1F, 0x87, 0x07, 0xE0, 0xE1, 0xF8, 0x1E, 0xEE, 0x03, 0xFB, 0x80, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 5, 29, 24, 10, -29 },
  { 20, 12, 12, 24, 6, -29 },
  { 38, 22, 29, 24, 1, -29 },
  { 118, 18, 41, 24, 3, -35 },
  { 211, 22, 29, 24, 1, -29 },
  { 291, 21, 30, 24, 2, -30 },
  { 370, 3, 12, 24, 10, -29 },
  { 375, 11, 39, 24, 8, -34 },
  { 429, 11, 39, 24, 5, -34 },
  { 483, 20, 20, 24, 2, -24 },
  { 533, 18, 19, 24, 3, -23 },
  { 576, 8, 12, 24, 7, -6 },
  { 588, 12, 2, 24, 6, -14 },
  { 591, 6, 6, 24, 9, -6 },
  { 596, 18, 37, 24, 3, -33 },
  { 680, 16, 30, 24, 4, -30 },
  { 740, 17, 29, 24, 4, -29 },
  { 802, 18, 30, 24, 3, -30 },
  { 870, 17, 29, 24, 3, -29 },
  { 932, 16, 29, 24, 4, -29 },
  { 990, 16, 29, 24, 4, -29 },
  { 1048, 18, 29, 24, 3, -29 },
  { 1114, 18, 29, 24, 3, -29 },
  { 1180, 18, 30, 24, 3, -30 },
  { 1248, 18, 30, 24, 3, -30 },
  { 1316, 6, 22, 24, 9, -22 },
  { 1333, 8, 28, 24, 7, -22 },
  { 1361, 16, 20, 24, 4, -23 },
  { 1401, 16, 12, 24, 4, -19 },
  { 1425, 16, 20, 24, 4, -23 },
  { 1465, 14, 29, 24, 6, -29 },
  { 1516, 20, 37, 24, 2, -30 },
  { 1609, 20, 29, 24, 2, -29 },
  { 1682, 17, 29, 24, 4, -29 },
  { 1744, 17, 30, 24, 4, -30 },
  { 1808, 16, 29, 24, 4, -29 },
  { 1866, 17, 29, 24, 4, -29 },
  { 1928, 17, 29, 24, 4, -29 },
  { 1990, 17, 30, 24, 4, -30 },
  { 2054, 16, 29, 24, 4, -29 },
  { 2112, 14, 29, 24, 5, -29 },
  { 2163, 17, 29, 24, 2, -29 },
  { 2225, 18, 29, 24, 4, -29 },
  { 2291, 16, 29, 24, 5, -29 },
  { 2349, 18, 29, 24, 3, -29 },
  { 2415, 16, 29, 24, 4, -29 },
  { 2473, 16, 30, 24, 4, -30 },
  { 2533, 18, 29, 24, 4, -29 },
  { 2599, 17, 37, 24, 4, -30 },
  { 2678, 17, 29, 24, 4, -29 },
  { 2740, 18, 30, 24, 3, -30 },
  { 2808, 20, 29, 24, 2, -29 },
  { 2881, 16, 29, 24, 4, -29 },
  { 2939, 20, 29, 24, 2, -29 },
  { 3012, 22, 29, 24, 1, -29 },
  { 3092, 20, 29, 24, 2, -29 },
  { 3165, 20, 29, 24, 2, -29 },
  { 3238, 16, 29, 24, 4, -29 },
  { 3296, 9, 37, 24, 9, -33 },
  { 3338, 18, 37, 24, 3, -33 },
  { 3422, 9, 37, 24, 6, -33 },
  { 3464, 16, 15, 24, 4, -29 },
  { 3494, 20, 2, 24, 2, 1 },
  { 3499, 7, 5, 24, 8, -31 },
  { 3504, 17, 22, 24, 3, -22 },
  { 3551, 16, 29, 24, 4, -29 },
  { 3609, 16, 22, 24, 4, -22 },
  { 3653, 16, 29, 24, 4, -29 },
  { 3711, 16, 22, 24, 4, -22 },
  { 3755, 18, 29, 24, 3, -29 },
  { 3821, 16, 29, 24, 4, -22 },
  { 3879, 16, 29, 24, 4, -29 },
  { 3937, 18, 31, 24, 4, -31 },
  { 4007, 14, 38, 24, 4, -31 },
  { 4074, 18, 29, 24, 4, -29 },
  { 4140, 20, 29, 24, 2, -29 },
  { 4213, 18, 22, 24, 3, -22 },
  { 4263, 16, 22, 24, 4, -22 },
  { 4307, 16, 22, 24, 4, -22 },
  { 4351, 16, 29, 24, 4, -22 },
  { 4409, 16, 29, 24, 4, -22 },
  { 4467, 16, 22, 24, 5, -22 },
  { 4511, 16, 22, 24, 4, -22 },
  { 4555, 17, 28, 24, 3, -28 },
  { 4615, 16, 22, 24, 4, -22 },
  { 4659, 18, 22, 24, 3, -22 },
  { 4709, 20, 22, 24, 2, -22 },
  { 4764, 18, 22, 24, 3, -22 },
  { 4814, 18, 29, 24, 3, -22 },
  { 4880, 16, 22, 24, 4, -22 },
  { 4924, 16, 37, 24, 4, -33 },
  { 4998, 2, 37, 24, 11, -33 },
  { 5008, 16, 37, 24, 4, -33 },
  { 5082, 18, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_EXTRALIGHT40PT7B_H_
