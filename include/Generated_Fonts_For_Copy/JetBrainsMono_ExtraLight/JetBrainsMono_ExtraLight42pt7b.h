#ifndef _JETBRAINSMONO_EXTRALIGHT42PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0x63, 0x18, 0x00, 0x00, 0x0D, 0xFF, 0xFD, 0xE0, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3E, 0x06, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x18, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C,
  0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xE0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0x80, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0x7F, 0x07, 0x8C, 0x70, 0xE1, 0x87, 0x38,
  0x30, 0xE7, 0x06, 0x0C, 0xE0, 0xC1, 0x9C, 0x18, 0x03, 0x83, 0x00, 0x38,
  0x60, 0x07, 0x0C, 0x00, 0x79, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0x7C, 0x00, 0x63, 0xC0, 0x0C, 0x38, 0x01,
  0x87, 0x00, 0x30, 0x70, 0x06, 0x0F, 0xC0, 0xC1, 0xF8, 0x18, 0x3B, 0x83,
  0x07, 0x70, 0x61, 0xCF, 0x0C, 0x78, 0xF9, 0x9E, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x06, 0x7F, 0x80, 0x1D, 0xC7, 0x00,
  0x37, 0x07, 0x00, 0xCE, 0x06, 0x03, 0x98, 0x0C, 0x0E, 0x30, 0x18, 0x18,
  0x60, 0x30, 0x60, 0xC0, 0x61, 0xC1, 0xC0, 0xC3, 0x03, 0x83, 0x8C, 0x03,
  0x87, 0x38, 0x07, 0xFC, 0x60, 0x03, 0xF1, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE3, 0xE0, 0x03, 0x8F, 0xE0, 0x06,
  0x38, 0xE0, 0x18, 0xE0, 0xE0, 0x71, 0xC0, 0xC0, 0xC3, 0x01, 0x83, 0x06,
  0x03, 0x0E, 0x0C, 0x06, 0x18, 0x18, 0x0C, 0x60, 0x30, 0x19, 0xC0, 0x70,
  0x77, 0x00, 0x71, 0xCC, 0x00, 0xFF, 0xB0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xE0, 0x07, 0xCF, 0x80, 0x78, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0x70, 0x00, 0xE1, 0xC0, 0x77, 0x07, 0x07, 0x30, 0x38, 0x39,
  0x80, 0xE3, 0x8C, 0x03, 0x9C, 0x60, 0x0F, 0xC3, 0x00, 0x7E, 0x18, 0x01,
  0xE0, 0xC0, 0x07, 0x06, 0x00, 0x7C, 0x38, 0x07, 0xE1, 0xC0, 0x7B, 0x87,
  0x87, 0x8E, 0x3F, 0xF8, 0x38, 0x7F, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0xC0, 0xF0, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x1C, 0x0E, 0xFC,
  0x71, 0xFB, 0xFC, 0xDF, 0xF1, 0xFA, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x03, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x8F, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0x10,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0x8F, 0x1C, 0x38, 0x71, 0xC3, 0x86,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0xFB, 0xFF, 0xF7, 0xEF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xE0, 0x3C, 0x70, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06,
  0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x30, 0x7E, 0x1E, 0x1F, 0x8F, 0x87, 0xE3, 0xE1, 0xF8, 0x70, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06,
  0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x1C, 0x3E, 0x1F, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7D,
  0x80, 0x3C, 0x60, 0x1E, 0x18, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x80, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7E, 0xFC, 0x1C, 0x03, 0xC7,
  0x00, 0x3C, 0xE0, 0x03, 0x98, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x1E, 0x3E, 0x0F, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x70, 0x0E, 0x70, 0x07,
  0x38, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x7F, 0x06, 0x7F, 0xE3,
  0x71, 0xF9, 0xE0, 0x3C, 0xE0, 0x0F, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xEE, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xE0, 0x3C, 0x78, 0x03, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60,
  0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01, 0xC1, 0xE0, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xF7,
  0xE1, 0xE0, 0x3C, 0x70, 0x07, 0x98, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x03, 0x98, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x1C, 0x3C, 0x1E, 0x03,
  0xCF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x0F, 0x07, 0x87, 0x80,
  0xF1, 0xC0, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x39, 0xC0, 0x1E, 0x7C, 0x1F, 0x0F,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1E,
  0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xE0,
  0x03, 0x9E, 0x00, 0x71, 0xE0, 0x1E, 0x1F, 0x1F, 0x81, 0xFF, 0x70, 0x1F,
  0xDC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xEF, 0x84,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xEF,
  0xFF, 0xDF, 0xBE, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3C,
  0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x07, 0xF8, 0x1F, 0xC0, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xE0, 0xF0, 0x3C, 0x01, 0xC3, 0x80, 0x07,
  0x1C, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x3E, 0x07, 0xFD, 0xF0, 0x38, 0x2F,
  0x83, 0x80, 0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x1F, 0x07, 0x00, 0xF8, 0x38,
  0x07, 0xC1, 0xC0, 0x3E, 0x0E, 0x01, 0xF0, 0x70, 0x0F, 0x83, 0x80, 0x7C,
  0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x03, 0x83, 0xF8, 0x1F, 0xF7, 0xC0, 0x7F,
  0x36, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1B, 0x00, 0x01, 0xB8, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00,
  0x31, 0x80, 0x03, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x60, 0xC0,
  0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x06, 0x00, 0xC0, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x01, 0x80, 0x38, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x38, 0x01, 0x83, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x70,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xE0, 0x7E, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xF7, 0xE1, 0xE0, 0x3C, 0x70, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0xE7, 0x00, 0x39, 0xE0,
  0x1C, 0x3C, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF9, 0xFF, 0xFC,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xF7,
  0xE1, 0xE0, 0x3C, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06,
  0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xB8, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1C, 0x3C, 0x1F, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0xE7, 0xC1, 0xE1, 0xFF,
  0xF0, 0x3F, 0xE0, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1C,
  0x1C, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xD8, 0x0F, 0xF6, 0x03,
  0x7D, 0xC0, 0xDF, 0x30, 0x77, 0xCC, 0x19, 0xF3, 0x86, 0x7C, 0x63, 0x9F,
  0x18, 0xC7, 0xC7, 0x31, 0xF0, 0xD8, 0x7C, 0x36, 0x1F, 0x0F, 0x87, 0xC1,
  0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0x60, 0x1F, 0xB0, 0x0F,
  0xDC, 0x07, 0xE6, 0x03, 0xF3, 0x81, 0xF9, 0xC0, 0xFC, 0x60, 0x7E, 0x38,
  0x3F, 0x0C, 0x1F, 0x86, 0x0F, 0xC3, 0x87, 0xE0, 0xC3, 0xF0, 0x71, 0xF8,
  0x38, 0xFC, 0x0C, 0x7E, 0x07, 0x3F, 0x01, 0x9F, 0x80, 0xCF, 0xC0, 0x77,
  0xE0, 0x1B, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1E, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0x01, 0xE7,
  0x00, 0x77, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x01,
  0xCF, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x03, 0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x01, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xF7, 0xE1, 0xE0, 0x3C, 0x70, 0x07, 0x38, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0x79,
  0xE0, 0x1C, 0x3C, 0x1E, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x07,
  0xCE, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07,
  0x38, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x03, 0xB8, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0xFC,
  0x1E, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x33, 0x80, 0x06,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x3C, 0x01, 0xE3,
  0xE0, 0x78, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01,
  0xDC, 0x01, 0xCF, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x38,
  0x38, 0x03, 0x81, 0x80, 0x38, 0x1C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x60,
  0xE0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0x80, 0x03,
  0x98, 0x00, 0x3B, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0xC0, 0x70, 0x1D, 0x80,
  0xF0, 0x3B, 0x01, 0xE0, 0x67, 0x02, 0xC0, 0xCE, 0x0D, 0x81, 0x9C, 0x1B,
  0x03, 0x38, 0x36, 0x0E, 0x70, 0x6C, 0x1C, 0x60, 0xC8, 0x38, 0xC1, 0x98,
  0x71, 0x83, 0x30, 0xC3, 0x0C, 0x61, 0x87, 0x18, 0xC3, 0x0E, 0x31, 0x86,
  0x1C, 0x63, 0x0C, 0x38, 0xC6, 0x38, 0x71, 0x86, 0x70, 0x63, 0x0C, 0xE0,
  0xC4, 0x19, 0x81, 0x98, 0x33, 0x03, 0x30, 0x66, 0x07, 0x60, 0xCC, 0x0E,
  0xC1, 0x98, 0x1D, 0x81, 0x70, 0x3B, 0x03, 0xE0, 0x34, 0x07, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x00, 0x70,
  0x00, 0x3B, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x1C,
  0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x1C,
  0x30, 0x00, 0xE3, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x07, 0x30,
  0x00, 0x3B, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x39, 0x80,
  0x38, 0xE0, 0x1C, 0x30, 0x0C, 0x1C, 0x0E, 0x0E, 0x06, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0x63, 0x80, 0x39, 0xC0, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0x40, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x78, 0x3E, 0x38, 0x03, 0x8E, 0x00,
  0x77, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x3F, 0xFF, 0x3F, 0xFF, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x70, 0x03, 0xDF, 0x03,
  0xF3, 0xFF, 0xDC, 0x3F, 0xC7, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x80, 0xE3, 0xF8,
  0x77, 0xFF, 0x3B, 0x03, 0xDF, 0x00, 0xEF, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xEE, 0xC1, 0xF7, 0x7F, 0xF3, 0x8F, 0xE0, 0x00,
  0x80, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0x73, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x71, 0xE0, 0xF8, 0x7F, 0xF8,
  0x1F, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x02, 0x07, 0x0F, 0xF3, 0x9F, 0xFD, 0xCF,
  0x07, 0xEE, 0x00, 0xF7, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x01, 0xEE,
  0x00, 0xF3, 0xC1, 0xF9, 0xFF, 0xDC, 0x3F, 0xCE, 0x00, 0x80, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0x81, 0xC7, 0x00, 0x73, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x71, 0xE0, 0x78, 0x7F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x01, 0x00, 0x07, 0xF9, 0xCF, 0xFE, 0xE7, 0x83, 0xF7, 0x00, 0x7B,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xB8, 0x03, 0xDC, 0x03, 0xE7, 0x83, 0xF1, 0xFF, 0xB8, 0x7F, 0x9C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x80, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x80, 0xE7, 0xF8, 0x77, 0xFF, 0x3B, 0x07, 0xDF, 0x00, 0xEF, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x0F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7E, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x1E,
  0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x01, 0xC0,
  0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0E, 0x0F, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3,
  0x80, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0xB8, 0x00, 0x78,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x02, 0x02,
  0x1D, 0xF1, 0xF3, 0xFF, 0x7F, 0x78, 0xE8, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1,
  0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83,
  0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0x00, 0x40, 0x73, 0xFC, 0x3B,
  0xFF, 0x9D, 0x83, 0xEF, 0x80, 0x77, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xDC, 0x01, 0xCF, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00,
  0x40, 0x71, 0xFC, 0x3B, 0xFF, 0x9D, 0x81, 0xEF, 0x80, 0x77, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x77, 0x60, 0xFB, 0xBF, 0xF9,
  0xC7, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x07, 0xF9, 0xCF,
  0xFE, 0xE7, 0x83, 0xF7, 0x00, 0x7B, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEE,
  0x00, 0xF7, 0x00, 0x79, 0xE0, 0xFC, 0x7F, 0xEE, 0x1F, 0xE7, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x40, 0x73, 0xFC, 0x3B, 0xFF, 0x9F, 0x83, 0xCF,
  0x00, 0x77, 0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0x80,
  0xF1, 0xC0, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x6E, 0x00,
  0x3B, 0xC0, 0x0E, 0x78, 0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x01, 0xCF, 0x01,
  0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0xE0, 0x00, 0xFC, 0x00, 0x1D,
  0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x1C, 0x03, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x00,
  0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x03, 0x1C, 0x00,
  0x73, 0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0xE0, 0x70, 0x1F, 0x03, 0x80, 0xF8, 0x1C, 0x0F, 0xC0, 0xB0,
  0x76, 0x0D, 0x83, 0xB0, 0x6C, 0x19, 0x83, 0x60, 0xCE, 0x19, 0x06, 0x70,
  0xCC, 0x33, 0x84, 0x63, 0x8C, 0x63, 0x1C, 0x63, 0x18, 0xC3, 0x18, 0xC6,
  0x1C, 0xC2, 0x30, 0xE6, 0x19, 0x87, 0x60, 0xDC, 0x1B, 0x06, 0xE0, 0xD8,
  0x36, 0x06, 0xC1, 0xB0, 0x36, 0x05, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x03,
  0xC1, 0xE0, 0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0xB8,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x70,
  0x00, 0xE7, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x70, 0x1C,
  0x1C, 0x01, 0xC7, 0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x38, 0xE0, 0x00,
  0xFE, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07,
  0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x18,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0,
  0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE7, 0xF0, 0x1D, 0xFF,
  0x03, 0xF0, 0xF0, 0x7E, 0x0E, 0x0F, 0xC0, 0xF1, 0xF8, 0x0F, 0xF7, 0x00,
  0xFC,
};

const GFXglyph JetBrainsMono_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 31, 25, 10, -31 },
  { 21, 11, 13, 25, 7, -31 },
  { 39, 23, 31, 25, 1, -31 },
  { 129, 19, 43, 25, 3, -37 },
  { 232, 23, 31, 25, 1, -31 },
  { 322, 21, 31, 25, 3, -31 },
  { 404, 3, 13, 25, 11, -31 },
  { 409, 12, 40, 25, 8, -35 },
  { 469, 12, 40, 25, 5, -35 },
  { 529, 22, 22, 25, 2, -26 },
  { 590, 19, 20, 25, 3, -24 },
  { 638, 7, 13, 25, 8, -6 },
  { 650, 13, 2, 25, 6, -15 },
  { 654, 7, 6, 25, 9, -6 },
  { 660, 18, 40, 25, 4, -35 },
  { 750, 18, 31, 25, 4, -31 },
  { 820, 18, 31, 25, 4, -31 },
  { 890, 19, 31, 25, 3, -31 },
  { 964, 18, 31, 25, 3, -31 },
  { 1034, 17, 31, 25, 4, -31 },
  { 1100, 17, 31, 25, 4, -31 },
  { 1166, 19, 31, 25, 3, -31 },
  { 1240, 19, 31, 25, 3, -31 },
  { 1314, 18, 31, 25, 4, -31 },
  { 1384, 19, 31, 25, 3, -31 },
  { 1458, 7, 24, 25, 9, -24 },
  { 1479, 8, 31, 25, 8, -24 },
  { 1510, 18, 22, 25, 4, -25 },
  { 1560, 17, 12, 25, 4, -20 },
  { 1586, 18, 22, 25, 4, -25 },
  { 1636, 14, 31, 25, 7, -31 },
  { 1691, 21, 39, 25, 2, -31 },
  { 1794, 20, 31, 25, 3, -31 },
  { 1872, 18, 31, 25, 4, -31 },
  { 1942, 18, 31, 25, 4, -31 },
  { 2012, 17, 31, 25, 4, -31 },
  { 2078, 17, 31, 25, 5, -31 },
  { 2144, 18, 31, 25, 4, -31 },
  { 2214, 18, 31, 25, 4, -31 },
  { 2284, 17, 31, 25, 4, -31 },
  { 2350, 15, 31, 25, 5, -31 },
  { 2409, 17, 31, 25, 3, -31 },
  { 2475, 19, 31, 25, 4, -31 },
  { 2549, 17, 31, 25, 5, -31 },
  { 2615, 18, 31, 25, 4, -31 },
  { 2685, 17, 31, 25, 4, -31 },
  { 2751, 17, 31, 25, 4, -31 },
  { 2817, 19, 31, 25, 4, -31 },
  { 2891, 18, 39, 25, 4, -31 },
  { 2979, 19, 31, 25, 4, -31 },
  { 3053, 19, 31, 25, 3, -31 },
  { 3127, 21, 31, 25, 2, -31 },
  { 3209, 17, 31, 25, 4, -31 },
  { 3275, 20, 31, 25, 3, -31 },
  { 3353, 23, 31, 25, 1, -31 },
  { 3443, 21, 31, 25, 2, -31 },
  { 3525, 21, 31, 25, 2, -31 },
  { 3607, 17, 31, 25, 4, -31 },
  { 3673, 10, 40, 25, 9, -35 },
  { 3723, 18, 40, 25, 4, -35 },
  { 3813, 10, 40, 25, 6, -35 },
  { 3863, 17, 17, 25, 4, -31 },
  { 3900, 20, 2, 25, 3, 1 },
  { 3905, 8, 6, 25, 8, -33 },
  { 3911, 18, 24, 25, 3, -24 },
  { 3965, 17, 31, 25, 4, -31 },
  { 4031, 17, 24, 25, 4, -24 },
  { 4082, 17, 31, 25, 4, -31 },
  { 4148, 17, 24, 25, 4, -24 },
  { 4199, 19, 31, 25, 3, -31 },
  { 4273, 17, 32, 25, 4, -24 },
  { 4341, 17, 31, 25, 4, -31 },
  { 4407, 19, 32, 25, 4, -32 },
  { 4483, 15, 40, 25, 4, -32 },
  { 4558, 19, 31, 25, 4, -31 },
  { 4632, 21, 31, 25, 2, -31 },
  { 4714, 19, 24, 25, 3, -24 },
  { 4771, 17, 24, 25, 4, -24 },
  { 4822, 17, 23, 25, 4, -23 },
  { 4871, 17, 32, 25, 4, -24 },
  { 4939, 17, 32, 25, 4, -24 },
  { 5007, 17, 24, 25, 5, -24 },
  { 5058, 18, 23, 25, 4, -23 },
  { 5110, 18, 30, 25, 3, -30 },
  { 5178, 17, 23, 25, 4, -23 },
  { 5227, 19, 23, 25, 3, -23 },
  { 5282, 21, 23, 25, 2, -23 },
  { 5343, 19, 23, 25, 3, -23 },
  { 5398, 19, 31, 25, 3, -23 },
  { 5472, 17, 23, 25, 4, -23 },
  { 5521, 17, 40, 25, 4, -35 },
  { 5606, 3, 40, 25, 11, -35 },
  { 5621, 17, 40, 25, 4, -35 },
  { 5706, 19, 8, 25, 3, -19 },
};

const GFXfont JetBrainsMono_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_EXTRALIGHT42PT7B_H_
