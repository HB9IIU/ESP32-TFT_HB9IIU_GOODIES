#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/JetBrainsMono_ExtraLight
// Headers: 67

#include "JetBrainsMono_ExtraLight6pt7b.h"
#include "JetBrainsMono_ExtraLight7pt7b.h"
#include "JetBrainsMono_ExtraLight8pt7b.h"
#include "JetBrainsMono_ExtraLight9pt7b.h"
#include "JetBrainsMono_ExtraLight10pt7b.h"
#include "JetBrainsMono_ExtraLight11pt7b.h"
#include "JetBrainsMono_ExtraLight12pt7b.h"
#include "JetBrainsMono_ExtraLight13pt7b.h"
#include "JetBrainsMono_ExtraLight14pt7b.h"
#include "JetBrainsMono_ExtraLight15pt7b.h"
#include "JetBrainsMono_ExtraLight16pt7b.h"
#include "JetBrainsMono_ExtraLight17pt7b.h"
#include "JetBrainsMono_ExtraLight18pt7b.h"
#include "JetBrainsMono_ExtraLight19pt7b.h"
#include "JetBrainsMono_ExtraLight20pt7b.h"
#include "JetBrainsMono_ExtraLight21pt7b.h"
#include "JetBrainsMono_ExtraLight22pt7b.h"
#include "JetBrainsMono_ExtraLight23pt7b.h"
#include "JetBrainsMono_ExtraLight24pt7b.h"
#include "JetBrainsMono_ExtraLight25pt7b.h"
#include "JetBrainsMono_ExtraLight26pt7b.h"
#include "JetBrainsMono_ExtraLight27pt7b.h"
#include "JetBrainsMono_ExtraLight28pt7b.h"
#include "JetBrainsMono_ExtraLight29pt7b.h"
#include "JetBrainsMono_ExtraLight30pt7b.h"
#include "JetBrainsMono_ExtraLight31pt7b.h"
#include "JetBrainsMono_ExtraLight32pt7b.h"
#include "JetBrainsMono_ExtraLight33pt7b.h"
#include "JetBrainsMono_ExtraLight34pt7b.h"
#include "JetBrainsMono_ExtraLight35pt7b.h"
#include "JetBrainsMono_ExtraLight36pt7b.h"
#include "JetBrainsMono_ExtraLight37pt7b.h"
#include "JetBrainsMono_ExtraLight38pt7b.h"
#include "JetBrainsMono_ExtraLight39pt7b.h"
#include "JetBrainsMono_ExtraLight40pt7b.h"
#include "JetBrainsMono_ExtraLight41pt7b.h"
#include "JetBrainsMono_ExtraLight42pt7b.h"
#include "JetBrainsMono_ExtraLight43pt7b.h"
#include "JetBrainsMono_ExtraLight44pt7b.h"
#include "JetBrainsMono_ExtraLight45pt7b.h"
#include "JetBrainsMono_ExtraLight46pt7b.h"
#include "JetBrainsMono_ExtraLight47pt7b.h"
#include "JetBrainsMono_ExtraLight48pt7b.h"
#include "JetBrainsMono_ExtraLight49pt7b.h"
#include "JetBrainsMono_ExtraLight50pt7b.h"
#include "JetBrainsMono_ExtraLight51pt7b.h"
#include "JetBrainsMono_ExtraLight52pt7b.h"
#include "JetBrainsMono_ExtraLight53pt7b.h"
#include "JetBrainsMono_ExtraLight54pt7b.h"
#include "JetBrainsMono_ExtraLight55pt7b.h"
#include "JetBrainsMono_ExtraLight56pt7b.h"
#include "JetBrainsMono_ExtraLight57pt7b.h"
#include "JetBrainsMono_ExtraLight58pt7b.h"
#include "JetBrainsMono_ExtraLight59pt7b.h"
#include "JetBrainsMono_ExtraLight60pt7b.h"
#include "JetBrainsMono_ExtraLight61pt7b.h"
#include "JetBrainsMono_ExtraLight62pt7b.h"
#include "JetBrainsMono_ExtraLight63pt7b.h"
#include "JetBrainsMono_ExtraLight64pt7b.h"
#include "JetBrainsMono_ExtraLight65pt7b.h"
#include "JetBrainsMono_ExtraLight66pt7b.h"
#include "JetBrainsMono_ExtraLight67pt7b.h"
#include "JetBrainsMono_ExtraLight68pt7b.h"
#include "JetBrainsMono_ExtraLight69pt7b.h"
#include "JetBrainsMono_ExtraLight70pt7b.h"
#include "JetBrainsMono_ExtraLight71pt7b.h"
#include "JetBrainsMono_ExtraLight72pt7b.h"
