#ifndef _JETBRAINSMONO_EXTRALIGHT41PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCC, 0x63,
  0x18, 0xC6, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x70, 0x00, 0xE0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18,
  0x01, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x38, 0x01,
  0x80, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x03, 0x01,
  0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x0E, 0x00, 0x60, 0x38, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE0, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x18,
  0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x4F, 0x0E, 0x10, 0xE3, 0x04,
  0x39, 0xC1, 0x07, 0x70, 0x41, 0xDC, 0x10, 0x77, 0x04, 0x01, 0xC1, 0x00,
  0x38, 0x40, 0x0F, 0x10, 0x01, 0xE4, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x05, 0xF0, 0x01, 0x1E, 0x00, 0x43, 0x80, 0x10, 0x70, 0x04,
  0x1C, 0x01, 0x03, 0xE0, 0x40, 0xF8, 0x10, 0x36, 0x04, 0x1D, 0xC1, 0x07,
  0x78, 0x43, 0x8F, 0x93, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x1F,
  0x00, 0x0E, 0xFF, 0x80, 0x19, 0xC7, 0x00, 0x67, 0x07, 0x01, 0x8C, 0x0E,
  0x07, 0x18, 0x0C, 0x0C, 0x30, 0x18, 0x30, 0x60, 0x30, 0xE0, 0xC0, 0x61,
  0x81, 0xC1, 0xC6, 0x03, 0x83, 0x1C, 0x03, 0xFE, 0x30, 0x03, 0xF8, 0xC0,
  0x00, 0x83, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x40,
  0x01, 0xC7, 0xF0, 0x03, 0x1F, 0xF0, 0x0C, 0x70, 0xE0, 0x38, 0xC0, 0xC0,
  0x61, 0x81, 0x81, 0x83, 0x03, 0x87, 0x06, 0x07, 0x0C, 0x0C, 0x0E, 0x30,
  0x18, 0x18, 0xC0, 0x30, 0x33, 0x80, 0x70, 0xE6, 0x00, 0x7F, 0x98, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xC3, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0x60, 0x0E, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0x38, 0x07, 0x70, 0xE0, 0x73, 0x03,
  0x83, 0x38, 0x0E, 0x39, 0xC0, 0x71, 0x8E, 0x01, 0xDC, 0x70, 0x07, 0xC3,
  0x80, 0x1E, 0x1C, 0x00, 0xE0, 0x60, 0x07, 0x83, 0x80, 0x7E, 0x1C, 0x07,
  0x30, 0xF0, 0xF1, 0xC3, 0xFF, 0x07, 0x0F, 0xF0, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x70, 0x1F, 0x03, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x00, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x01, 0xC0, 0x5F, 0x0C, 0x1F, 0xFE, 0x63, 0xF9,
  0xFD, 0x7F, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xEC,
  0x00, 0x0E, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x0F, 0x00, 0x70, 0x38, 0x07,
  0x80, 0xE0, 0x38, 0x07, 0x80, 0x80, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x39, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x1F, 0x0F, 0x8E, 0x01,
  0xEE, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0E, 0x1F, 0x0F, 0x8F,
  0x87, 0x87, 0xC1, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0x9C,
  0x03, 0xCF, 0x83, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7B, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x0E, 0x0E, 0x02,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xF8, 0x3C, 0x1C,
  0x03, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0xDE,
  0x01, 0xC7, 0x81, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x38, 0x0C, 0xFF, 0x86, 0xFF, 0xE7,
  0xC0, 0xF3, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0x70, 0x03, 0x9C, 0x03, 0xCF, 0x83, 0xC3, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1D, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0xF1, 0xE0, 0x1E,
  0x70, 0x03, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xE3, 0x80,
  0x78, 0xF8, 0x3C, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0xE7, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE,
  0x0F, 0x07, 0x8E, 0x01, 0xE6, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0x30, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC1, 0xE3, 0xC0,
  0x7F, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x1C, 0x3C, 0x3C, 0x07, 0x1C, 0x01,
  0xDC, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xCF, 0x83, 0xC3, 0xFF, 0xE0, 0x7F, 0xC0,
  0x07, 0xF8, 0x03, 0xFF, 0x83, 0xE0, 0xF0, 0xE0, 0x1E, 0x70, 0x03, 0x9C,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x38, 0xF8, 0x3E,
  0x1F, 0xFB, 0x01, 0xFD, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x39, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xFF, 0xFF,
  0xF7, 0xC0, 0x1E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87, 0x83,
  0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x8F,
  0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE1, 0xFF, 0x07, 0xF8,
  0x1F, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xC0, 0xF0, 0x38, 0x01, 0xC3,
  0x80, 0x06, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0x7F, 0x7E, 0x07, 0x8F, 0xF0,
  0x70, 0x3F, 0x83, 0x80, 0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01,
  0xF8, 0x38, 0x0F, 0xC1, 0xC0, 0x7E, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x83,
  0x80, 0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x7F, 0x03, 0xEF, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3C, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0D,
  0x80, 0x01, 0xD8, 0x00, 0x1D, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0xC0, 0x03,
  0x8C, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00,
  0x70, 0x70, 0x06, 0x07, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x38,
  0x0C, 0x03, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x18, 0x01,
  0xC3, 0x80, 0x0C, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x06, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0xFC, 0xE0, 0x0F, 0x70, 0x03, 0xB8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xDC, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x83, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x03, 0xCE, 0x00,
  0xE7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x07, 0x9C,
  0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xE7, 0x00,
  0x77, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC7,
  0x83, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0xE3, 0x80, 0x78, 0xF8, 0x3C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xBD, 0x80, 0xDE, 0xC0, 0xEF,
  0x70, 0x67, 0x98, 0x33, 0xCC, 0x39, 0xE7, 0x18, 0xF1, 0x8C, 0x78, 0xCE,
  0x7C, 0x76, 0x3E, 0x1B, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0xC1, 0xC3, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1C, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xEC, 0x03, 0xEE, 0x03, 0xE6, 0x03, 0xE6, 0x03, 0xE7,
  0x03, 0xE3, 0x03, 0xE3, 0x83, 0xE1, 0x83, 0xE1, 0x83, 0xE1, 0xC3, 0xE0,
  0xC3, 0xE0, 0xC3, 0xE0, 0xE3, 0xE0, 0x63, 0xE0, 0x73, 0xE0, 0x33, 0xE0,
  0x33, 0xE0, 0x3B, 0xE0, 0x1B, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x01, 0xE7,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x06, 0xE0, 0x03, 0x38, 0x03, 0x9C, 0x03,
  0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xB8, 0x01, 0xEE, 0x03, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x01, 0xEE,
  0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x03, 0x9C, 0x03,
  0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x3C, 0xE0, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80,
  0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x0E,
  0x01, 0xC3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xE0,
  0xF0, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0x60, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x38, 0xF8, 0x3E, 0x1F, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x3C,
  0x1E, 0x1F, 0xFC, 0x0F, 0xF0, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x67, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80,
  0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x80, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x60, 0x07, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xC0,
  0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0x80, 0x00, 0xD8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x38, 0x0D, 0x80,
  0xE0, 0x36, 0x03, 0x81, 0xD8, 0x1A, 0x07, 0x60, 0x6C, 0x1D, 0xC1, 0xB0,
  0x77, 0x06, 0xC1, 0x9C, 0x1B, 0x06, 0x70, 0x6C, 0x18, 0xC1, 0x30, 0x63,
  0x0C, 0xC1, 0x8C, 0x31, 0x0E, 0x30, 0xC6, 0x38, 0xC3, 0x18, 0xE3, 0x8C,
  0x63, 0x0E, 0x31, 0x8C, 0x38, 0x86, 0x30, 0xE6, 0x18, 0xC1, 0x98, 0x63,
  0x06, 0x60, 0x8C, 0x19, 0x83, 0x70, 0x66, 0x0D, 0xC1, 0xD8, 0x36, 0x07,
  0x40, 0xD8, 0x1D, 0x03, 0x60, 0x7C, 0x0D, 0x80, 0xF0, 0x16, 0x03, 0xC0,
  0x58, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x73, 0x80, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x70,
  0x00, 0x3C, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0xE0,
  0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x31, 0x80, 0x38, 0xE0,
  0x18, 0x70, 0x1C, 0x18, 0x0C, 0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC7, 0x00,
  0x63, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xEF,
  0xC7, 0x80, 0xE3, 0x80, 0x3B, 0x80, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC1, 0xFF, 0xE3, 0xFF, 0xF7, 0xC0, 0x1B, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00,
  0xF7, 0x80, 0xD9, 0xFF, 0xCC, 0x7F, 0xC6, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC7, 0xE0,
  0xE7, 0xFC, 0x77, 0xBF, 0x3E, 0x03, 0x9E, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0x78, 0x03, 0xBC, 0x03, 0xDF, 0x83, 0xCE, 0xFF, 0xC7, 0x3F, 0xC0, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x00, 0x1B,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x07, 0xC3, 0x1F, 0xF3, 0x3E, 0x7B, 0x78, 0x0B, 0x70, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x7C, 0x1B, 0x3F, 0xF3, 0x0F, 0xE3,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x9F, 0x8F, 0x01, 0xC7, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x01, 0xD8, 0x01, 0xCE, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xC3, 0x1F, 0xF3, 0x3E, 0x7B, 0x78, 0x0B, 0x70, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70,
  0x0F, 0x78, 0x1B, 0x3F, 0xF3, 0x0F, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x1F, 0xFE, 0x1F,
  0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xEF, 0x7E, 0xF8, 0x0E, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0x00, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x03, 0xB8,
  0x01, 0xEE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xE0, 0x70, 0x38, 0x1E, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x1E, 0x38,
  0x03, 0x8E, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xCF, 0x0F, 0x1B, 0xF3, 0xF3, 0x47, 0x47, 0x70, 0x70, 0x6E,
  0x0E, 0x0D, 0xC1, 0x81, 0xF8, 0x30, 0x3F, 0x06, 0x07, 0xE0, 0xC0, 0xFC,
  0x18, 0x1F, 0x83, 0x03, 0xF0, 0x60, 0x7E, 0x0C, 0x0F, 0xC1, 0x81, 0xF8,
  0x30, 0x3F, 0x06, 0x07, 0xE0, 0xC0, 0xFC, 0x18, 0x1F, 0x83, 0x03, 0xF0,
  0x60, 0x7E, 0x0C, 0x0F, 0xC1, 0x81, 0xF8, 0x30, 0x38, 0xE3, 0xF0, 0xE7,
  0xFC, 0xEF, 0x7E, 0xF8, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xDF, 0x8F, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0x98, 0x01, 0xCE,
  0x01, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0xE3, 0xF0, 0x73, 0xFE,
  0x3B, 0xDF, 0x9F, 0x01, 0xCF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0D, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xBC, 0x01,
  0xDE, 0x01, 0xEF, 0xC1, 0xE7, 0x7F, 0xE3, 0x9F, 0xE1, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xC3, 0x1F, 0xF3, 0x3E, 0x7B, 0x78, 0x0B, 0x70, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0x60, 0x07, 0x70, 0x0F, 0x3C, 0x1B, 0x3F, 0xF3, 0x0F, 0xE3, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0xE3, 0xF0, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x0E, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8E, 0x00, 0xE6, 0x00, 0x37, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x3C, 0x1E, 0x1F,
  0xFC, 0x0F, 0xF0, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x18, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x18, 0x06, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x18,
  0x01, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0x67, 0x00, 0x0E, 0xE0,
  0x01, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xC0, 0x70,
  0x3E, 0x03, 0x81, 0xF8, 0x1C, 0x0D, 0xC1, 0xE0, 0x6E, 0x0D, 0x03, 0x30,
  0x6C, 0x19, 0x83, 0x61, 0xCC, 0x1B, 0x0E, 0x70, 0x98, 0x63, 0x8C, 0xC3,
  0x1C, 0x62, 0x18, 0x63, 0x18, 0xC3, 0x18, 0xCE, 0x18, 0x86, 0x70, 0xEC,
  0x33, 0x07, 0x61, 0x98, 0x3B, 0x06, 0xC0, 0xD8, 0x36, 0x06, 0xC1, 0xB0,
  0x34, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0xE0,
  0x01, 0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x1C, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x00, 0xCE, 0x00, 0x38,
  0xE0, 0x0E, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0xC7, 0x00,
  0x38, 0xE0, 0x03, 0xB8, 0x00, 0x78, 0xE0, 0x00, 0xFC, 0x00, 0x19, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xC0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x60,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x36,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x00, 0x3F, 0x00, 0xDF, 0xE0,
  0x3E, 0x1C, 0x0F, 0x83, 0x83, 0xE0, 0x71, 0xF8, 0x1F, 0xFE, 0x01, 0xF8,
  0x00, 0x10,
};

const GFXglyph JetBrainsMono_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 30, 25, 10, -30 },
  { 20, 11, 12, 25, 7, -30 },
  { 37, 22, 30, 25, 1, -30 },
  { 120, 18, 42, 25, 3, -36 },
  { 215, 23, 30, 25, 1, -30 },
  { 302, 21, 30, 25, 2, -30 },
  { 381, 3, 12, 25, 11, -30 },
  { 386, 12, 39, 25, 8, -34 },
  { 445, 12, 39, 25, 5, -34 },
  { 504, 21, 21, 25, 2, -25 },
  { 560, 19, 19, 25, 3, -23 },
  { 606, 8, 13, 25, 7, -6 },
  { 619, 13, 3, 25, 6, -15 },
  { 624, 6, 6, 25, 9, -6 },
  { 629, 17, 39, 25, 4, -34 },
  { 712, 17, 30, 25, 4, -30 },
  { 776, 18, 30, 25, 4, -30 },
  { 844, 19, 30, 25, 3, -30 },
  { 916, 17, 30, 25, 3, -30 },
  { 980, 16, 30, 25, 4, -30 },
  { 1040, 17, 30, 25, 4, -30 },
  { 1104, 18, 30, 25, 3, -30 },
  { 1172, 19, 30, 25, 3, -30 },
  { 1244, 17, 30, 25, 4, -30 },
  { 1308, 18, 30, 25, 3, -30 },
  { 1376, 6, 23, 25, 9, -23 },
  { 1394, 9, 30, 25, 7, -23 },
  { 1428, 17, 21, 25, 4, -24 },
  { 1473, 17, 12, 25, 4, -20 },
  { 1499, 17, 21, 25, 4, -24 },
  { 1544, 14, 30, 25, 6, -30 },
  { 1597, 21, 37, 25, 2, -30 },
  { 1695, 20, 30, 25, 2, -30 },
  { 1770, 17, 30, 25, 4, -30 },
  { 1834, 17, 30, 25, 4, -30 },
  { 1898, 17, 30, 25, 4, -30 },
  { 1962, 16, 30, 25, 5, -30 },
  { 2022, 18, 30, 25, 4, -30 },
  { 2090, 17, 30, 25, 4, -30 },
  { 2154, 16, 30, 25, 4, -30 },
  { 2214, 15, 30, 25, 5, -30 },
  { 2271, 18, 30, 25, 2, -30 },
  { 2339, 18, 30, 25, 4, -30 },
  { 2407, 17, 30, 25, 5, -30 },
  { 2471, 17, 30, 25, 4, -30 },
  { 2535, 16, 30, 25, 4, -30 },
  { 2595, 17, 30, 25, 4, -30 },
  { 2659, 18, 30, 25, 4, -30 },
  { 2727, 17, 37, 25, 4, -30 },
  { 2806, 18, 30, 25, 4, -30 },
  { 2874, 18, 30, 25, 3, -30 },
  { 2942, 20, 30, 25, 2, -30 },
  { 3017, 16, 30, 25, 4, -30 },
  { 3077, 20, 30, 25, 2, -30 },
  { 3152, 22, 30, 25, 1, -30 },
  { 3235, 21, 30, 25, 2, -30 },
  { 3314, 21, 30, 25, 2, -30 },
  { 3393, 17, 30, 25, 4, -30 },
  { 3457, 9, 39, 25, 9, -34 },
  { 3501, 17, 39, 25, 4, -34 },
  { 3584, 10, 39, 25, 6, -34 },
  { 3633, 17, 16, 25, 4, -30 },
  { 3667, 20, 2, 25, 2, 1 },
  { 3672, 8, 6, 25, 8, -32 },
  { 3678, 17, 23, 25, 3, -23 },
  { 3727, 17, 30, 25, 4, -30 },
  { 3791, 17, 23, 25, 4, -23 },
  { 3840, 16, 30, 25, 4, -30 },
  { 3900, 17, 23, 25, 4, -23 },
  { 3949, 19, 30, 25, 3, -30 },
  { 4021, 16, 30, 25, 4, -23 },
  { 4081, 16, 30, 25, 4, -30 },
  { 4141, 18, 32, 25, 4, -32 },
  { 4213, 15, 39, 25, 4, -32 },
  { 4287, 18, 30, 25, 4, -30 },
  { 4355, 20, 30, 25, 2, -30 },
  { 4430, 19, 23, 25, 3, -23 },
  { 4485, 16, 23, 25, 4, -23 },
  { 4531, 17, 23, 25, 4, -23 },
  { 4580, 17, 30, 25, 4, -23 },
  { 4644, 16, 30, 25, 4, -23 },
  { 4704, 16, 23, 25, 5, -23 },
  { 4750, 17, 23, 25, 4, -23 },
  { 4799, 18, 29, 25, 3, -29 },
  { 4865, 16, 23, 25, 4, -23 },
  { 4911, 19, 23, 25, 3, -23 },
  { 4966, 21, 23, 25, 2, -23 },
  { 5027, 19, 23, 25, 3, -23 },
  { 5082, 19, 30, 25, 3, -23 },
  { 5154, 17, 23, 25, 4, -23 },
  { 5203, 17, 39, 25, 4, -34 },
  { 5286, 3, 39, 25, 11, -34 },
  { 5301, 17, 39, 25, 4, -34 },
  { 5384, 18, 8, 25, 3, -18 },
};

const GFXfont JetBrainsMono_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_EXTRALIGHT41PT7B_H_
