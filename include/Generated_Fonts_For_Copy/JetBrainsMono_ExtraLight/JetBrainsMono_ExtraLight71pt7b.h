#ifndef _JETBRAINSMONO_EXTRALIGHT71PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0xE3, 0xF8, 0x0F, 0xC1,
  0xC1, 0xF8, 0x3F, 0x03, 0x81, 0xF8, 0x7C, 0x07, 0x01, 0xF0, 0xF8, 0x0E,
  0x01, 0xF3, 0xE0, 0x1C, 0x03, 0xE7, 0xC0, 0x38, 0x07, 0xCF, 0x80, 0x70,
  0x0F, 0x9F, 0x00, 0xE0, 0x0F, 0x3E, 0x01, 0xC0, 0x00, 0x7C, 0x03, 0x80,
  0x00, 0xF8, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x01, 0xF0, 0x1C, 0x00,
  0x03, 0xF0, 0x38, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x07, 0xF0, 0xE0, 0x00,
  0x07, 0xF1, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xEF, 0xF8, 0x00, 0x01, 0xC7, 0xF8, 0x00,
  0x03, 0x83, 0xF0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x0E, 0x03, 0xF0, 0x00,
  0x1C, 0x03, 0xE0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x70, 0x07, 0xC0, 0x00,
  0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x1F, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0x07,
  0x00, 0x7F, 0xC0, 0x0E, 0x00, 0xFF, 0xC0, 0x1C, 0x01, 0xFF, 0x80, 0x38,
  0x03, 0xFF, 0x00, 0x70, 0x0F, 0x9F, 0x00, 0xE0, 0x1F, 0x3F, 0x01, 0xC0,
  0x7C, 0x3F, 0x03, 0x81, 0xF8, 0x3F, 0x87, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x0F, 0xFF, 0x00, 0x00,
  0x1E, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x3F, 0xFF, 0xC0, 0x00, 0x3C, 0x3E,
  0x03, 0xE0, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0x00, 0x78, 0x78, 0x01, 0xE0,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x03, 0xE0,
  0xF0, 0x00, 0x3F, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0xFF, 0xC3, 0xC0, 0x00,
  0x0F, 0xFF, 0x87, 0x80, 0x00, 0x07, 0xFE, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xE0,
  0xFF, 0xF8, 0x00, 0x01, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0xC3, 0xF8, 0xFC,
  0x00, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x1E, 0x00,
  0x03, 0xE0, 0x3E, 0x1E, 0x00, 0x01, 0xFD, 0xFC, 0x3C, 0x00, 0x01, 0xFF,
  0xF8, 0x78, 0x00, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0x00, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x7E, 0x07, 0xC0, 0x03, 0xE7, 0xC0, 0x7E,
  0x00, 0x7C, 0x7C, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x0F, 0xC1, 0xF0, 0xF8, 0x00, 0x7C, 0x1E,
  0x0F, 0x80, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0x1F, 0x7C, 0x0F, 0x80, 0x01,
  0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x07, 0xFC, 0x07, 0xC0, 0x00,
  0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0xBE, 0x07, 0xE0, 0x03, 0xF1, 0xF0, 0x3F,
  0x00, 0xFE, 0x0F, 0x83, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xC0, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x78, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x10,
  0x00, 0x3E, 0x00, 0x08, 0xF0, 0x01, 0xF0, 0x01, 0xE7, 0xF0, 0x0F, 0x00,
  0x7F, 0x7F, 0xF0, 0x78, 0x1F, 0xFB, 0xFF, 0xE1, 0xC3, 0xFF, 0xE7, 0xFF,
  0x8E, 0x7F, 0xFC, 0x07, 0xFF, 0x67, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x0F, 0xFB, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x01, 0xE0, 0x0F, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0, 0x3F,
  0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0x80, 0x38, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x7C, 0x00, 0x03, 0xF8,
  0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x3E,
  0x00, 0x18, 0x00, 0x7C, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0xF0,
  0xFF, 0xFC, 0x07, 0x8F, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xC1, 0xEF, 0xC1,
  0xFF, 0x0F, 0x70, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x1C, 0x00,
  0x01, 0xF1, 0xFF, 0xC0, 0x03, 0xCF, 0xFF, 0xE0, 0x0F, 0xBF, 0xFF, 0xE0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xFD, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xBE, 0x00,
  0xFF, 0xFE, 0xF8, 0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01,
  0xFC, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF1, 0xFC,
  0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF,
  0x9F, 0xE0, 0x03, 0xFF, 0xFB, 0xFC, 0x00, 0x7F, 0x8F, 0x7F, 0x80, 0x1F,
  0x80, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0xC0,
  0x1F, 0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x1F,
  0xE0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x3E, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x1F,
  0x00, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x0F, 0x80, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x0F,
  0xF0, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x0F, 0x80,
  0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0xDF, 0xE0, 0x03,
  0xFF, 0xFB, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x8F, 0xF8,
  0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0xC3, 0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x0F, 0xE3,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x7F, 0xF0,
  0x7C, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0xEF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1D, 0xFE, 0xE0, 0x00, 0x7B, 0xFD, 0xE0, 0x00, 0xF7, 0xFB,
  0xC0, 0x03, 0xCF, 0xF3, 0xC0, 0x07, 0x9F, 0xE7, 0x80, 0x0F, 0x3F, 0xCF,
  0x00, 0x3C, 0xFF, 0x8F, 0x00, 0x79, 0xFF, 0x1E, 0x00, 0xF3, 0xFE, 0x3C,
  0x03, 0xC7, 0xFC, 0x3C, 0x07, 0x8F, 0xF8, 0x78, 0x0F, 0x1F, 0xF0, 0xF0,
  0x3C, 0x3F, 0xE0, 0xF0, 0x78, 0x7F, 0xE1, 0xE0, 0xF0, 0xFF, 0xC1, 0xC3,
  0xC1, 0xFF, 0x83, 0xC7, 0x83, 0xFF, 0x07, 0x8E, 0x07, 0xFE, 0x07, 0x3C,
  0x0F, 0xFC, 0x0F, 0x78, 0x1F, 0xF8, 0x1E, 0xE0, 0x3F, 0xF0, 0x1D, 0xC0,
  0x7F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xC0,
  0x00, 0xFF, 0xBC, 0x00, 0x0F, 0xFB, 0xE0, 0x00, 0xFF, 0x9E, 0x00, 0x0F,
  0xF9, 0xE0, 0x00, 0xFF, 0x9F, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0xFF, 0x8F,
  0x00, 0x0F, 0xF8, 0x78, 0x00, 0xFF, 0x87, 0x80, 0x0F, 0xF8, 0x7C, 0x00,
  0xFF, 0x83, 0xC0, 0x0F, 0xF8, 0x3C, 0x00, 0xFF, 0x83, 0xE0, 0x0F, 0xF8,
  0x1E, 0x00, 0xFF, 0x81, 0xE0, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF0,
  0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0x78, 0x0F, 0xF8, 0x07, 0x80, 0xFF,
  0x80, 0x3C, 0x0F, 0xF8, 0x03, 0xC0, 0xFF, 0x80, 0x3E, 0x0F, 0xF8, 0x01,
  0xE0, 0xFF, 0x80, 0x1E, 0x0F, 0xF8, 0x01, 0xF0, 0xFF, 0x80, 0x0F, 0x0F,
  0xF8, 0x00, 0xF0, 0xFF, 0x80, 0x07, 0x8F, 0xF8, 0x00, 0x78, 0xFF, 0x80,
  0x07, 0xCF, 0xF8, 0x00, 0x3C, 0xFF, 0x80, 0x03, 0xCF, 0xF8, 0x00, 0x3E,
  0xFF, 0x80, 0x01, 0xEF, 0xF8, 0x00, 0x1E, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xFF, 0x1F, 0x00, 0x00, 0xFE, 0x3E,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x0F,
  0xFE, 0x1F, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC1,
  0xFC, 0x01, 0xFC, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3D, 0xE0, 0x01, 0xF0, 0x00, 0xF7,
  0x80, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0x80, 0x1F, 0x78, 0x00, 0xEE,
  0x00, 0x7D, 0xE0, 0x03, 0xB8, 0x01, 0xF7, 0xC0, 0x0E, 0xE0, 0x07, 0x9F,
  0x00, 0x3B, 0x80, 0x1E, 0x7C, 0x00, 0xEE, 0x00, 0x78, 0xF0, 0x03, 0xB8,
  0x01, 0xE3, 0xC0, 0x1E, 0xF0, 0x07, 0x8F, 0x00, 0x73, 0xC0, 0x1E, 0x3C,
  0x01, 0xC7, 0x00, 0xF8, 0xF0, 0x07, 0x1C, 0x03, 0xE3, 0xC0, 0x1C, 0x70,
  0x0F, 0x0F, 0x80, 0x71, 0xC0, 0x3C, 0x3E, 0x01, 0xC7, 0x00, 0xF0, 0xF8,
  0x0F, 0x1C, 0x03, 0xC1, 0xE0, 0x3C, 0x78, 0x0F, 0x07, 0x80, 0xE1, 0xE0,
  0x3C, 0x1E, 0x03, 0x83, 0x80, 0xF0, 0x78, 0x0E, 0x0E, 0x07, 0xC1, 0xE0,
  0x38, 0x38, 0x1E, 0x07, 0xC0, 0xE0, 0xE0, 0x78, 0x1F, 0x03, 0x83, 0x81,
  0xE0, 0x7C, 0x1E, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x3C, 0x1E, 0x03, 0xC1,
  0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x07, 0x07,
  0x80, 0xF0, 0x70, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x70, 0xF0, 0x0F, 0x8F,
  0x01, 0xC3, 0xC0, 0x3E, 0x38, 0x07, 0x0F, 0x00, 0x78, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0x80, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1E, 0x38,
  0x03, 0x8F, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x01, 0xE7, 0x80, 0x39, 0xE0,
  0x07, 0xDC, 0x00, 0xE7, 0x80, 0x1F, 0x70, 0x03, 0x9E, 0x00, 0x3D, 0xC0,
  0x0F, 0x78, 0x00, 0xF7, 0x00, 0x1D, 0xE0, 0x03, 0xDC, 0x00, 0x77, 0x80,
  0x0F, 0x70, 0x01, 0xDE, 0x00, 0x3D, 0xC0, 0x07, 0x78, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x3B, 0xCF, 0xE0, 0x01, 0xEF, 0x1F, 0xF0, 0x3F, 0x3C,
  0x3F, 0xFF, 0xF8, 0xF0, 0x7F, 0xFF, 0xC3, 0xC0, 0x7F, 0xFC, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x7C, 0x1F, 0xFE, 0x03, 0xE3, 0xFF, 0xF8, 0x1F, 0x3F, 0xFF,
  0xF0, 0xFB, 0xF0, 0x7F, 0xC7, 0xDC, 0x00, 0x7E, 0x3F, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7F, 0x00,
  0x01, 0xF3, 0xFC, 0x00, 0x1F, 0x9F, 0x78, 0x03, 0xF8, 0xFB, 0xF8, 0x7F,
  0xC7, 0xCF, 0xFF, 0xFC, 0x3E, 0x3F, 0xFF, 0x81, 0xF0, 0x7F, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xF0, 0x1F, 0xFE, 0x0F, 0x07, 0xFF,
  0xF0, 0xF0, 0xFF, 0xFF, 0x8F, 0x1F, 0xF0, 0xFC, 0xF3, 0xF8, 0x01, 0xEF,
  0x3F, 0x00, 0x06, 0xF7, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x0E, 0xF3, 0xF8, 0x01, 0xEF, 0x1F, 0xF0, 0xFC,
  0xF0, 0xFF, 0xFF, 0x8F, 0x07, 0xFF, 0xF0, 0xF0, 0x1F, 0xFE, 0x0F, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x07, 0xFF, 0xF0, 0xF0, 0xFF,
  0xFF, 0x8F, 0x1F, 0xF0, 0xFC, 0xF3, 0xF8, 0x01, 0xEF, 0x3F, 0x00, 0x06,
  0xF7, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x06,
  0xF3, 0xF0, 0x00, 0xEF, 0x1F, 0xC0, 0x3E, 0xF0, 0xFF, 0xFF, 0xCF, 0x07,
  0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0x0F, 0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x83, 0xFF, 0xC0, 0xF8, 0xFF, 0xFE, 0x0F, 0x9F,
  0xFF, 0xF8, 0xFB, 0xF0, 0x7F, 0x8F, 0xB8, 0x01, 0xFC, 0xFF, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x00,
  0x0F, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0xFC, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x01,
  0xE0, 0xF1, 0xFE, 0x07, 0xF8, 0xF3, 0xFF, 0x0F, 0xFC, 0xF7, 0xFF, 0x9F,
  0xFE, 0xF6, 0x0F, 0x98, 0x7E, 0xF4, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xE0,
  0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xFF, 0xC0, 0xF8, 0xFF, 0xFE, 0x0F,
  0x9F, 0xFF, 0xF8, 0xFB, 0xF0, 0x7F, 0x8F, 0xBC, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3E, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x9F, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF,
  0x81, 0xF3, 0xFF, 0xFF, 0x0F, 0xBF, 0x07, 0xFC, 0x7D, 0xE0, 0x07, 0xE3,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7B, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFE, 0x00,
  0x01, 0xF7, 0xF0, 0x00, 0x1F, 0x3F, 0xC0, 0x01, 0xF9, 0xF7, 0x80, 0x3F,
  0x8F, 0xBF, 0x87, 0xF8, 0x7C, 0xFF, 0xFF, 0x83, 0xE3, 0xFF, 0xF8, 0x1F,
  0x07, 0xFF, 0x80, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x07, 0xFF,
  0xF0, 0xF0, 0xFF, 0xFF, 0x8F, 0x1F, 0xF0, 0xFC, 0xF3, 0xF8, 0x01, 0xEF,
  0x3F, 0x00, 0x06, 0xF7, 0xE0, 0x00, 0x7F, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x0E, 0xF3, 0xF8, 0x01, 0xEF, 0x1F, 0xF0, 0xFC,
  0xF0, 0xFF, 0xFF, 0x8F, 0x07, 0xFF, 0xF0, 0xF0, 0x1F, 0xFE, 0x0F, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x0F, 0x07, 0xFF, 0x80, 0xF1, 0xFF, 0xFE, 0x0F, 0x3F, 0xFF, 0xF0, 0xF3,
  0xE0, 0xFF, 0x8F, 0x78, 0x01, 0xFC, 0xF6, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7C,
  0xFE, 0x00, 0x0F, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x78, 0x00,
  0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x80, 0x0F, 0x78, 0x01, 0xF8, 0x00, 0xF7,
  0x80, 0x1D, 0xC0, 0x1F, 0x78, 0x01, 0xDC, 0x01, 0xE7, 0xC0, 0x1D, 0xC0,
  0x1E, 0x3C, 0x03, 0xDC, 0x01, 0xE3, 0xC0, 0x39, 0xC0, 0x1E, 0x3C, 0x03,
  0x9E, 0x01, 0xE3, 0xC0, 0x38, 0xE0, 0x3E, 0x3C, 0x03, 0x8E, 0x03, 0xC3,
  0xE0, 0x38, 0xE0, 0x3C, 0x1E, 0x07, 0x8E, 0x03, 0xC1, 0xE0, 0x70, 0xE0,
  0x3C, 0x1E, 0x07, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x70, 0x3C, 0x1E, 0x07,
  0x07, 0x07, 0x81, 0xF0, 0x70, 0x70, 0x78, 0x0F, 0x0E, 0x07, 0x07, 0x80,
  0xF0, 0xE0, 0x78, 0x78, 0x0F, 0x0E, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x38,
  0x78, 0x0F, 0x0E, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x38, 0xF0, 0x07, 0x9C,
  0x03, 0x8F, 0x00, 0x79, 0xC0, 0x3C, 0xF0, 0x07, 0x9C, 0x01, 0xCF, 0x00,
  0x79, 0xC0, 0x1C, 0xE0, 0x07, 0x9C, 0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x1D,
  0xE0, 0x03, 0xB8, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x0F, 0x3F,
  0xFF, 0x00, 0x0F, 0x7E, 0x1F, 0x80, 0x0F, 0x7C, 0x0F, 0xC0, 0x0F, 0x78,
  0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x1F, 0xF8,
  0x00, 0xFC, 0x3E, 0xF8, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x3F, 0xFC, 0xF8,
  0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 9, 52, 43, 17, -52 },
  { 60, 20, 21, 43, 11, -52 },
  { 113, 38, 52, 43, 2, -52 },
  { 360, 31, 72, 43, 6, -62 },
  { 639, 40, 52, 43, 1, -52 },
  { 899, 36, 54, 43, 4, -53 },
  { 1142, 6, 21, 43, 18, -52 },
  { 1158, 20, 69, 43, 14, -60 },
  { 1331, 21, 69, 43, 8, -60 },
  { 1513, 37, 36, 43, 3, -43 },
  { 1680, 33, 33, 43, 5, -40 },
  { 1817, 13, 22, 43, 13, -11 },
  { 1853, 23, 5, 43, 10, -26 },
  { 1868, 11, 11, 43, 16, -10 },
  { 1884, 30, 67, 43, 6, -59 },
  { 2136, 30, 54, 43, 6, -53 },
  { 2339, 31, 52, 43, 7, -52 },
  { 2541, 31, 53, 43, 6, -53 },
  { 2747, 29, 53, 43, 6, -52 },
  { 2940, 28, 52, 43, 7, -52 },
  { 3122, 29, 53, 43, 7, -52 },
  { 3315, 31, 53, 43, 6, -52 },
  { 3521, 32, 52, 43, 6, -52 },
  { 3729, 31, 54, 43, 6, -53 },
  { 3939, 31, 53, 43, 6, -53 },
  { 4145, 11, 41, 43, 16, -40 },
  { 4202, 14, 51, 43, 13, -40 },
  { 4292, 30, 37, 43, 6, -42 },
  { 4431, 30, 21, 43, 6, -34 },
  { 4510, 30, 37, 43, 6, -42 },
  { 4649, 24, 52, 43, 11, -52 },
  { 4805, 35, 66, 43, 4, -53 },
  { 5094, 34, 52, 43, 4, -52 },
  { 5315, 30, 52, 43, 7, -52 },
  { 5510, 29, 54, 43, 7, -53 },
  { 5706, 29, 52, 43, 7, -52 },
  { 5895, 29, 52, 43, 8, -52 },
  { 6084, 29, 52, 43, 8, -52 },
  { 6273, 29, 54, 43, 7, -53 },
  { 6469, 28, 52, 43, 7, -52 },
  { 6651, 27, 52, 43, 8, -52 },
  { 6827, 31, 53, 43, 4, -52 },
  { 7033, 32, 52, 43, 7, -52 },
  { 7241, 30, 52, 43, 8, -52 },
  { 7436, 31, 52, 43, 6, -52 },
  { 7638, 28, 52, 43, 7, -52 },
  { 7820, 29, 54, 43, 7, -53 },
  { 8016, 31, 52, 43, 7, -52 },
  { 8218, 30, 66, 43, 7, -53 },
  { 8466, 31, 52, 43, 7, -52 },
  { 8668, 31, 54, 43, 6, -53 },
  { 8878, 34, 52, 43, 4, -52 },
  { 9099, 28, 53, 43, 7, -52 },
  { 9285, 34, 52, 43, 4, -52 },
  { 9506, 38, 52, 43, 2, -52 },
  { 9753, 36, 52, 43, 3, -52 },
  { 9987, 36, 52, 43, 3, -52 },
  { 10221, 30, 52, 43, 6, -52 },
  { 10416, 17, 67, 43, 15, -59 },
  { 10559, 30, 67, 43, 6, -59 },
  { 10811, 16, 67, 43, 11, -59 },
  { 10945, 29, 28, 43, 7, -52 },
  { 11047, 34, 4, 43, 4, 2 },
  { 11064, 13, 10, 43, 14, -56 },
  { 11081, 30, 41, 43, 5, -40 },
  { 11235, 29, 53, 43, 7, -52 },
  { 11428, 29, 41, 43, 7, -40 },
  { 11577, 28, 53, 43, 7, -52 },
  { 11763, 29, 41, 43, 7, -40 },
  { 11912, 32, 52, 43, 5, -52 },
  { 12120, 28, 53, 43, 7, -40 },
  { 12306, 28, 52, 43, 7, -52 },
  { 12488, 33, 55, 43, 6, -55 },
  { 12715, 26, 68, 43, 6, -55 },
  { 12936, 30, 52, 43, 8, -52 },
  { 13131, 36, 52, 43, 3, -52 },
  { 13365, 32, 40, 43, 5, -40 },
  { 13525, 28, 40, 43, 7, -40 },
  { 13665, 29, 41, 43, 7, -40 },
  { 13814, 29, 53, 43, 7, -40 },
  { 14007, 28, 53, 43, 7, -40 },
  { 14193, 28, 40, 43, 9, -40 },
  { 14333, 29, 41, 43, 7, -40 },
  { 14482, 31, 50, 43, 5, -50 },
  { 14676, 28, 40, 43, 7, -39 },
  { 14816, 33, 39, 43, 5, -39 },
  { 14977, 36, 39, 43, 3, -39 },
  { 15153, 33, 39, 43, 5, -39 },
  { 15314, 33, 52, 43, 5, -39 },
  { 15529, 29, 39, 43, 7, -39 },
  { 15671, 29, 67, 43, 7, -59 },
  { 15914, 5, 67, 43, 19, -59 },
  { 15956, 29, 67, 43, 7, -59 },
  { 16199, 32, 14, 43, 5, -32 },
};

const GFXfont JetBrainsMono_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_EXTRALIGHT71PT7B_H_
