#ifndef _JETBRAINSMONO_EXTRALIGHT43PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x70, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x1E, 0xFF, 0xF7,
  0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0x60, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x83, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x67,
  0x87, 0x0C, 0x38, 0xE1, 0x87, 0x38, 0x30, 0x77, 0x06, 0x0E, 0xE0, 0xC0,
  0x1C, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x8C, 0x00, 0x79, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0x3C,
  0x00, 0x61, 0xC0, 0x0C, 0x3C, 0x01, 0x83, 0x80, 0x30, 0x70, 0x06, 0x0F,
  0xC0, 0xC1, 0xD8, 0x18, 0x3B, 0x83, 0x07, 0x70, 0x60, 0xE7, 0x0C, 0x38,
  0xF9, 0x9E, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x01, 0x3F, 0x80, 0x06, 0x7F, 0xC0, 0x0E, 0x60, 0xE0, 0x0C, 0xE0, 0x60,
  0x18, 0xE0, 0x60, 0x38, 0xE0, 0x60, 0x30, 0xE0, 0x60, 0x60, 0xE0, 0x60,
  0xE0, 0xE0, 0x61, 0xC0, 0xE0, 0x61, 0x80, 0x60, 0xE3, 0x00, 0x7B, 0xE7,
  0x00, 0x3F, 0xC6, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x71, 0xF8, 0x00, 0xE3, 0xFC, 0x00, 0xC7,
  0x0E, 0x01, 0xC6, 0x06, 0x03, 0x8E, 0x07, 0x03, 0x0E, 0x07, 0x06, 0x0E,
  0x07, 0x0E, 0x0E, 0x07, 0x0C, 0x0E, 0x07, 0x18, 0x0E, 0x07, 0x38, 0x06,
  0x06, 0x30, 0x07, 0x0E, 0x60, 0x03, 0xFC, 0xE0, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x38, 0x1E, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0x00, 0x71, 0xC0, 0x0F, 0x0F, 0x03, 0xB8, 0x38, 0x1D,
  0xC0, 0xE1, 0xCC, 0x03, 0x8E, 0x60, 0x1C, 0xE3, 0x00, 0x77, 0x18, 0x01,
  0xF0, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x8F,
  0x03, 0xCE, 0x3C, 0x3C, 0x71, 0xFF, 0xC1, 0xC3, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF6, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x18, 0xC0, 0x0F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xFC, 0x0F, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x04, 0x03, 0x00, 0xBE, 0x0C, 0x1F, 0xFE, 0x31,
  0xFD, 0xFE, 0xDF, 0xC0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x00, 0x1C,
  0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x0C, 0x01, 0xC0, 0x10, 0x02,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x3C, 0x70, 0x07, 0xBC, 0x00,
  0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1,
  0xE1, 0xF8, 0x78, 0x7E, 0x08, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3D,
  0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x07, 0xC7, 0x01, 0xE0,
  0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xC0, 0x78, 0x38,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xEE, 0x00, 0xE7, 0xC1, 0xE1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x70, 0x0E, 0x70,
  0x07, 0x78, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0x01, 0xCF, 0xF0,
  0x7F, 0xFF, 0x1F, 0x03, 0xC7, 0x80, 0x79, 0xC0, 0x0E, 0x70, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E,
  0x3C, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xCF, 0xC0, 0x3F, 0xFE, 0x0F, 0xC3, 0xE1, 0xE0, 0x1E, 0x78, 0x01, 0xCE,
  0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xE0, 0x07, 0x1E,
  0x01, 0xE1, 0xF0, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0xE7, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x70, 0x03, 0x9C, 0x00,
  0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00, 0x39,
  0xC0, 0x0E, 0x38, 0x07, 0x07, 0x87, 0x80, 0xFF, 0x80, 0x0F, 0xC0, 0x07,
  0xF8, 0x07, 0xCF, 0x03, 0xC0, 0xF1, 0xE0, 0x1E, 0x70, 0x03, 0xB8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0x70, 0x07, 0x9F, 0x03, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x03, 0xC3, 0x80, 0x1C, 0xE0,
  0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x79, 0xC0,
  0x0E, 0x3C, 0x07, 0xC3, 0xFF, 0xB8, 0x3F, 0xEE, 0x00, 0xF3, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFE, 0x1E, 0x3F, 0x7F,
  0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x3F, 0x07, 0xF8, 0x1F, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x00,
  0x03, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80, 0x00, 0x76, 0x00, 0x01,
  0xF8, 0x03, 0xC7, 0xE0, 0x3F, 0xDF, 0x81, 0xF3, 0xFE, 0x07, 0x03, 0xF8,
  0x18, 0x07, 0xE0, 0xE0, 0x1F, 0x83, 0x80, 0x7E, 0x0E, 0x01, 0xF8, 0x38,
  0x07, 0xE0, 0xE0, 0x1F, 0x83, 0x80, 0x7E, 0x0E, 0x01, 0xF8, 0x38, 0x07,
  0xE0, 0x60, 0x1F, 0x81, 0xC0, 0xFE, 0x07, 0x03, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xDD, 0x80, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00, 0x39, 0x80, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x03, 0x1C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x60, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0C, 0x03, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x00, 0xC7, 0x00,
  0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0xFF, 0xF8, 0x3F, 0xFF, 0x8E, 0x01, 0xF3, 0x80, 0x1E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x1F, 0x8F, 0xFF, 0x83,
  0xFF, 0xF8, 0xE0, 0x0F, 0x38, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x03, 0x9C,
  0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0E, 0x03, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0xB8,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x73, 0x80, 0x3C, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78,
  0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87, 0xC1, 0xFF, 0xE0,
  0x1F, 0xF0, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEF, 0x00, 0x39, 0xC0,
  0x1E, 0x3C, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x00, 0xEE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x60, 0x1B, 0xD8, 0x0E, 0xF7,
  0x03, 0x3C, 0xC0, 0xCF, 0x30, 0x73, 0xCE, 0x18, 0xF1, 0x86, 0x7C, 0x63,
  0x9F, 0x1C, 0xC7, 0xC3, 0x31, 0xF0, 0xDC, 0x7C, 0x1E, 0x1F, 0x07, 0x87,
  0xC1, 0xE1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3E, 0xC0, 0x1F, 0x60, 0x0F, 0xB8,
  0x07, 0xCC, 0x03, 0xE7, 0x01, 0xF3, 0x80, 0xF8, 0xC0, 0x7C, 0x70, 0x3E,
  0x18, 0x1F, 0x0E, 0x0F, 0x87, 0x07, 0xC1, 0x83, 0xE0, 0xE1, 0xF0, 0x70,
  0xF8, 0x18, 0x7C, 0x0E, 0x3E, 0x03, 0x1F, 0x01, 0xCF, 0x80, 0xE7, 0xC0,
  0x33, 0xE0, 0x1D, 0xF0, 0x06, 0xF8, 0x03, 0x7C, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1E, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0,
  0x3C, 0x70, 0x07, 0x9C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x07, 0x0F, 0x87, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0x80, 0x3E, 0x70,
  0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0xC0,
  0x07, 0xB8, 0x01, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF0, 0x3C, 0x70, 0x07, 0x9C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x07, 0x8F,
  0x87, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0x80, 0x7E, 0x70, 0x01, 0xCE, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x0F, 0xE7,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xB8,
  0x00, 0x78, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0x03, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0,
  0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x1C, 0x7C,
  0x0F, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xEF, 0x00, 0xE3, 0xE1, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x18,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x30, 0x0C, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x19, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x06, 0xC0, 0x78, 0x1D, 0x80, 0xF0,
  0x3B, 0x81, 0xE0, 0x77, 0x03, 0xC0, 0xEE, 0x07, 0x81, 0xDC, 0x19, 0x83,
  0xB8, 0x33, 0x06, 0x30, 0x66, 0x0C, 0x60, 0xCC, 0x18, 0xC1, 0x98, 0x71,
  0xC3, 0x30, 0xE3, 0x86, 0x61, 0xC7, 0x18, 0xC3, 0x8E, 0x30, 0xC7, 0x1C,
  0x61, 0x8C, 0x18, 0xC3, 0x18, 0x31, 0x86, 0x30, 0x63, 0x0C, 0x60, 0xC6,
  0x19, 0xC1, 0xC8, 0x33, 0x83, 0xB0, 0x27, 0x07, 0x60, 0x6E, 0x0E, 0xC0,
  0xD8, 0x1D, 0x81, 0xB0, 0x1B, 0x03, 0x60, 0x36, 0x06, 0xC0, 0x68, 0x0D,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00,
  0x38, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x38, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x38, 0x03, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0E,
  0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x0C, 0xC0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x0C,
  0x0C, 0x07, 0x03, 0x81, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00,
  0xE7, 0x00, 0x3B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xF8, 0x70, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF,
  0xDE, 0x00, 0x37, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x07, 0x70, 0x02, 0xDF, 0x03, 0xB3, 0xFF, 0xCC, 0x3F,
  0xE3, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x87, 0xE0, 0xE7, 0xFE, 0x3B, 0xCF, 0xCE,
  0x80, 0x73, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0x6E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xEF,
  0x00, 0x3B, 0xE0, 0x1E, 0xEC, 0x0F, 0x39, 0xFF, 0x8E, 0x3F, 0xC0, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xE0, 0x1E, 0x70, 0x03, 0x9C, 0x00,
  0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87,
  0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x0F, 0xC3, 0x1F, 0xF9,
  0x9F, 0xBE, 0xDE, 0x03, 0x6E, 0x00, 0xF7, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xDC, 0x00, 0xEF, 0x00, 0xB3, 0xC1, 0xD8, 0xFF, 0xCC, 0x3F, 0xC6, 0x07,
  0xF0, 0x07, 0xFF, 0x03, 0xF3, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x9C, 0x00,
  0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x03,
  0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xE1, 0x8F, 0xFC, 0xCF, 0xDF, 0x6F, 0x01, 0xB7, 0x00, 0x7B, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB8,
  0x01, 0xDE, 0x01, 0x67, 0x83, 0xB1, 0xFF, 0x98, 0x7F, 0x8C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xF0,
  0xE7, 0xFE, 0x77, 0x9F, 0xBA, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x06, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x01, 0xEC,
  0x00, 0x73, 0x00, 0x38, 0xC0, 0x1E, 0x30, 0x0F, 0x0C, 0x03, 0x83, 0x01,
  0xC0, 0xC0, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xC0, 0xE0,
  0x30, 0x1C, 0x0C, 0x07, 0x83, 0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x07, 0x8C,
  0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x07, 0xB0, 0x00, 0xEC, 0x00, 0x1C, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0xE7, 0x87, 0x8E,
  0xFC, 0xFC, 0xF9, 0xF9, 0xEF, 0x0F, 0x0E, 0xE0, 0xE0, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60,
  0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06,
  0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE1, 0xF8, 0x73,
  0xFF, 0x3B, 0xCF, 0xDD, 0x00, 0xEF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x9C,
  0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x07, 0x0F,
  0x87, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xF3,
  0xF3, 0xE0, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x1B, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x3B, 0xC0, 0x0E, 0xF8, 0x07, 0xBB, 0x83, 0xCE, 0x7F, 0xE3, 0x8F, 0xF0,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE1, 0x8F, 0xFC, 0xCF, 0xDF,
  0x6F, 0x01, 0xB7, 0x00, 0x7B, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00, 0xEE, 0x00,
  0x77, 0x80, 0x59, 0xE0, 0xEC, 0x7F, 0xE6, 0x1F, 0xE3, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0xE3, 0xF8, 0x39, 0xFF, 0x8E, 0xF3, 0xF3, 0xE0, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xE0, 0x1E, 0x70, 0x03, 0x9C, 0x00, 0x76, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x03, 0x9F, 0x01, 0xE3, 0xFF, 0xF0,
  0x3F, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x80, 0x71, 0xF0,
  0xF8, 0x7F, 0xF8, 0x0F, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x18, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x70, 0x1F, 0x81, 0xE0, 0x7E, 0x07,
  0x81, 0xF8, 0x1E, 0x06, 0x60, 0x78, 0x19, 0x81, 0x60, 0x66, 0x0C, 0x83,
  0x9C, 0x33, 0x0E, 0x70, 0xCC, 0x39, 0xC3, 0x30, 0xC3, 0x0C, 0xC3, 0x0C,
  0x23, 0x0C, 0x31, 0x86, 0x70, 0xE6, 0x19, 0xC3, 0x98, 0x67, 0x0E, 0x61,
  0x98, 0x19, 0x86, 0x60, 0x6C, 0x19, 0x81, 0xB0, 0x3E, 0x06, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0xF0,
  0x00, 0xF7, 0x00, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x38, 0x1C, 0x07, 0x80,
  0xE0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8,
  0x00, 0x39, 0xC0, 0x07, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x01, 0xC0,
  0x38, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E,
  0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x6F, 0xF0, 0x0D, 0xC7, 0x01, 0xF0, 0x70, 0x3E, 0x07, 0x07, 0xC0,
  0x7B, 0xF8, 0x07, 0xF7, 0x00, 0x7C,
};

const GFXglyph JetBrainsMono_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 12, 13, 26, 7, -31 },
  { 45, 23, 31, 26, 1, -31 },
  { 135, 19, 43, 26, 3, -37 },
  { 238, 24, 32, 26, 1, -32 },
  { 334, 21, 32, 26, 3, -32 },
  { 418, 3, 13, 26, 11, -31 },
  { 423, 13, 41, 26, 8, -36 },
  { 490, 12, 41, 26, 5, -36 },
  { 552, 22, 22, 26, 2, -26 },
  { 613, 20, 20, 26, 3, -24 },
  { 663, 8, 14, 26, 8, -7 },
  { 677, 14, 2, 26, 6, -15 },
  { 681, 6, 6, 26, 10, -6 },
  { 686, 18, 41, 26, 4, -36 },
  { 779, 18, 32, 26, 4, -32 },
  { 851, 19, 31, 26, 4, -31 },
  { 925, 20, 32, 26, 3, -32 },
  { 1005, 17, 31, 26, 4, -31 },
  { 1071, 17, 31, 26, 4, -31 },
  { 1137, 18, 31, 26, 4, -31 },
  { 1207, 19, 31, 26, 3, -31 },
  { 1281, 19, 31, 26, 4, -31 },
  { 1355, 18, 32, 26, 4, -32 },
  { 1427, 19, 32, 26, 3, -32 },
  { 1503, 6, 24, 26, 10, -24 },
  { 1521, 8, 31, 26, 8, -24 },
  { 1552, 18, 22, 26, 4, -25 },
  { 1602, 18, 12, 26, 4, -20 },
  { 1629, 18, 22, 26, 4, -25 },
  { 1679, 14, 31, 26, 7, -31 },
  { 1734, 22, 40, 26, 2, -32 },
  { 1844, 20, 31, 26, 3, -31 },
  { 1922, 18, 31, 26, 4, -31 },
  { 1992, 18, 32, 26, 4, -32 },
  { 2064, 18, 31, 26, 4, -31 },
  { 2134, 17, 31, 26, 5, -31 },
  { 2200, 18, 31, 26, 5, -31 },
  { 2270, 18, 32, 26, 4, -32 },
  { 2342, 17, 31, 26, 4, -31 },
  { 2408, 16, 31, 26, 5, -31 },
  { 2470, 18, 31, 26, 3, -31 },
  { 2540, 20, 31, 26, 4, -31 },
  { 2618, 18, 31, 26, 5, -31 },
  { 2688, 18, 31, 26, 4, -31 },
  { 2758, 17, 31, 26, 4, -31 },
  { 2824, 18, 32, 26, 4, -32 },
  { 2896, 19, 31, 26, 4, -31 },
  { 2970, 18, 40, 26, 4, -32 },
  { 3060, 19, 31, 26, 4, -31 },
  { 3134, 19, 32, 26, 3, -32 },
  { 3210, 21, 31, 26, 2, -31 },
  { 3292, 17, 31, 26, 4, -31 },
  { 3358, 20, 31, 26, 3, -31 },
  { 3436, 23, 31, 26, 1, -31 },
  { 3526, 22, 31, 26, 2, -31 },
  { 3612, 22, 31, 26, 2, -31 },
  { 3698, 18, 31, 26, 4, -31 },
  { 3768, 10, 41, 26, 9, -36 },
  { 3820, 18, 41, 26, 4, -36 },
  { 3913, 10, 41, 26, 7, -36 },
  { 3965, 18, 16, 26, 4, -31 },
  { 4001, 20, 3, 26, 3, 1 },
  { 4009, 8, 6, 26, 8, -34 },
  { 4015, 18, 24, 26, 3, -24 },
  { 4069, 18, 31, 26, 4, -31 },
  { 4139, 18, 24, 26, 4, -24 },
  { 4193, 17, 31, 26, 4, -31 },
  { 4259, 18, 24, 26, 4, -24 },
  { 4313, 20, 31, 26, 3, -31 },
  { 4391, 17, 32, 26, 4, -24 },
  { 4459, 17, 31, 26, 4, -31 },
  { 4525, 19, 33, 26, 4, -33 },
  { 4604, 15, 41, 26, 4, -33 },
  { 4681, 18, 31, 26, 5, -31 },
  { 4751, 21, 31, 26, 2, -31 },
  { 4833, 20, 24, 26, 3, -24 },
  { 4893, 17, 24, 26, 4, -24 },
  { 4944, 18, 24, 26, 4, -24 },
  { 4998, 18, 32, 26, 4, -24 },
  { 5070, 17, 32, 26, 4, -24 },
  { 5138, 18, 24, 26, 5, -24 },
  { 5192, 18, 24, 26, 4, -24 },
  { 5246, 19, 30, 26, 3, -30 },
  { 5318, 17, 24, 26, 4, -24 },
  { 5369, 20, 24, 26, 3, -24 },
  { 5429, 22, 24, 26, 2, -24 },
  { 5495, 20, 24, 26, 3, -24 },
  { 5555, 20, 32, 26, 3, -24 },
  { 5635, 18, 24, 26, 4, -24 },
  { 5689, 18, 41, 26, 4, -36 },
  { 5782, 3, 41, 26, 11, -36 },
  { 5798, 18, 41, 26, 4, -36 },
  { 5891, 19, 8, 26, 3, -19 },
};

const GFXfont JetBrainsMono_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_EXTRALIGHT43PT7B_H_
