#ifndef _JETBRAINSMONO_EXTRALIGHT61PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0xC0, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xF8, 0xE3, 0xF0, 0x7C, 0x1C, 0x1F, 0x0F, 0x03, 0x81,
  0xE1, 0xE0, 0x70, 0x3E, 0x78, 0x0E, 0x03, 0xCF, 0x01, 0xC0, 0x79, 0xE0,
  0x38, 0x0F, 0x3C, 0x07, 0x01, 0xE7, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00,
  0x1F, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE1,
  0xC0, 0x00, 0x7E, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x38, 0x7E, 0x00, 0x07, 0x07, 0xC0,
  0x00, 0xE0, 0x7C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70,
  0x1F, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8,
  0x07, 0x00, 0xFF, 0x00, 0xE0, 0x3D, 0xF0, 0x1C, 0x07, 0x9E, 0x03, 0x81,
  0xF3, 0xE0, 0x70, 0x3C, 0x3F, 0x0E, 0x1F, 0x83, 0xF9, 0xCF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE1, 0xFF, 0x00, 0x00,
  0x78, 0x7F, 0xF8, 0x00, 0x0E, 0x1F, 0x9F, 0x00, 0x03, 0x87, 0x80, 0xF0,
  0x00, 0xF0, 0xF0, 0x0E, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x70, 0x07, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x00, 0x78, 0x1C,
  0x00, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0x38,
  0x38, 0x00, 0x7C, 0x0F, 0x0E, 0x00, 0x07, 0xFF, 0xC3, 0xC0, 0x00, 0x7F,
  0xF0, 0x70, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x00, 0x1C,
  0x1F, 0xF8, 0x00, 0x07, 0x87, 0xFF, 0x80, 0x00, 0xE1, 0xF0, 0xF8, 0x00,
  0x38, 0x38, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0xF0, 0x03, 0xC1, 0xC0, 0x1E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x07, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x1C, 0x0F, 0x00,
  0x70, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x1E, 0x1E,
  0x00, 0x3C, 0x03, 0x83, 0x80, 0x03, 0xC0, 0xF0, 0xE0, 0x00, 0x3F, 0xFC,
  0x3C, 0x00, 0x07, 0xFF, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F,
  0x0F, 0x80, 0x1F, 0xF8, 0x1E, 0x00, 0x7B, 0xC0, 0x7C, 0x03, 0xCF, 0x00,
  0xF8, 0x0F, 0x3C, 0x01, 0xE0, 0x78, 0xF0, 0x03, 0xC1, 0xE3, 0xC0, 0x0F,
  0x8F, 0x0F, 0x00, 0x1F, 0x7C, 0x3C, 0x00, 0x3D, 0xE0, 0xF0, 0x00, 0x7F,
  0x83, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xFE, 0x0F, 0x00, 0x07, 0xFC, 0x3E,
  0x00, 0x3C, 0xF0, 0x7C, 0x01, 0xF1, 0xE1, 0xF8, 0x1F, 0x87, 0xC3, 0xFF,
  0xFC, 0x0F, 0x87, 0xFF, 0xC0, 0x1E, 0x0F, 0xFE, 0x00, 0x3C, 0x03, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBC, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x03, 0xC0, 0x06, 0x7E, 0x03, 0xC0, 0x3E, 0x7F, 0x81, 0xC1, 0xFF,
  0xFF, 0xE1, 0xC7, 0xFF, 0x1F, 0xF9, 0xDF, 0xFC, 0x07, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x07, 0xC3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x38, 0x0F, 0xF8, 0x1F, 0x03,
  0xFE, 0x0F, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0xFC, 0x0F, 0xF8, 0x1F,
  0x03, 0xFE, 0x03, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0x9E, 0x00, 0x07, 0xE3, 0xC0, 0x03, 0xF0, 0x78,
  0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x60,
  0x07, 0x80, 0x08, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x0F,
  0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x7F, 0xC0, 0x3C, 0xFF, 0xF8, 0x1E, 0xFF,
  0xFE, 0x0F, 0xFC, 0x7F, 0x87, 0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0xC0,
  0x7E, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x0F, 0xBF, 0xFC, 0x01, 0xEF, 0xFF,
  0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x1F,
  0x80, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x0F, 0xC7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x03,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xE0, 0x0F, 0xFE, 0x78, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x83, 0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0xF3, 0xFF, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x0C, 0x0F,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0x7F,
  0x80, 0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x03, 0xFE, 0x01, 0xE0, 0x07, 0xFC,
  0x03, 0xC0, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0xF0, 0x0F, 0x00, 0x1F, 0xE0,
  0x1E, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x7F, 0x80, 0x78, 0x00, 0xFF, 0x00,
  0xF0, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07,
  0x80, 0x0F, 0xF0, 0x0F, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0xC0, 0x3C,
  0x00, 0x7F, 0x80, 0x78, 0x01, 0xFF, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0xF7, 0xB8, 0x01, 0xFF, 0xEF, 0x70, 0x01, 0xFF,
  0x1E, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF0, 0x01, 0xFC, 0x3C,
  0x00, 0x1F, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x03, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xF0,
  0x07, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x60, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x00,
  0x3F, 0x87, 0x80, 0x07, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF9,
  0xE0, 0x00, 0xF8, 0xF0, 0x01, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xF0, 0x07, 0xE1, 0xF0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0xE0, 0x3F,
  0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xB8, 0x00, 0x3F, 0xEE, 0x00, 0x1F, 0xFB,
  0xC0, 0x07, 0x7F, 0x70, 0x01, 0xDF, 0xDC, 0x00, 0xF7, 0xF7, 0x80, 0x39,
  0xFC, 0xE0, 0x0E, 0x7F, 0x38, 0x07, 0x9F, 0xCF, 0x01, 0xC7, 0xF1, 0xC0,
  0x71, 0xFC, 0x70, 0x3C, 0x7F, 0x1E, 0x0E, 0x1F, 0xC3, 0x83, 0x87, 0xF0,
  0xE1, 0xE1, 0xFC, 0x3C, 0x70, 0x7F, 0x07, 0x1C, 0x3F, 0xC1, 0xCF, 0x0F,
  0xF0, 0x3B, 0x83, 0xFC, 0x0E, 0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0x7C,
  0x0F, 0xF0, 0x1F, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF7, 0x00, 0x0F, 0xF7, 0x80,
  0x0F, 0xF3, 0x80, 0x0F, 0xF3, 0x80, 0x0F, 0xF3, 0xC0, 0x0F, 0xF1, 0xC0,
  0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF0, 0xE0, 0x0F, 0xF0, 0xF0,
  0x0F, 0xF0, 0x70, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x38,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x1C, 0x0F, 0xF0, 0x1E,
  0x0F, 0xF0, 0x0E, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x07,
  0x0F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x03, 0xCF, 0xF0, 0x03,
  0xCF, 0xF0, 0x01, 0xC7, 0xF0, 0x01, 0xE7, 0xF0, 0x01, 0xE7, 0xF0, 0x00,
  0xE7, 0xF0, 0x00, 0xF7, 0xF0, 0x00, 0xF7, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFE,
  0xFF, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x7E,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x83, 0xF0, 0x07,
  0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x7E,
  0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xCF,
  0x00, 0x03, 0xF1, 0xE0, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFD,
  0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3C, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xBC, 0x00, 0xF8, 0x01, 0xDE, 0x00,
  0x7C, 0x01, 0xE7, 0x00, 0x36, 0x00, 0xF3, 0x80, 0x3B, 0x00, 0x79, 0xE0,
  0x1D, 0xC0, 0x3C, 0xF0, 0x0E, 0xE0, 0x1E, 0x78, 0x07, 0x70, 0x0F, 0x3C,
  0x03, 0xB8, 0x07, 0x1E, 0x01, 0xDC, 0x03, 0x8F, 0x00, 0xCE, 0x01, 0xC3,
  0x80, 0x63, 0x01, 0xE1, 0xC0, 0x71, 0x80, 0xF0, 0xE0, 0x38, 0xE0, 0x78,
  0x78, 0x1C, 0x70, 0x3C, 0x3C, 0x0E, 0x38, 0x1E, 0x1E, 0x07, 0x1C, 0x0E,
  0x0F, 0x03, 0x0E, 0x07, 0x07, 0x81, 0x87, 0x03, 0x83, 0xC1, 0xC1, 0x81,
  0xC0, 0xE0, 0xE0, 0xC1, 0xE0, 0x70, 0x70, 0x70, 0xF0, 0x3C, 0x38, 0x38,
  0x78, 0x1E, 0x1C, 0x1C, 0x3C, 0x0F, 0x0C, 0x0E, 0x1C, 0x07, 0x86, 0x07,
  0x0E, 0x03, 0xC3, 0x03, 0x87, 0x01, 0xE3, 0x80, 0xC3, 0x80, 0x71, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x39, 0xE0, 0x1C, 0x70, 0x1C, 0xF0, 0x0F, 0x38,
  0x0E, 0x78, 0x07, 0x98, 0x07, 0x3C, 0x03, 0xCC, 0x03, 0x9C, 0x01, 0xEE,
  0x00, 0xCE, 0x00, 0xF7, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x1D,
  0xC0, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0x60, 0x07, 0xF0, 0x03,
  0xB0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x9E, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0x7F, 0xC1, 0xF8, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xC0, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFB, 0xE0,
  0x01, 0xFD, 0xFC, 0x03, 0xDE, 0x7F, 0xFF, 0xEF, 0x1F, 0xFF, 0xE7, 0x83,
  0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0xF8, 0x0F, 0x0F, 0xFF, 0x07, 0x9F,
  0xFF, 0xC3, 0xDF, 0x8F, 0xF1, 0xEE, 0x00, 0xFC, 0xFE, 0x00, 0x3E, 0x7E,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3C, 0xF6,
  0x00, 0x3E, 0x7B, 0xC0, 0x7E, 0x3C, 0xFF, 0xFE, 0x1E, 0x3F, 0xFE, 0x0F,
  0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x00,
  0xF1, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F,
  0xFF, 0xCF, 0x1F, 0xC3, 0xEF, 0x3F, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F,
  0x80, 0xEF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0x3F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F,
  0x0F, 0xFF, 0xCF, 0x1F, 0xC3, 0xEF, 0x3F, 0x00, 0x7F, 0x7C, 0x00, 0x3F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0x3E, 0x00, 0x7F, 0x3F, 0x00, 0xEF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF,
  0x03, 0xFF, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0xC0, 0xF0, 0xFF, 0xF0,
  0xF3, 0xFF, 0xF8, 0xF7, 0xC1, 0xFC, 0xF7, 0x00, 0x7E, 0xFE, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x3E, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0xE3, 0xF0, 0x3F, 0x1C, 0xFF, 0x1F, 0xF3, 0xBF,
  0xF3, 0xFF, 0x76, 0x3E, 0xC3, 0xEF, 0x03, 0xF0, 0x3F, 0xE0, 0x3E, 0x03,
  0xFC, 0x07, 0x80, 0x7F, 0x00, 0xF0, 0x0F, 0xE0, 0x0E, 0x01, 0xFC, 0x01,
  0xC0, 0x3F, 0x80, 0x38, 0x07, 0xF0, 0x07, 0x00, 0xFE, 0x00, 0xE0, 0x1F,
  0xC0, 0x1C, 0x03, 0xF8, 0x03, 0x80, 0x7F, 0x00, 0x70, 0x0F, 0xE0, 0x0E,
  0x01, 0xFC, 0x01, 0xC0, 0x3F, 0x80, 0x38, 0x07, 0xF0, 0x07, 0x00, 0xFE,
  0x00, 0xE0, 0x1F, 0xC0, 0x1C, 0x03, 0xF8, 0x03, 0x80, 0x7F, 0x00, 0x70,
  0x0F, 0xE0, 0x0E, 0x01, 0xFC, 0x01, 0xC0, 0x3F, 0x80, 0x38, 0x07, 0xF0,
  0x07, 0x00, 0xFE, 0x00, 0xE0, 0x1F, 0xC0, 0x1C, 0x03, 0xF8, 0x03, 0x80,
  0x7F, 0x00, 0x70, 0x0F, 0xE0, 0x0E, 0x01, 0xFC, 0x01, 0xC0, 0x3C, 0xF0,
  0x7F, 0xC0, 0xF0, 0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF3, 0xE3, 0xFC, 0xF7,
  0x00, 0x7E, 0xF6, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFC, 0xFF, 0x83, 0xF0, 0x07, 0xC1, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xE1,
  0xF0, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x7F, 0xC0, 0x78, 0x7F,
  0xF8, 0x3C, 0xFF, 0xFE, 0x1E, 0xFC, 0x7F, 0x8F, 0x70, 0x07, 0xE7, 0xF0,
  0x01, 0xF3, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x80, 0x03, 0xEF, 0xC0,
  0x01, 0xE7, 0xB0, 0x01, 0xF3, 0xDE, 0x03, 0xF1, 0xE7, 0xFF, 0xF0, 0xF1,
  0xFF, 0xF0, 0x78, 0x7F, 0xF0, 0x3C, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0xFF,
  0xCF, 0x1F, 0xC3, 0xEF, 0x3F, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x80,
  0xEF, 0x1F, 0xFF, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00, 0x30,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x78, 0x7F,
  0xF8, 0x3C, 0xFF, 0xFE, 0x1E, 0x78, 0x3F, 0x8F, 0x70, 0x07, 0xE7, 0xB0,
  0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xE0, 0x03, 0xF3, 0xE0, 0x00,
  0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x0F,
  0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xEF, 0x00, 0x7C,
  0x01, 0xCE, 0x01, 0xD8, 0x03, 0x9C, 0x03, 0xB0, 0x0F, 0x3C, 0x07, 0x70,
  0x1E, 0x78, 0x0E, 0xE0, 0x3C, 0xF0, 0x19, 0xC0, 0x71, 0xE0, 0x33, 0x80,
  0xE1, 0xC0, 0xE3, 0x01, 0xC3, 0x81, 0xC6, 0x07, 0x87, 0x03, 0x8E, 0x0F,
  0x0F, 0x06, 0x1C, 0x1E, 0x1E, 0x0C, 0x38, 0x38, 0x3C, 0x38, 0x70, 0x70,
  0x38, 0x70, 0x60, 0xE0, 0x70, 0xE0, 0xE3, 0xC0, 0xE1, 0xC1, 0xC7, 0x81,
  0xE3, 0x03, 0x8F, 0x03, 0xC6, 0x07, 0x1C, 0x07, 0x9C, 0x0E, 0x38, 0x07,
  0x38, 0x0C, 0x70, 0x0E, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x3B, 0xC0, 0x39,
  0x80, 0x77, 0x80, 0x7B, 0x00, 0xEE, 0x00, 0xFE, 0x00, 0xDC, 0x01, 0xFC,
  0x01, 0xB8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xE7,
  0xFE, 0x00, 0x3D, 0xFF, 0xE0, 0x07, 0xFC, 0x3E, 0x00, 0xFF, 0x03, 0xE0,
  0x1F, 0xE0, 0x3E, 0x03, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x1E, 0xE0,
  0x03, 0xFF, 0xDC, 0x00, 0x3F, 0xF3, 0x80, 0x03, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 7, 45, 37, 15, -45 },
  { 41, 17, 19, 37, 10, -45 },
  { 82, 32, 45, 37, 2, -45 },
  { 262, 27, 62, 37, 5, -53 },
  { 472, 35, 45, 37, 1, -45 },
  { 669, 30, 46, 37, 4, -45 },
  { 842, 5, 19, 37, 16, -45 },
  { 854, 18, 58, 37, 12, -51 },
  { 985, 18, 58, 37, 7, -51 },
  { 1116, 32, 31, 37, 2, -37 },
  { 1240, 28, 28, 37, 4, -34 },
  { 1338, 11, 19, 37, 11, -9 },
  { 1365, 19, 4, 37, 9, -22 },
  { 1375, 9, 10, 37, 14, -9 },
  { 1387, 26, 58, 37, 5, -51 },
  { 1576, 26, 46, 37, 5, -45 },
  { 1726, 27, 45, 37, 6, -45 },
  { 1878, 27, 45, 37, 5, -45 },
  { 2030, 25, 46, 37, 5, -45 },
  { 2174, 24, 44, 37, 6, -44 },
  { 2306, 25, 46, 37, 6, -45 },
  { 2450, 27, 46, 37, 5, -45 },
  { 2606, 27, 45, 37, 5, -45 },
  { 2758, 26, 46, 37, 5, -45 },
  { 2908, 27, 45, 37, 5, -45 },
  { 3060, 9, 35, 37, 14, -34 },
  { 3100, 12, 44, 37, 11, -34 },
  { 3166, 26, 31, 37, 5, -36 },
  { 3267, 25, 18, 37, 6, -29 },
  { 3324, 26, 31, 37, 5, -36 },
  { 3425, 20, 45, 37, 10, -45 },
  { 3538, 31, 56, 37, 3, -45 },
  { 3755, 29, 45, 37, 4, -45 },
  { 3919, 26, 45, 37, 6, -45 },
  { 4066, 25, 46, 37, 6, -45 },
  { 4210, 25, 45, 37, 6, -45 },
  { 4351, 24, 45, 37, 7, -45 },
  { 4486, 25, 45, 37, 7, -45 },
  { 4627, 25, 46, 37, 6, -45 },
  { 4771, 24, 45, 37, 6, -45 },
  { 4906, 23, 45, 37, 7, -45 },
  { 5036, 26, 46, 37, 4, -45 },
  { 5186, 27, 45, 37, 6, -45 },
  { 5338, 25, 45, 37, 7, -45 },
  { 5479, 26, 45, 37, 5, -45 },
  { 5626, 24, 45, 37, 6, -45 },
  { 5761, 25, 46, 37, 6, -45 },
  { 5905, 27, 45, 37, 6, -45 },
  { 6057, 25, 56, 37, 6, -45 },
  { 6232, 27, 45, 37, 6, -45 },
  { 6384, 27, 46, 37, 5, -45 },
  { 6540, 29, 45, 37, 4, -45 },
  { 6704, 24, 46, 37, 6, -45 },
  { 6842, 29, 45, 37, 4, -45 },
  { 7006, 33, 45, 37, 2, -45 },
  { 7192, 31, 45, 37, 3, -45 },
  { 7367, 31, 45, 37, 3, -45 },
  { 7542, 26, 45, 37, 5, -45 },
  { 7689, 14, 58, 37, 13, -51 },
  { 7791, 26, 58, 37, 5, -51 },
  { 7980, 15, 58, 37, 9, -51 },
  { 8089, 25, 24, 37, 6, -45 },
  { 8164, 29, 3, 37, 4, 2 },
  { 8175, 11, 9, 37, 12, -48 },
  { 8188, 25, 35, 37, 5, -34 },
  { 8298, 25, 46, 37, 6, -45 },
  { 8442, 25, 35, 37, 6, -34 },
  { 8552, 24, 46, 37, 6, -45 },
  { 8690, 25, 35, 37, 6, -34 },
  { 8800, 28, 45, 37, 4, -45 },
  { 8958, 24, 45, 37, 6, -34 },
  { 9093, 24, 45, 37, 6, -45 },
  { 9228, 27, 47, 37, 6, -47 },
  { 9387, 22, 58, 37, 6, -47 },
  { 9547, 27, 45, 37, 6, -45 },
  { 9699, 30, 45, 37, 3, -45 },
  { 9868, 27, 34, 37, 5, -34 },
  { 9983, 24, 34, 37, 6, -34 },
  { 10085, 25, 35, 37, 6, -34 },
  { 10195, 25, 45, 37, 6, -34 },
  { 10336, 24, 45, 37, 6, -34 },
  { 10471, 25, 34, 37, 7, -34 },
  { 10578, 25, 35, 37, 6, -34 },
  { 10688, 27, 43, 37, 4, -43 },
  { 10834, 24, 35, 37, 6, -34 },
  { 10939, 28, 34, 37, 4, -34 },
  { 11058, 31, 34, 37, 3, -34 },
  { 11190, 29, 34, 37, 4, -34 },
  { 11314, 28, 45, 37, 4, -34 },
  { 11472, 25, 34, 37, 6, -34 },
  { 11579, 25, 58, 37, 6, -51 },
  { 11761, 4, 58, 37, 16, -51 },
  { 11790, 25, 58, 37, 6, -51 },
  { 11972, 27, 11, 37, 5, -27 },
};

const GFXfont JetBrainsMono_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_EXTRALIGHT61PT7B_H_
