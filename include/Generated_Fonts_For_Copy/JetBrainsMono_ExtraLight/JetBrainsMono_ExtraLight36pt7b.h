#ifndef _JETBRAINSMONO_EXTRALIGHT36PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00,
  0xEF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x06, 0x00, 0xC0, 0xC1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x30, 0x18, 0x06, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC, 0x31, 0x9C, 0x71, 0x8E,
  0x61, 0x86, 0x61, 0x86, 0x61, 0x80, 0x61, 0x80, 0x71, 0x80, 0x71, 0x80,
  0x3D, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xBC, 0x01, 0x8E,
  0x01, 0x8E, 0x01, 0x86, 0x01, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xE1, 0x86,
  0x61, 0x8E, 0x79, 0x9C, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00, 0x77, 0x78, 0x06, 0xC1,
  0x80, 0xCC, 0x18, 0x18, 0xC1, 0x81, 0x8C, 0x18, 0x30, 0xC1, 0x86, 0x0C,
  0x18, 0x60, 0xC1, 0x8C, 0x06, 0x39, 0x80, 0x7F, 0x30, 0x00, 0x83, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC7, 0x80, 0x19, 0xFC, 0x03, 0x18,
  0x60, 0x33, 0x06, 0x06, 0x30, 0x30, 0xC3, 0x03, 0x18, 0x30, 0x31, 0x83,
  0x03, 0x30, 0x30, 0x76, 0x01, 0x86, 0x60, 0x1F, 0xEC, 0x00, 0xFC, 0x01,
  0x80, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x60, 0x70, 0x38, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0x20, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x06, 0x38, 0x1F, 0x87, 0x06, 0xE0,
  0xE3, 0xB8, 0x18, 0xCE, 0x07, 0x63, 0x80, 0xF8, 0xE0, 0x1C, 0x38, 0x07,
  0x0E, 0x01, 0xE3, 0x80, 0xFC, 0x70, 0x73, 0x0F, 0xF8, 0x61, 0xFC, 0x1C,
  0xFF, 0xFF, 0xFF, 0x6D, 0x80, 0x00, 0xC0, 0xF0, 0x78, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x30,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0xF8, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x80,
  0xC0, 0x5C, 0x18, 0x7F, 0xF3, 0x3F, 0x1F, 0xDF, 0x80, 0x7F, 0x80, 0x03,
  0x80, 0x00, 0xD8, 0x00, 0x39, 0x80, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x70,
  0x70, 0x1E, 0x07, 0x01, 0x80, 0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x1E, 0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38, 0x60, 0xC3, 0x80,
  0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC0, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x38, 0x7C,
  0x78, 0xF8, 0xF1, 0xF0, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB8, 0x07, 0x38, 0x1C, 0x7F, 0xF0,
  0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1E, 0xC0, 0x38, 0xC0, 0x70, 0xC0,
  0x60, 0xC0, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x1F, 0xF0, 0x3E, 0xFC,
  0x70, 0x1C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xFC, 0x01, 0xD8, 0x07, 0x3C, 0x1E, 0x3F, 0xF8, 0x1F,
  0xC0, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x73,
  0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x7F, 0xFC, 0xFF, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xCF, 0xE1, 0xBF, 0xE3, 0xC0,
  0xE7, 0x00, 0xEE, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0xDC, 0x03, 0x1C, 0x0E, 0x3F,
  0xF8, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x3B,
  0xF0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x70,
  0x0E, 0x38, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x1C, 0x38, 0x0F,
  0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x3C, 0x38, 0x70, 0x1C, 0x60, 0x0E, 0xE0,
  0x06, 0xE0, 0x06, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0x60, 0x0E, 0x78,
  0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x70,
  0x1C, 0x70, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x1E, 0x3C, 0x7C, 0x1F,
  0xFC, 0x07, 0x98, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x7B,
  0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFB,
  0xFF, 0x9E, 0x3C, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x0C, 0x38, 0x60, 0xC1,
  0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x01, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x3F, 0xC3,
  0xF0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFF, 0x01,
  0xF1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0xEF, 0x03, 0xDB, 0xC1, 0xC1,
  0xF0, 0x60, 0x7C, 0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x60, 0x3C,
  0x18, 0x0F, 0x06, 0x03, 0xC1, 0x81, 0xF0, 0x60, 0x7C, 0x1C, 0x3F, 0x03,
  0xFB, 0xC0, 0x7C, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x37, 0x00, 0x19, 0x80, 0x1C,
  0xC0, 0x0C, 0x60, 0x06, 0x38, 0x03, 0x0C, 0x03, 0x86, 0x01, 0x83, 0x80,
  0xC1, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x1C, 0x18, 0x06, 0x1F, 0xFF,
  0x0F, 0xFF, 0x86, 0x00, 0xE3, 0x00, 0x33, 0x80, 0x19, 0xC0, 0x0C, 0xC0,
  0x07, 0x60, 0x01, 0xF0, 0x00, 0xC0, 0xFF, 0xE1, 0xFF, 0xE3, 0x01, 0xE6,
  0x00, 0xEC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x1D, 0x80,
  0x3B, 0x00, 0xE7, 0xFF, 0x8F, 0xFE, 0x18, 0x3F, 0x30, 0x0F, 0x60, 0x0E,
  0xC0, 0x0D, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0,
  0x07, 0x60, 0x3C, 0xFF, 0xF1, 0xFF, 0x80, 0x03, 0x00, 0x7F, 0x87, 0xFF,
  0x9C, 0x0E, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0x70, 0x38, 0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x8C, 0x07,
  0x30, 0x0E, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0,
  0x3C, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x98, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x7F, 0x87, 0xFF,
  0x9C, 0x0E, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0x70, 0x38, 0xFF, 0xC1, 0xFE, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0x60, 0x06, 0x70,
  0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0,
  0xE0, 0xC0, 0xC0, 0xC1, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xC1, 0xC0, 0xC1,
  0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0,
  0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1B, 0xD8, 0x1B, 0xD8, 0x1F, 0xD8, 0x37,
  0xCC, 0x37, 0xCC, 0x27, 0xC4, 0x67, 0xC6, 0x67, 0xC6, 0x47, 0xC2, 0xC7,
  0xC3, 0xC7, 0xC3, 0x87, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xD8,
  0x0F, 0x60, 0x3D, 0x80, 0xF3, 0x03, 0xCC, 0x0F, 0x38, 0x3C, 0x60, 0xF1,
  0x83, 0xC3, 0x0F, 0x0C, 0x3C, 0x38, 0xF0, 0x63, 0xC1, 0x8F, 0x07, 0x3C,
  0x0C, 0xF0, 0x33, 0xC0, 0x6F, 0x01, 0xBC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x70, 0x03, 0x00, 0x7F, 0x87, 0xFF, 0x1C, 0x0E, 0xE0, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x06, 0x70, 0x38, 0xFF, 0xC1,
  0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xF3, 0x00, 0xF6, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xEC, 0x0F, 0xDF, 0xFE, 0x3F, 0xF0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x38, 0x1C, 0x70,
  0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0x60, 0x06, 0x60,
  0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF3, 0x00, 0xF6, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x76, 0x01, 0xEF, 0xFF, 0x9F, 0xFC, 0x30,
  0x70, 0x60, 0xE0, 0xC0, 0xE1, 0x81, 0xC3, 0x01, 0xC6, 0x03, 0x8C, 0x03,
  0x98, 0x07, 0x30, 0x07, 0x60, 0x0E, 0xC0, 0x0F, 0x80, 0x1C, 0x01, 0x80,
  0x0F, 0xF0, 0x3F, 0xFC, 0x70, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x78, 0x1C,
  0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F,
  0x80, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x1C, 0x70, 0x0C, 0x18, 0x06, 0x0C, 0x07, 0x06, 0x03,
  0x83, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0xE0, 0x38, 0x60, 0x1C, 0x30, 0x06,
  0x18, 0x03, 0x1C, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1B, 0x80,
  0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0xE0, 0x7C,
  0x1E, 0x0D, 0x83, 0xC1, 0xB0, 0x78, 0x36, 0x0B, 0x06, 0xC1, 0x60, 0xD8,
  0x2C, 0x3B, 0x0C, 0x86, 0x61, 0x90, 0xCE, 0x33, 0x18, 0xC6, 0x63, 0x18,
  0xCC, 0x63, 0x11, 0x8C, 0x62, 0x31, 0x8C, 0x42, 0x31, 0x98, 0x4C, 0x33,
  0x09, 0x87, 0x61, 0xB0, 0xEC, 0x36, 0x0D, 0x06, 0xC1, 0xA0, 0xD8, 0x34,
  0x1B, 0x07, 0x81, 0x60, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0xE0,
  0x03, 0x9C, 0x00, 0xC3, 0x00, 0x70, 0xE0, 0x18, 0x18, 0x0E, 0x07, 0x03,
  0x00, 0xE1, 0xC0, 0x18, 0x60, 0x07, 0x30, 0x00, 0xDC, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0D, 0xC0, 0x07,
  0x38, 0x01, 0x86, 0x00, 0xC1, 0xC0, 0x70, 0x30, 0x18, 0x0E, 0x0E, 0x01,
  0x83, 0x00, 0x71, 0xC0, 0x0C, 0x60, 0x03, 0xB8, 0x00, 0x70, 0xC0, 0x01,
  0xF8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0C, 0x30, 0x07, 0x0E, 0x01, 0x81,
  0x80, 0xE0, 0x70, 0x30, 0x0C, 0x1C, 0x03, 0x86, 0x00, 0x63, 0x80, 0x1C,
  0xC0, 0x03, 0x70, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x33, 0x00, 0x66, 0x01, 0x8E, 0x03, 0x0C, 0x0E,
  0x1C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xFC, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x66, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x3F, 0xFD, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x2D, 0xFF, 0xD8, 0xFE,
  0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x7E, 0x37, 0xFC, 0xF0, 0x7B, 0x80, 0x6E, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xFC, 0x0E, 0xDF, 0xF3, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x76, 0x00, 0xEC, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x01, 0xB0, 0x07, 0x70, 0x0E, 0x70, 0x38, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC3, 0xF1, 0x8F, 0xF3, 0x38, 0x36, 0xE0, 0x3D, 0x80, 0x3B, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x76, 0x00, 0xEC, 0x01, 0xDC, 0x03, 0x9C, 0x0B, 0x3F, 0xF6,
  0x1F, 0x8C, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x66, 0x00, 0xEC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x03, 0x70, 0x0E, 0x70, 0x38,
  0x7F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x1F, 0x8C, 0xFF, 0x37, 0x06, 0xF8, 0x0B, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x0B, 0x7D, 0xEC, 0xFF, 0x30, 0x60, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x3F, 0xF8, 0xFF, 0xC0, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x7E, 0x37, 0xFC,
  0xF0, 0x7B, 0x80, 0x6E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C,
  0xFF, 0xE7, 0xFC, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x03, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x73, 0x00,
  0xC6, 0x03, 0x8C, 0x0E, 0x18, 0x38, 0x30, 0x70, 0x7F, 0xC0, 0xFF, 0x81,
  0x83, 0x83, 0x03, 0x86, 0x07, 0x0C, 0x07, 0x18, 0x07, 0x30, 0x0E, 0x60,
  0x0E, 0xC0, 0x0F, 0x80, 0x1C, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0xDE, 0x3C, 0xFF, 0x7E, 0xE3, 0xC7, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC7, 0xE3, 0x7F, 0xCF,
  0x07, 0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x07, 0xE0, 0x3F, 0xF0, 0xE0,
  0xF3, 0x80, 0x66, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB0,
  0x07, 0x70, 0x0C, 0x70, 0x38, 0x7F, 0xE0, 0x7F, 0x80, 0xC7, 0xE3, 0x7F,
  0xCF, 0x07, 0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xE0, 0x1B, 0xC0, 0xED, 0xFF, 0x33, 0xF8, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x1F, 0x8C, 0xFF, 0x37, 0x06,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x1D, 0xC0, 0xB7, 0xFE, 0xC7, 0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0xE7, 0xE1, 0xDF, 0xF3, 0xE0, 0xF7, 0x80,
  0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0xE0,
  0x73, 0x80, 0x76, 0x00, 0x6C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xF0,
  0x03, 0x60, 0x06, 0xE0, 0x1C, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xE0, 0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x01,
  0xB0, 0x01, 0xDC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0xC0, 0x30, 0x60,
  0x18, 0x30, 0x1C, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x07, 0x01, 0xC3, 0x00,
  0x61, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xC0, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F,
  0x07, 0x86, 0xC1, 0x61, 0xB8, 0x58, 0x66, 0x12, 0x19, 0x8C, 0x86, 0x63,
  0x21, 0x98, 0xCC, 0xC6, 0x23, 0x31, 0xC8, 0xCC, 0x36, 0x13, 0x0D, 0x84,
  0xC3, 0x61, 0xB0, 0xD8, 0x78, 0x34, 0x1E, 0x0D, 0x07, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x70, 0x03, 0x98, 0x03, 0x8E, 0x01, 0x83, 0x81, 0xC0, 0xC1,
  0xC0, 0x70, 0xC0, 0x1C, 0xE0, 0x06, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x37, 0x00, 0x31, 0xC0, 0x38, 0x60, 0x38, 0x38,
  0x18, 0x0E, 0x1C, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0x70, 0xE0, 0x03, 0xB8,
  0x01, 0xDC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x70, 0xC0, 0x30, 0x70, 0x38,
  0x38, 0x18, 0x0C, 0x0C, 0x07, 0x0E, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x73,
  0x80, 0x19, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0xFF, 0x81,
  0xFE, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xFF,
  0x03, 0xC3, 0x83, 0xC1, 0x87, 0xC1, 0xE6, 0xC0, 0xFE, 0xC0, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 26, 22, 9, -26 },
  { 14, 10, 11, 22, 6, -26 },
  { 28, 19, 26, 22, 1, -26 },
  { 90, 16, 36, 22, 3, -31 },
  { 162, 20, 26, 22, 1, -26 },
  { 227, 18, 27, 22, 2, -27 },
  { 288, 3, 11, 22, 9, -26 },
  { 293, 10, 34, 22, 7, -30 },
  { 336, 11, 34, 22, 4, -30 },
  { 383, 19, 18, 22, 1, -22 },
  { 426, 16, 16, 22, 3, -20 },
  { 458, 7, 11, 22, 6, -5 },
  { 468, 12, 2, 22, 5, -13 },
  { 471, 6, 5, 22, 8, -5 },
  { 475, 15, 34, 22, 3, -30 },
  { 539, 15, 27, 22, 3, -27 },
  { 590, 16, 26, 22, 3, -26 },
  { 642, 16, 27, 22, 3, -27 },
  { 696, 15, 26, 22, 3, -26 },
  { 745, 15, 26, 22, 3, -26 },
  { 794, 15, 26, 22, 3, -26 },
  { 843, 16, 26, 22, 3, -26 },
  { 895, 16, 26, 22, 3, -26 },
  { 947, 16, 27, 22, 3, -27 },
  { 1001, 16, 27, 22, 3, -27 },
  { 1055, 6, 20, 22, 8, -20 },
  { 1070, 7, 26, 22, 7, -20 },
  { 1093, 15, 18, 22, 3, -21 },
  { 1127, 15, 10, 22, 3, -17 },
  { 1146, 15, 18, 22, 3, -21 },
  { 1180, 12, 26, 22, 6, -26 },
  { 1219, 18, 33, 22, 2, -27 },
  { 1294, 17, 26, 22, 2, -26 },
  { 1350, 15, 26, 22, 4, -26 },
  { 1399, 14, 27, 22, 4, -27 },
  { 1447, 14, 26, 22, 4, -26 },
  { 1493, 15, 26, 22, 4, -26 },
  { 1542, 15, 26, 22, 4, -26 },
  { 1591, 14, 27, 22, 4, -27 },
  { 1639, 14, 26, 22, 4, -26 },
  { 1685, 14, 26, 22, 4, -26 },
  { 1731, 16, 26, 22, 2, -26 },
  { 1783, 16, 26, 22, 4, -26 },
  { 1835, 15, 26, 22, 4, -26 },
  { 1884, 16, 26, 22, 3, -26 },
  { 1936, 14, 26, 22, 4, -26 },
  { 1982, 14, 27, 22, 4, -27 },
  { 2030, 15, 26, 22, 4, -26 },
  { 2079, 16, 33, 22, 3, -27 },
  { 2145, 15, 26, 22, 4, -26 },
  { 2194, 16, 27, 22, 3, -27 },
  { 2248, 18, 26, 22, 2, -26 },
  { 2307, 14, 26, 22, 4, -26 },
  { 2353, 17, 26, 22, 2, -26 },
  { 2409, 19, 26, 22, 1, -26 },
  { 2471, 18, 26, 22, 2, -26 },
  { 2530, 18, 26, 22, 2, -26 },
  { 2589, 15, 26, 22, 3, -26 },
  { 2638, 8, 34, 22, 8, -30 },
  { 2672, 15, 34, 22, 3, -30 },
  { 2736, 8, 34, 22, 6, -30 },
  { 2770, 15, 14, 22, 3, -26 },
  { 2797, 17, 2, 22, 2, 1 },
  { 2802, 7, 5, 22, 7, -28 },
  { 2807, 15, 20, 22, 3, -20 },
  { 2845, 14, 26, 22, 4, -26 },
  { 2891, 15, 20, 22, 3, -20 },
  { 2929, 15, 26, 22, 3, -26 },
  { 2978, 15, 20, 22, 3, -20 },
  { 3016, 17, 26, 22, 2, -26 },
  { 3072, 14, 26, 22, 4, -20 },
  { 3118, 14, 26, 22, 4, -26 },
  { 3164, 17, 28, 22, 3, -28 },
  { 3224, 13, 34, 22, 3, -28 },
  { 3280, 15, 26, 22, 4, -26 },
  { 3329, 18, 26, 22, 2, -26 },
  { 3388, 16, 20, 22, 3, -20 },
  { 3428, 14, 20, 22, 4, -20 },
  { 3463, 15, 20, 22, 3, -20 },
  { 3501, 14, 26, 22, 4, -20 },
  { 3547, 14, 26, 22, 4, -20 },
  { 3593, 15, 20, 22, 4, -20 },
  { 3631, 15, 20, 22, 3, -20 },
  { 3669, 16, 25, 22, 2, -25 },
  { 3719, 14, 20, 22, 4, -20 },
  { 3754, 17, 20, 22, 2, -20 },
  { 3797, 18, 20, 22, 2, -20 },
  { 3842, 17, 20, 22, 2, -20 },
  { 3885, 17, 26, 22, 2, -20 },
  { 3941, 14, 20, 22, 4, -20 },
  { 3976, 15, 34, 22, 3, -30 },
  { 4040, 2, 34, 22, 10, -30 },
  { 4049, 15, 34, 22, 3, -30 },
  { 4113, 16, 7, 22, 3, -16 },
};

const GFXfont JetBrainsMono_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_EXTRALIGHT36PT7B_H_
