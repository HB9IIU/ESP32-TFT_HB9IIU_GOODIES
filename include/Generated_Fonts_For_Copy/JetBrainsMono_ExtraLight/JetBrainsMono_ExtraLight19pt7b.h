#ifndef _JETBRAINSMONO_EXTRALIGHT19PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0xF0, 0xCE, 0x73, 0x18, 0xC4, 0x10, 0x84, 0x41,
  0x10, 0x44, 0xFF, 0xC8, 0x42, 0x30, 0x88, 0x22, 0x3F, 0xE4, 0x21, 0x08,
  0x44, 0x11, 0x00, 0x10, 0x10, 0x10, 0x3C, 0xD6, 0x93, 0x93, 0x90, 0xD0,
  0x78, 0x1E, 0x12, 0x13, 0x91, 0x93, 0xD2, 0x7C, 0x10, 0x10, 0x10, 0x78,
  0x29, 0x09, 0x22, 0x24, 0x44, 0x90, 0xF4, 0x00, 0x80, 0x20, 0x0B, 0xC3,
  0x44, 0x48, 0x91, 0x14, 0x23, 0x83, 0x80, 0x3C, 0x18, 0x84, 0x31, 0x00,
  0x60, 0x08, 0x07, 0x03, 0x63, 0x8D, 0xA1, 0x48, 0x32, 0x0C, 0xC5, 0x9E,
  0x30, 0xFC, 0x09, 0x98, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0x0C,
  0x30, 0xC0, 0xC1, 0x81, 0x06, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x20, 0x84, 0x33, 0x00, 0x08, 0x02, 0x00, 0x82, 0x22, 0xEB, 0xC7, 0x01,
  0x40, 0x58, 0x23, 0x18, 0x40, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x32, 0x66, 0x4C, 0xFC, 0x7F, 0x80, 0x03, 0x02,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x60,
  0x40, 0x40, 0xC0, 0x80, 0x7C, 0xC6, 0x83, 0x83, 0x83, 0x83, 0x9B, 0x9B,
  0x83, 0x83, 0x83, 0x83, 0xC6, 0x7C, 0x18, 0x68, 0xC8, 0x88, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x3E, 0x31, 0x90, 0x78,
  0x30, 0x18, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0xFC,
  0xFE, 0x04, 0x10, 0x41, 0x07, 0x01, 0x81, 0x02, 0x06, 0x0C, 0x1C, 0x6F,
  0x80, 0x06, 0x18, 0x20, 0x83, 0x04, 0x18, 0xE1, 0x83, 0x07, 0xF8, 0x10,
  0x20, 0x40, 0xFE, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC6, 0x82, 0x03, 0x03,
  0x03, 0x82, 0xC6, 0x7C, 0x06, 0x06, 0x02, 0x02, 0x01, 0x01, 0x01, 0xFC,
  0xC2, 0x41, 0xE0, 0x50, 0x28, 0x36, 0x31, 0xF0, 0xFF, 0x81, 0x83, 0x82,
  0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x7C, 0xC6,
  0x82, 0x83, 0x82, 0x46, 0x38, 0x6C, 0xC2, 0x83, 0x81, 0x83, 0xC2, 0x7C,
  0x3E, 0x31, 0x90, 0x68, 0x1C, 0x0A, 0x0D, 0x06, 0x6E, 0x1B, 0x01, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x5F, 0x80, 0x00, 0x5F, 0x80, 0x27, 0x70, 0x00,
  0x00, 0x32, 0x66, 0x4C, 0x01, 0x06, 0x18, 0x60, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x06, 0x1C, 0x70, 0xC0, 0x80, 0xF0, 0x30, 0x41, 0x04, 0x10, 0xDC, 0x61,
  0x80, 0x00, 0x61, 0x80, 0x1E, 0x30, 0xD0, 0x38, 0x18, 0x0C, 0x7E, 0x23,
  0x11, 0x88, 0xC4, 0x62, 0x31, 0x18, 0x7C, 0x01, 0x00, 0xC0, 0x3E, 0x00,
  0x0C, 0x06, 0x05, 0x02, 0x81, 0x61, 0x90, 0x88, 0x44, 0x21, 0x3F, 0x90,
  0x48, 0x34, 0x0E, 0x04, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x82, 0xFC, 0x86,
  0x83, 0x81, 0x81, 0x83, 0x86, 0xFC, 0x3C, 0xC6, 0x83, 0x83, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x83, 0x83, 0xC2, 0x7C, 0xF8, 0x86, 0x82, 0x82,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0x82, 0x86, 0xF8, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x3C, 0xC6, 0x83, 0x83, 0x80, 0x80, 0x80, 0x9F, 0x83, 0x83,
  0x83, 0x83, 0xC2, 0x7C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x1F, 0xC0, 0x0F, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x81, 0xC1, 0x43, 0x3E, 0x81, 0x83, 0x82, 0x86,
  0x84, 0x8C, 0xF8, 0x88, 0x8C, 0x84, 0x86, 0x82, 0x83, 0x81, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xC3, 0xC3, 0xC5, 0xA5, 0xA5, 0xA9, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x87, 0x8D, 0x1A, 0x32, 0x64, 0xC9, 0x8B, 0x16, 0x3C,
  0x38, 0x70, 0x40, 0x3C, 0xC6, 0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x82, 0xC6, 0x7C, 0xFC, 0x86, 0x81, 0x81, 0x81, 0x81, 0x83,
  0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0xC6, 0x82, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0xC6, 0x7C, 0x04, 0x06, 0x03,
  0xFC, 0x86, 0x83, 0x81, 0x81, 0x83, 0x86, 0xFC, 0x88, 0x84, 0x84, 0x86,
  0x82, 0x83, 0x7C, 0xC6, 0x83, 0x83, 0x80, 0xC0, 0x78, 0x0E, 0x02, 0x03,
  0x81, 0x83, 0xC2, 0x7C, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x6F, 0x80, 0xC0, 0xA0, 0x50,
  0x68, 0x26, 0x11, 0x08, 0x8C, 0x44, 0x32, 0x09, 0x05, 0x02, 0x81, 0xC0,
  0x60, 0x8C, 0x63, 0x38, 0xCA, 0x52, 0x94, 0xA5, 0x2D, 0x49, 0x52, 0x52,
  0x94, 0xA5, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0xC0, 0xA0, 0x88, 0x44, 0x41,
  0x60, 0xA0, 0x30, 0x18, 0x14, 0x19, 0x08, 0xCC, 0x24, 0x1E, 0x04, 0x80,
  0xD0, 0x24, 0x10, 0x84, 0x22, 0x0C, 0x81, 0x40, 0x70, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFE, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x20, 0x20, 0x40, 0xC0, 0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0x80, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02,
  0x03, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x18, 0x38,
  0x28, 0x24, 0x44, 0x46, 0x82, 0x83, 0xFF, 0xFF, 0xC0, 0x88, 0x80, 0x0C,
  0x3F, 0x61, 0x01, 0x01, 0x3F, 0x41, 0xC1, 0xC1, 0x43, 0x3D, 0x80, 0x80,
  0x80, 0x98, 0xAE, 0xC2, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0xC2, 0xBC,
  0x18, 0x7E, 0xC2, 0x83, 0x80, 0x80, 0x80, 0x80, 0x83, 0xC2, 0x7C, 0x02,
  0x04, 0x09, 0x96, 0xF8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x6F, 0x40,
  0x18, 0x6E, 0xC2, 0x83, 0x83, 0xFF, 0x80, 0x80, 0x83, 0xC2, 0x7C, 0x0F,
  0x84, 0x06, 0x03, 0x01, 0x87, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x30, 0xDF, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC6, 0xFC,
  0x08, 0x10, 0x2F, 0xC0, 0x81, 0x02, 0x04, 0xCA, 0xF8, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0x18, 0x18, 0x18, 0x00, 0x00, 0xF8, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x04, 0x1C, 0x10, 0x00,
  0x1F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0D, 0xF0,
  0x80, 0x80, 0x80, 0x80, 0x83, 0x86, 0x84, 0x88, 0xF8, 0x88, 0x8C, 0x86,
  0x82, 0x83, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x80, 0x7C, 0x33, 0x6E, 0xF2, 0x39, 0x1C, 0x8E,
  0x47, 0x23, 0x91, 0xC8, 0xE4, 0x72, 0x20, 0x19, 0x5F, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x08, 0x18, 0x7E, 0xC2, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x82, 0xC6, 0x7C, 0x18, 0xAE, 0xC2, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x30, 0xDF, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x8D, 0xE8, 0x10, 0x20, 0x40, 0x18, 0xE6, 0xC3, 0xC1, 0xC1,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x38, 0x7E, 0x83, 0x80, 0xC0, 0x7C,
  0x06, 0x03, 0x83, 0xC2, 0x7E, 0x10, 0x08, 0x04, 0x1F, 0xF1, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0xF8, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xC6, 0xF8, 0xC0, 0xA0, 0x98, 0x44, 0x22, 0x21, 0x90,
  0x48, 0x28, 0x1C, 0x06, 0x00, 0x88, 0xE3, 0x29, 0x4B, 0x52, 0x54, 0x95,
  0x25, 0x31, 0x4C, 0x63, 0x18, 0xC0, 0xE1, 0x91, 0x8C, 0x83, 0x80, 0xC0,
  0xE0, 0x58, 0x44, 0x61, 0x60, 0xC0, 0xC1, 0xA0, 0x98, 0x44, 0x63, 0x20,
  0x90, 0x58, 0x38, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x00, 0xFE, 0x06, 0x04,
  0x08, 0x18, 0x30, 0x20, 0x40, 0x80, 0xFF, 0x07, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x18, 0xF0, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x07, 0xFF, 0xFF, 0xC0, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x18, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x30, 0xE0, 0x20, 0xBC,
  0x73, 0x38, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 14, 11, 5, -14 },
  { 5, 5, 6, 11, 3, -14 },
  { 9, 10, 14, 11, 1, -14 },
  { 27, 8, 20, 11, 2, -17 },
  { 47, 11, 14, 11, 0, -14 },
  { 67, 10, 14, 11, 1, -14 },
  { 85, 1, 6, 11, 5, -14 },
  { 86, 5, 18, 11, 4, -16 },
  { 98, 6, 18, 11, 2, -16 },
  { 112, 10, 10, 11, 1, -12 },
  { 125, 9, 9, 11, 1, -11 },
  { 136, 4, 6, 11, 3, -3 },
  { 139, 6, 1, 11, 3, -7 },
  { 140, 3, 3, 11, 4, -3 },
  { 142, 8, 18, 11, 2, -16 },
  { 160, 8, 14, 11, 2, -14 },
  { 174, 8, 14, 11, 2, -14 },
  { 188, 9, 14, 11, 1, -14 },
  { 204, 7, 14, 11, 2, -14 },
  { 217, 7, 14, 11, 2, -14 },
  { 230, 8, 14, 11, 2, -14 },
  { 244, 9, 14, 11, 1, -14 },
  { 260, 8, 14, 11, 2, -14 },
  { 274, 8, 14, 11, 2, -14 },
  { 288, 9, 14, 11, 1, -14 },
  { 304, 3, 11, 11, 4, -11 },
  { 309, 4, 14, 11, 3, -11 },
  { 316, 8, 10, 11, 2, -11 },
  { 326, 8, 5, 11, 2, -9 },
  { 331, 8, 10, 11, 2, -11 },
  { 341, 6, 14, 11, 3, -14 },
  { 352, 9, 17, 11, 1, -14 },
  { 372, 9, 14, 11, 1, -14 },
  { 388, 8, 14, 11, 2, -14 },
  { 402, 8, 14, 11, 2, -14 },
  { 416, 8, 14, 11, 2, -14 },
  { 430, 8, 14, 11, 2, -14 },
  { 444, 8, 14, 11, 2, -14 },
  { 458, 8, 14, 11, 2, -14 },
  { 472, 7, 14, 11, 2, -14 },
  { 485, 7, 14, 11, 2, -14 },
  { 498, 8, 14, 11, 1, -14 },
  { 512, 8, 14, 11, 2, -14 },
  { 526, 8, 14, 11, 2, -14 },
  { 540, 8, 14, 11, 2, -14 },
  { 554, 7, 14, 11, 2, -14 },
  { 567, 8, 14, 11, 2, -14 },
  { 581, 8, 14, 11, 2, -14 },
  { 595, 8, 17, 11, 2, -14 },
  { 612, 8, 14, 11, 2, -14 },
  { 626, 8, 14, 11, 2, -14 },
  { 640, 9, 14, 11, 1, -14 },
  { 656, 7, 14, 11, 2, -14 },
  { 669, 9, 14, 11, 1, -14 },
  { 685, 10, 14, 11, 1, -14 },
  { 703, 9, 14, 11, 1, -14 },
  { 719, 10, 14, 11, 1, -14 },
  { 737, 8, 14, 11, 2, -14 },
  { 751, 5, 18, 11, 4, -16 },
  { 763, 8, 18, 11, 2, -16 },
  { 781, 4, 18, 11, 3, -16 },
  { 790, 8, 8, 11, 2, -14 },
  { 798, 9, 2, 11, 1, 0 },
  { 801, 3, 3, 11, 4, -15 },
  { 803, 8, 11, 11, 1, -11 },
  { 814, 8, 14, 11, 2, -14 },
  { 828, 8, 11, 11, 2, -11 },
  { 839, 7, 14, 11, 2, -14 },
  { 852, 8, 11, 11, 2, -11 },
  { 863, 9, 14, 11, 1, -14 },
  { 879, 7, 14, 11, 2, -11 },
  { 892, 7, 14, 11, 2, -14 },
  { 905, 8, 15, 11, 2, -15 },
  { 920, 7, 18, 11, 2, -15 },
  { 936, 8, 14, 11, 2, -14 },
  { 950, 9, 14, 11, 1, -14 },
  { 966, 9, 11, 11, 1, -11 },
  { 979, 7, 11, 11, 2, -11 },
  { 989, 8, 11, 11, 2, -11 },
  { 1000, 8, 14, 11, 2, -11 },
  { 1014, 7, 14, 11, 2, -11 },
  { 1027, 8, 11, 11, 2, -11 },
  { 1038, 8, 11, 11, 2, -11 },
  { 1049, 9, 13, 11, 1, -13 },
  { 1064, 7, 10, 11, 2, -10 },
  { 1073, 9, 10, 11, 1, -10 },
  { 1085, 10, 10, 11, 1, -10 },
  { 1098, 9, 10, 11, 1, -10 },
  { 1110, 9, 13, 11, 1, -10 },
  { 1125, 8, 10, 11, 2, -10 },
  { 1135, 8, 18, 11, 2, -16 },
  { 1153, 1, 18, 11, 5, -16 },
  { 1156, 8, 18, 11, 2, -16 },
  { 1174, 9, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_EXTRALIGHT19PT7B_H_
