#ifndef _JETBRAINSMONO_EXTRALIGHT9PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x5E, 0xAF, 0xA9, 0x40, 0x46, 0xDC, 0x65,
  0xDA, 0x40, 0x4D, 0x6C, 0xC3, 0xAE, 0x60, 0x4A, 0x88, 0xDA, 0xD0, 0xE0,
  0x6A, 0xAA, 0x40, 0x88, 0x92, 0x4A, 0x80, 0x26, 0xC8, 0xA0, 0x44, 0xF4,
  0xC0, 0xE0, 0x80, 0x32, 0x24, 0x44, 0x88, 0x69, 0x9D, 0x99, 0xE0, 0x4C,
  0x44, 0x44, 0xF0, 0x69, 0x12, 0x24, 0xF0, 0xE5, 0x13, 0x78, 0x25, 0x5B,
  0xC8, 0xE8, 0xCA, 0x11, 0xE0, 0x24, 0x8E, 0x99, 0xE0, 0xF9, 0x22, 0x24,
  0x40, 0x69, 0x96, 0xB9, 0xE0, 0x69, 0x99, 0x62, 0x40, 0x88, 0x8C, 0x3C,
  0xC3, 0xFF, 0xC2, 0x3C, 0xC4, 0x94, 0x10, 0x69, 0xBD, 0xDD, 0xA8, 0x60,
  0x44, 0x6A, 0xE9, 0x90, 0xE9, 0x9E, 0x99, 0xE0, 0x69, 0x88, 0x89, 0xE0,
  0xCA, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80,
  0x69, 0x88, 0xB9, 0xE0, 0xB6, 0xFB, 0x68, 0xE9, 0x24, 0xB8, 0x64, 0x93,
  0x78, 0x9A, 0xAC, 0xAA, 0x90, 0x88, 0x88, 0x88, 0xF0, 0x9B, 0xBD, 0x99,
  0x90, 0xB7, 0xFF, 0x68, 0x69, 0x99, 0x99, 0xE0, 0xE9, 0x9F, 0x88, 0x80,
  0x69, 0x99, 0x99, 0xE2, 0x10, 0xE9, 0x9E, 0xAA, 0x90, 0x69, 0x86, 0x19,
  0xE0, 0xF4, 0x44, 0x44, 0x40, 0xB6, 0xDB, 0x78, 0x99, 0xAA, 0xA4, 0x40,
  0xAD, 0x6B, 0x55, 0xA9, 0x40, 0x8A, 0x8C, 0x43, 0x2B, 0x20, 0x8A, 0x54,
  0x42, 0x10, 0x80, 0xE2, 0x24, 0x48, 0xF0, 0xEA, 0xAB, 0x88, 0x44, 0x42,
  0x21, 0xD5, 0x57, 0x44, 0xA9, 0xF0, 0x80, 0xE7, 0xDE, 0x88, 0xE9, 0x99,
  0xE0, 0xE9, 0x89, 0xE0, 0x27, 0xDB, 0x78, 0xE9, 0xF9, 0xE0, 0x34, 0xF4,
  0x44, 0x40, 0xF6, 0xD6, 0x58, 0x93, 0xDB, 0x68, 0x40, 0xC4, 0x44, 0xF0,
  0x23, 0x92, 0x49, 0xC0, 0x88, 0x9A, 0xCA, 0x90, 0xE1, 0x08, 0x42, 0x10,
  0xE0, 0xFD, 0xDD, 0xD0, 0xF6, 0xDA, 0xE9, 0x99, 0xE0, 0xE9, 0x99, 0xE8,
  0x80, 0xF6, 0xDE, 0x48, 0xE9, 0x88, 0x80, 0xE9, 0x61, 0xE0, 0x4F, 0x44,
  0x47, 0xB6, 0xDE, 0x9A, 0xA6, 0x40, 0xAD, 0x56, 0xA5, 0x00, 0x96, 0x4A,
  0x90, 0x9A, 0xA6, 0x44, 0x40, 0xE2, 0x48, 0xF0, 0x74, 0x2C, 0x44, 0x43,
  0xFF, 0xC4, 0x47, 0x44, 0x4C, 0xDA,
};

const GFXglyph JetBrainsMono_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 5, 7, 5, 0, -7 },
  { 19, 4, 7, 5, 1, -7 },
  { 23, 1, 3, 5, 2, -7 },
  { 24, 2, 9, 5, 2, -8 },
  { 27, 3, 9, 5, 1, -8 },
  { 31, 5, 4, 5, 0, -5 },
  { 34, 4, 4, 5, 1, -5 },
  { 36, 1, 2, 5, 2, -1 },
  { 37, 3, 1, 5, 1, -3 },
  { 38, 1, 1, 5, 2, -1 },
  { 39, 4, 8, 5, 1, -7 },
  { 43, 4, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 1, -7 },
  { 51, 4, 7, 5, 1, -7 },
  { 55, 3, 7, 5, 1, -7 },
  { 58, 3, 7, 5, 1, -7 },
  { 61, 4, 7, 5, 1, -7 },
  { 65, 4, 7, 5, 1, -7 },
  { 69, 4, 7, 5, 1, -7 },
  { 73, 4, 7, 5, 1, -7 },
  { 77, 4, 7, 5, 1, -7 },
  { 81, 1, 5, 5, 2, -5 },
  { 82, 1, 6, 5, 2, -5 },
  { 83, 4, 4, 5, 1, -5 },
  { 85, 4, 2, 5, 1, -4 },
  { 86, 4, 4, 5, 1, -5 },
  { 88, 3, 7, 5, 1, -7 },
  { 91, 4, 9, 5, 1, -7 },
  { 96, 4, 7, 5, 1, -7 },
  { 100, 4, 7, 5, 1, -7 },
  { 104, 4, 7, 5, 1, -7 },
  { 108, 4, 7, 5, 1, -7 },
  { 112, 4, 7, 5, 1, -7 },
  { 116, 4, 7, 5, 1, -7 },
  { 120, 4, 7, 5, 1, -7 },
  { 124, 3, 7, 5, 1, -7 },
  { 127, 3, 7, 5, 1, -7 },
  { 130, 3, 7, 5, 1, -7 },
  { 133, 4, 7, 5, 1, -7 },
  { 137, 4, 7, 5, 1, -7 },
  { 141, 4, 7, 5, 1, -7 },
  { 145, 3, 7, 5, 1, -7 },
  { 148, 4, 7, 5, 1, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 4, 9, 5, 1, -7 },
  { 161, 4, 7, 5, 1, -7 },
  { 165, 4, 7, 5, 1, -7 },
  { 169, 4, 7, 5, 1, -7 },
  { 173, 3, 7, 5, 1, -7 },
  { 176, 4, 7, 5, 1, -7 },
  { 180, 5, 7, 5, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 4, 7, 5, 1, -7 },
  { 199, 2, 8, 5, 2, -7 },
  { 201, 4, 8, 5, 1, -7 },
  { 205, 2, 8, 5, 1, -7 },
  { 207, 4, 4, 5, 1, -7 },
  { 209, 4, 1, 5, 1, 0 },
  { 210, 1, 1, 5, 2, -7 },
  { 211, 3, 5, 5, 1, -5 },
  { 213, 4, 7, 5, 1, -7 },
  { 217, 4, 5, 5, 1, -5 },
  { 220, 3, 7, 5, 1, -7 },
  { 223, 4, 5, 5, 1, -5 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 3, 7, 5, 1, -5 },
  { 233, 3, 7, 5, 1, -7 },
  { 236, 4, 7, 5, 1, -7 },
  { 240, 3, 9, 5, 1, -7 },
  { 244, 4, 7, 5, 1, -7 },
  { 248, 5, 7, 5, 0, -7 },
  { 253, 4, 5, 5, 1, -5 },
  { 256, 3, 5, 5, 1, -5 },
  { 258, 4, 5, 5, 1, -5 },
  { 261, 4, 7, 5, 1, -5 },
  { 265, 3, 7, 5, 1, -5 },
  { 268, 4, 5, 5, 1, -5 },
  { 271, 4, 5, 5, 1, -5 },
  { 274, 4, 6, 5, 1, -6 },
  { 277, 3, 5, 5, 1, -5 },
  { 279, 4, 5, 5, 1, -5 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 4, 5, 5, 1, -5 },
  { 289, 4, 7, 5, 1, -5 },
  { 293, 4, 5, 5, 1, -5 },
  { 296, 4, 8, 5, 1, -7 },
  { 300, 1, 8, 5, 2, -7 },
  { 301, 4, 8, 5, 1, -7 },
  { 305, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_EXTRALIGHT9PT7B_H_
