#ifndef _JETBRAINSMONO_EXTRALIGHT48PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x3E, 0xFE, 0xF9, 0xF0, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x30,
  0x06, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x1C, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x03, 0x00,
  0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x18,
  0x03, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0x1C, 0x78, 0x70, 0xE1, 0xE7, 0x87, 0x07, 0x38, 0x38, 0x39, 0xC1, 0xC1,
  0xCE, 0x0E, 0x0F, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0xC7, 0x00, 0x0F, 0xB8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1D, 0xF8, 0x00, 0xE3, 0xC0, 0x07,
  0x0F, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x3F,
  0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0xFF, 0x07, 0x07, 0x3C, 0x38,
  0x79, 0xF1, 0xC7, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0xE7, 0xFC, 0x00,
  0x39, 0xE3, 0xC0, 0x0E, 0x38, 0x18, 0x01, 0x8E, 0x03, 0x80, 0x71, 0xC0,
  0x70, 0x1C, 0x38, 0x0E, 0x03, 0x07, 0x01, 0xC0, 0xE0, 0xE0, 0x38, 0x38,
  0x1C, 0x07, 0x06, 0x03, 0x80, 0xE1, 0xC0, 0x30, 0x1C, 0x70, 0x07, 0x07,
  0x1C, 0x00, 0xFF, 0xE3, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x1E, 0x00, 0x03, 0x8F, 0xF0, 0x00, 0xE3, 0xFF, 0x00, 0x18, 0xF0, 0x70,
  0x07, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0xC0, 0x70, 0x70, 0x1C, 0x0C, 0x0E,
  0x03, 0x83, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x0E, 0x18, 0x07, 0x01, 0x87,
  0x00, 0xE0, 0x31, 0xC0, 0x1C, 0x0E, 0x30, 0x01, 0xE3, 0xCE, 0x00, 0x1F,
  0xF3, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0x8F, 0x80, 0x1E, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x01, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x79,
  0xE0, 0x01, 0x70, 0xF0, 0x0E, 0xF0, 0x78, 0x1E, 0xE0, 0x38, 0x1C, 0xE0,
  0x3C, 0x38, 0xE0, 0x1E, 0x38, 0xE0, 0x0F, 0x70, 0xE0, 0x07, 0x70, 0xE0,
  0x07, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xE0, 0xE0,
  0x03, 0xF0, 0xF0, 0x07, 0x78, 0x78, 0x1F, 0x38, 0x7E, 0x7E, 0x1C, 0x3F,
  0xFC, 0x1E, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77,
  0x00, 0x0C, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xC0, 0x07, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x38,
  0x06, 0xFC, 0x1C, 0x1F, 0x7F, 0x8E, 0x3F, 0xCF, 0xF6, 0x7F, 0x81, 0xFF,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x38, 0x01, 0xE0,
  0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xC0, 0x3E, 0x3C, 0x00, 0x71, 0xE0,
  0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0xC1, 0xF0, 0xFE,
  0x07, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x3E, 0x03, 0xE0, 0xFE, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x3E, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x03, 0xC1, 0xE0,
  0x1C, 0x0F, 0x00, 0xC0, 0x78, 0x04, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0x1F,
  0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F, 0x9F, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x0E, 0x00, 0xF1,
  0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x1F, 0xC1, 0xCF, 0xFE, 0x3B, 0xFF, 0xE7, 0x60, 0x3E, 0xF8,
  0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x73, 0xC0,
  0x3E, 0x3F, 0x3F, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x73, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0x8F, 0xC3, 0xE0, 0x0F, 0x1E, 0x00, 0x3D, 0xE0,
  0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0x38, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x7C, 0x1F, 0x8F, 0xC0,
  0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC,
  0x00, 0x1E, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83,
  0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x1E,
  0x00, 0xF0, 0x78, 0x0F, 0x01, 0xE1, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xBE, 0x01, 0xF0, 0x78, 0x1E, 0x00, 0xE1, 0xE0,
  0x03, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x39, 0xC0, 0x01, 0xCF, 0x00,
  0x1E, 0x3C, 0x01, 0xE1, 0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xC0,
  0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x8F,
  0x00, 0x7C, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFC, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x39,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF0, 0x1E,
  0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xF0, 0xF8,
  0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0,
  0x07, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0xF8, 0x0F, 0xFD, 0xF0, 0x1E, 0x1B, 0xE0, 0x78, 0x1F,
  0xC0, 0xE0, 0x1F, 0x81, 0xC0, 0x3F, 0x03, 0x80, 0x7E, 0x07, 0x00, 0xFC,
  0x0E, 0x01, 0xF8, 0x1C, 0x03, 0xF0, 0x38, 0x07, 0xE0, 0x70, 0x0F, 0xC0,
  0xE0, 0x1F, 0x81, 0xC0, 0x3F, 0x03, 0x80, 0x7E, 0x07, 0x00, 0xFC, 0x0F,
  0x03, 0xF8, 0x0F, 0x0D, 0xF0, 0x1F, 0xFB, 0xE0, 0x0F, 0xE7, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x78, 0x00, 0xE0,
  0xE0, 0x01, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x38, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0x7C,
  0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00,
  0x1C, 0xE0, 0x07, 0x8E, 0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0,
  0x1F, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x7C, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xF1, 0xF8, 0x78, 0x03, 0xC7, 0x00, 0x1E, 0xF0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0xE7,
  0x00, 0x1E, 0x7C, 0x03, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x79,
  0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8,
  0x01, 0xE7, 0x00, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x03, 0xF1, 0xF8, 0x78, 0x03, 0xC7, 0x00, 0x1E, 0xF0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0,
  0x00, 0xE7, 0x00, 0x1E, 0x7C, 0x03, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00,
  0x7F, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x0F,
  0x78, 0x01, 0xE3, 0xC0, 0x3E, 0x3F, 0x1F, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE,
  0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x87, 0x00, 0x38, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x70,
  0x0E, 0x03, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0F, 0x03, 0x80,
  0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00,
  0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0xC0, 0x1B, 0xF6, 0x01,
  0xDF, 0xB8, 0x0E, 0xFC, 0xC0, 0x67, 0xE7, 0x07, 0x3F, 0x38, 0x39, 0xF8,
  0xC1, 0x8F, 0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF0, 0xC6, 0x1F, 0x87, 0x70,
  0xFC, 0x3B, 0x87, 0xE0, 0xD8, 0x3F, 0x07, 0xC1, 0xF8, 0x3C, 0x0F, 0xC0,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFB, 0x80, 0x3F, 0x70, 0x07,
  0xE6, 0x00, 0xFC, 0xE0, 0x1F, 0x9C, 0x03, 0xF1, 0xC0, 0x7E, 0x38, 0x0F,
  0xC7, 0x01, 0xF8, 0x70, 0x3F, 0x0E, 0x07, 0xE0, 0xC0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x38, 0x7E, 0x07, 0x0F, 0xC0, 0x61, 0xF8, 0x0E, 0x3F,
  0x01, 0xC7, 0xE0, 0x1C, 0xFC, 0x03, 0x9F, 0x80, 0x73, 0xF0, 0x07, 0x7E,
  0x00, 0xEF, 0xC0, 0x0D, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0x9F, 0xC7, 0x80, 0x7C, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x1E, 0x78, 0x07, 0xC7,
  0xF7, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xC0, 0x07, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80,
  0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00,
  0x3E, 0xE0, 0x03, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xF1,
  0xF8, 0x78, 0x07, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x01, 0xE7, 0x00, 0x3C, 0x78,
  0x07, 0xC3, 0xFB, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x7B,
  0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C,
  0x00, 0x7C, 0xE0, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x3C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0xB8, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0x1F, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xDC, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xCF, 0x00, 0x1E, 0x7C, 0x01, 0xE1, 0xFE, 0x7F, 0x07, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0xC0, 0x3C,
  0x3F, 0xBF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCF, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x78, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x76, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x06,
  0xC0, 0x7E, 0x03, 0x60, 0x3F, 0x01, 0xB0, 0x1F, 0x80, 0xD8, 0x1C, 0xC0,
  0x6C, 0x0E, 0x70, 0x36, 0x07, 0x38, 0x3B, 0x83, 0x9C, 0x18, 0xC1, 0xCE,
  0x0C, 0x60, 0xE7, 0x06, 0x30, 0x73, 0x83, 0x18, 0x39, 0xC1, 0x8C, 0x18,
  0x60, 0xC6, 0x1C, 0x38, 0xE3, 0x0E, 0x1C, 0x61, 0xC7, 0x0E, 0x30, 0x63,
  0x87, 0x18, 0x31, 0xC3, 0x8C, 0x18, 0xE1, 0xC6, 0x0C, 0x70, 0xE3, 0x06,
  0x30, 0x71, 0x83, 0x18, 0x19, 0xC1, 0xCC, 0x0E, 0xC0, 0xEE, 0x07, 0x60,
  0x37, 0x03, 0xB0, 0x1B, 0x81, 0xD8, 0x0D, 0xC0, 0xEC, 0x06, 0xE0, 0x76,
  0x03, 0x60, 0x3F, 0x01, 0xB0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x07,
  0x03, 0x80, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x8E, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x01,
  0xC0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xDC,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x3C,
  0x01, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x07, 0xF0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xF0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xF7, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0x00, 0x77, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xF7, 0x80, 0x37, 0x7E, 0x0F, 0x73, 0xFF, 0xE7, 0x0F, 0xF8,
  0x70, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xF8, 0x1C, 0x7F,
  0xC3, 0xBF, 0xFE, 0x77, 0x03, 0xCF, 0x80, 0x3D, 0xE0, 0x03, 0xBC, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x77, 0xC0, 0x1E, 0xEF, 0x1F, 0x9C, 0xFF, 0xE3, 0x8F, 0xF8,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x07, 0xC7, 0x80,
  0x3D, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0xE0, 0x1E, 0x3F, 0xBF,
  0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x03, 0xE0, 0xE1, 0xFF, 0x1C, 0xFF, 0xF3, 0xBE, 0x07, 0x77, 0x80,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xDC, 0x00, 0xFB, 0xC0, 0x37, 0x3F, 0x1E,
  0xE3, 0xFF, 0x9C, 0x3F, 0xE3, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00,
  0x73, 0xC0, 0x1E, 0x3F, 0x0F, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xFF, 0x1C, 0xFF, 0xF3, 0xBE, 0x07, 0x77, 0x80, 0x2F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xF7,
  0x00, 0x3E, 0xF8, 0x0D, 0xCF, 0xFF, 0xB8, 0xFF, 0xE7, 0x07, 0xF0, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xF8, 0x1C,
  0x7F, 0xC3, 0xBF, 0xFE, 0x76, 0x03, 0xCF, 0x80, 0x3D, 0xE0, 0x03, 0xBC,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0xCE,
  0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x1E,
  0x07, 0x00, 0xF0, 0x38, 0x0F, 0x01, 0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xF0,
  0x38, 0x03, 0x81, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC3, 0x80,
  0x0F, 0x1C, 0x00, 0x3C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xB8, 0x00, 0x1E,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0x83, 0xC6,
  0x7E, 0x3F, 0xB7, 0xFB, 0xFD, 0xA1, 0xD0, 0xFE, 0x07, 0x03, 0xF0, 0x38,
  0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8,
  0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0,
  0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0,
  0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0E, 0x00, 0xF8, 0x1C, 0x7F,
  0xC3, 0xBF, 0xFE, 0x77, 0x07, 0xCF, 0x80, 0x3D, 0xE0, 0x03, 0xBC, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80,
  0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xF3, 0xC0, 0x3E, 0x3F, 0xBF,
  0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x1C, 0x7F, 0xC3, 0xBF,
  0xFE, 0x77, 0x03, 0xCF, 0x80, 0x3D, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0x77, 0xE0, 0x1E, 0xEF, 0x1F, 0x9C, 0xFF, 0xE3, 0x8F, 0xF8, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0x1C, 0xFF, 0xF3, 0xBE, 0x07, 0x77, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03,
  0xDC, 0x00, 0xFB, 0xC0, 0x37, 0x3F, 0x1E, 0xE3, 0xFF, 0x9C, 0x3F, 0xE3,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0xF8,
  0x1C, 0xFF, 0xC3, 0xBF, 0xFC, 0x76, 0x03, 0xCF, 0x80, 0x3D, 0xE0, 0x03,
  0xBC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C,
  0x07, 0xC3, 0x80, 0x0F, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xB8, 0x00,
  0x39, 0xC0, 0x01, 0xCF, 0x80, 0x1E, 0x3F, 0x87, 0xE0, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x1C, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xFD, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x1E, 0x01, 0x9C,
  0x0F, 0x01, 0xCE, 0x06, 0xC0, 0xE7, 0x03, 0x60, 0x73, 0x81, 0xB0, 0x39,
  0xC0, 0xD8, 0x1C, 0xE0, 0xEC, 0x0C, 0x30, 0x67, 0x0E, 0x1C, 0x31, 0x87,
  0x0E, 0x18, 0xC3, 0x87, 0x0C, 0x61, 0xC3, 0x86, 0x30, 0xE1, 0xC6, 0x18,
  0x60, 0x63, 0x06, 0x70, 0x39, 0x83, 0x38, 0x1C, 0xC1, 0x9C, 0x0E, 0x60,
  0xCE, 0x07, 0x70, 0x67, 0x03, 0xB0, 0x3B, 0x00, 0xD8, 0x0D, 0x80, 0x6C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xC0,
  0xF0, 0x07, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0xE0, 0x01,
  0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF7,
  0x00, 0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xBC,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x01, 0xDF, 0xF0, 0x0F,
  0xE3, 0xC0, 0x7E, 0x0F, 0x03, 0xF0, 0x3C, 0x1F, 0x80, 0xF1, 0xFC, 0x03,
  0xFE, 0xE0, 0x0F, 0xE7, 0x00, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 35, 29, 11, -35 },
  { 32, 13, 14, 29, 8, -35 },
  { 55, 25, 35, 29, 2, -35 },
  { 165, 21, 49, 29, 4, -42 },
  { 294, 27, 35, 29, 1, -35 },
  { 413, 24, 36, 29, 3, -36 },
  { 521, 4, 14, 29, 12, -35 },
  { 528, 14, 46, 29, 9, -40 },
  { 609, 13, 46, 29, 6, -40 },
  { 684, 25, 24, 29, 2, -29 },
  { 759, 22, 22, 29, 3, -27 },
  { 820, 8, 15, 29, 9, -7 },
  { 835, 15, 3, 29, 7, -17 },
  { 841, 7, 7, 29, 11, -7 },
  { 848, 21, 45, 29, 4, -40 },
  { 967, 21, 36, 29, 4, -36 },
  { 1062, 21, 35, 29, 5, -35 },
  { 1154, 21, 36, 29, 4, -36 },
  { 1249, 20, 35, 29, 4, -35 },
  { 1337, 20, 35, 29, 4, -35 },
  { 1425, 19, 35, 29, 5, -35 },
  { 1509, 21, 35, 29, 4, -35 },
  { 1601, 21, 35, 29, 4, -35 },
  { 1693, 21, 36, 29, 4, -36 },
  { 1788, 21, 36, 29, 4, -36 },
  { 1883, 7, 27, 29, 11, -27 },
  { 1907, 9, 35, 29, 9, -27 },
  { 1947, 21, 24, 29, 4, -28 },
  { 2010, 20, 14, 29, 4, -23 },
  { 2045, 21, 24, 29, 4, -28 },
  { 2108, 17, 35, 29, 7, -35 },
  { 2183, 23, 45, 29, 3, -36 },
  { 2313, 23, 35, 29, 3, -35 },
  { 2414, 20, 35, 29, 5, -35 },
  { 2502, 20, 36, 29, 5, -36 },
  { 2592, 19, 35, 29, 5, -35 },
  { 2676, 20, 35, 29, 5, -35 },
  { 2764, 20, 35, 29, 5, -35 },
  { 2852, 20, 36, 29, 5, -36 },
  { 2942, 19, 35, 29, 5, -35 },
  { 3026, 18, 35, 29, 5, -35 },
  { 3105, 20, 35, 29, 3, -35 },
  { 3193, 21, 35, 29, 5, -35 },
  { 3285, 19, 35, 29, 6, -35 },
  { 3369, 21, 35, 29, 4, -35 },
  { 3461, 19, 35, 29, 5, -35 },
  { 3545, 19, 36, 29, 5, -36 },
  { 3631, 21, 35, 29, 5, -35 },
  { 3723, 20, 45, 29, 5, -36 },
  { 3836, 21, 35, 29, 5, -35 },
  { 3928, 21, 36, 29, 4, -36 },
  { 4023, 23, 35, 29, 3, -35 },
  { 4124, 19, 35, 29, 5, -35 },
  { 4208, 23, 35, 29, 3, -35 },
  { 4309, 25, 35, 29, 2, -35 },
  { 4419, 25, 35, 29, 2, -35 },
  { 4529, 25, 35, 29, 2, -35 },
  { 4639, 21, 35, 29, 4, -35 },
  { 4731, 11, 45, 29, 10, -40 },
  { 4793, 21, 45, 29, 4, -40 },
  { 4912, 12, 45, 29, 7, -40 },
  { 4980, 20, 19, 29, 4, -35 },
  { 5028, 23, 3, 29, 3, 1 },
  { 5037, 9, 7, 29, 9, -38 },
  { 5045, 20, 27, 29, 4, -27 },
  { 5113, 19, 35, 29, 5, -35 },
  { 5197, 19, 27, 29, 5, -27 },
  { 5262, 19, 35, 29, 5, -35 },
  { 5346, 19, 27, 29, 5, -27 },
  { 5411, 22, 35, 29, 3, -35 },
  { 5508, 19, 36, 29, 5, -27 },
  { 5594, 19, 35, 29, 5, -35 },
  { 5678, 22, 37, 29, 4, -37 },
  { 5780, 18, 46, 29, 4, -37 },
  { 5884, 21, 35, 29, 5, -35 },
  { 5976, 24, 35, 29, 2, -35 },
  { 6081, 21, 27, 29, 4, -27 },
  { 6152, 19, 27, 29, 5, -27 },
  { 6217, 19, 27, 29, 5, -27 },
  { 6282, 19, 36, 29, 5, -27 },
  { 6368, 19, 36, 29, 5, -27 },
  { 6454, 19, 27, 29, 6, -27 },
  { 6519, 21, 27, 29, 4, -27 },
  { 6590, 22, 34, 29, 3, -34 },
  { 6684, 19, 26, 29, 5, -26 },
  { 6746, 23, 26, 29, 3, -26 },
  { 6821, 25, 26, 29, 2, -26 },
  { 6903, 23, 26, 29, 3, -26 },
  { 6978, 23, 35, 29, 3, -26 },
  { 7079, 19, 26, 29, 5, -26 },
  { 7141, 19, 45, 29, 5, -40 },
  { 7248, 3, 45, 29, 13, -40 },
  { 7265, 19, 45, 29, 5, -40 },
  { 7372, 21, 10, 29, 4, -22 },
};

const GFXfont JetBrainsMono_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_EXTRALIGHT48PT7B_H_
