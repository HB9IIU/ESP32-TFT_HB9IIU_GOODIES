#ifndef _JETBRAINSMONO_EXTRALIGHT59PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0,
  0x1F, 0x78, 0x0F, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x31,
  0xF8, 0x3E, 0x0C, 0x3E, 0x0F, 0x03, 0x03, 0xC7, 0xC0, 0xC0, 0xF1, 0xE0,
  0x30, 0x1E, 0x78, 0x0C, 0x07, 0x9E, 0x03, 0x01, 0xE7, 0x80, 0xC0, 0x79,
  0xE0, 0x30, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0x03, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0xF8, 0x30, 0x00, 0x3F, 0x0C, 0x00, 0x07, 0xE3, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x37, 0xF0, 0x00, 0x0C, 0x7E, 0x00, 0x03, 0x07,
  0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x30, 0x3E, 0x00, 0x0C, 0x07, 0x80, 0x03,
  0x01, 0xE0, 0x00, 0xC0, 0x3C, 0x00, 0x30, 0x0F, 0xF0, 0x0C, 0x03, 0xFC,
  0x03, 0x00, 0xFF, 0x00, 0xC0, 0x7F, 0xC0, 0x30, 0x1E, 0x78, 0x0C, 0x07,
  0x9F, 0x03, 0x03, 0xE3, 0xE0, 0xC1, 0xF0, 0xFE, 0x31, 0xF8, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0x8F, 0xFE, 0x00, 0x03, 0x8F, 0xFF, 0x80, 0x03, 0xCF, 0x83,
  0xC0, 0x01, 0xC7, 0x80, 0xF0, 0x01, 0xC3, 0x80, 0x38, 0x01, 0xC1, 0xC0,
  0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0x70, 0x78, 0x03, 0x80, 0x78, 0x38, 0x01, 0xE0, 0x3C, 0x38, 0x00,
  0xF0, 0x3C, 0x3C, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x0F, 0xFE, 0x1C, 0x00,
  0x03, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x07, 0xF8, 0x00, 0x07, 0x87, 0xFF, 0x00, 0x03, 0x87,
  0xFF, 0x80, 0x03, 0x87, 0x81, 0xE0, 0x03, 0x83, 0x80, 0x70, 0x03, 0xC3,
  0xC0, 0x3C, 0x01, 0xC1, 0xE0, 0x1E, 0x01, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0x78, 0x07, 0x80, 0xE0, 0x3C, 0x03, 0xC0, 0xE0, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x00, 0xF0, 0x70, 0x07, 0x80, 0x78, 0x70, 0x01, 0xC0, 0x3C, 0x78,
  0x00, 0xE0, 0x1C, 0x78, 0x00, 0x78, 0x1E, 0x38, 0x00, 0x1F, 0xFE, 0x38,
  0x00, 0x07, 0xFE, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3F, 0x07, 0x80, 0x1E, 0xF0,
  0x3E, 0x00, 0xF7, 0x80, 0xF8, 0x0F, 0x3C, 0x03, 0xC0, 0x79, 0xE0, 0x0F,
  0x07, 0x8F, 0x00, 0x7C, 0x78, 0x78, 0x01, 0xF3, 0xC3, 0xC0, 0x07, 0xBC,
  0x1E, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0xFE, 0x07, 0x80, 0x03, 0xF0, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xF0, 0x78, 0x00,
  0x7F, 0x83, 0xC0, 0x07, 0xDE, 0x1F, 0x00, 0x7C, 0x78, 0x7E, 0x0F, 0xC3,
  0xE1, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0xC0, 0x3C, 0x1F, 0xF8, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBD, 0xEE, 0x73, 0x80, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x03, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x19, 0xF8,
  0x0E, 0x01, 0xF3, 0xFC, 0x1C, 0x1F, 0xFF, 0xFE, 0x38, 0xFF, 0xE3, 0xFF,
  0x37, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x1F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x81, 0xF8, 0x0F, 0xE1, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0x80, 0xFF, 0x03, 0xE0, 0x7F, 0x81, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F,
  0xE0, 0x7E, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x04, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0xCF,
  0x00, 0x07, 0xE3, 0xC0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0xF8,
  0x0F, 0x00, 0x38, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x02, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3E, 0x00,
  0x7E, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0xFF,
  0xC0, 0x71, 0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0x83, 0xFC, 0xFE, 0x00,
  0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xCF, 0xF8, 0x01,
  0xEF, 0xFF, 0x80, 0xF7, 0xFF, 0xF0, 0x3F, 0xC0, 0xFE, 0x1F, 0x80, 0x0F,
  0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x7E, 0x03, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x3E, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x07,
  0xC1, 0xF8, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x03, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3C, 0x7C, 0x00,
  0x3E, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7F, 0x03, 0xFC, 0x0F,
  0xFF, 0xDE, 0x01, 0xFF, 0xEF, 0x80, 0x1F, 0xE3, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0xFE, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x04, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9F,
  0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x0C,
  0x0F, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xFE, 0xFF, 0x00, 0x7F, 0x7B,
  0xFC, 0x03, 0xE0, 0x3F, 0xF0, 0x0F, 0x00, 0x7F, 0xC0, 0x38, 0x01, 0xFF,
  0x01, 0xE0, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xF0, 0x1E, 0x00, 0x3F, 0xC0,
  0x78, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xF0, 0x1E,
  0x00, 0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x80,
  0x0F, 0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x00, 0xE0, 0x07,
  0xFC, 0x03, 0xC0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x1F, 0x9E, 0xFF,
  0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x7F, 0xCF, 0x70, 0x00, 0x7C, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1E, 0x01, 0xFF, 0x0F,
  0x00, 0x0F, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x7E, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x83, 0xC0, 0x3F, 0xE1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xC0, 0x01,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xF0, 0x1F, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0xFC, 0xF0,
  0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFD,
  0xC0, 0x03, 0xFE, 0xE0, 0x03, 0xFF, 0x70, 0x01, 0xDF, 0x9C, 0x00, 0xEF,
  0xCE, 0x00, 0xF7, 0xE7, 0x00, 0x73, 0xF1, 0xC0, 0x39, 0xFC, 0xE0, 0x38,
  0xFE, 0x78, 0x1C, 0x7F, 0x1C, 0x0E, 0x3F, 0x8E, 0x0E, 0x1F, 0xC7, 0x87,
  0x0F, 0xE1, 0xC3, 0x87, 0xF0, 0xE3, 0x83, 0xF8, 0x79, 0xC1, 0xFC, 0x1C,
  0xE0, 0xFE, 0x0E, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFB, 0x80, 0x07, 0xF7, 0x80, 0x0F, 0xEF, 0x00, 0x1F, 0xCE, 0x00,
  0x3F, 0x9E, 0x00, 0x7F, 0x1C, 0x00, 0xFE, 0x38, 0x01, 0xFC, 0x78, 0x03,
  0xF8, 0x70, 0x07, 0xF0, 0xF0, 0x0F, 0xE1, 0xE0, 0x1F, 0xC1, 0xC0, 0x3F,
  0x83, 0xC0, 0x7F, 0x03, 0x80, 0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x03, 0xF8,
  0x0E, 0x07, 0xF0, 0x1E, 0x0F, 0xE0, 0x3C, 0x1F, 0xC0, 0x38, 0x3F, 0x80,
  0x78, 0x7F, 0x00, 0x70, 0xFE, 0x00, 0xF1, 0xFC, 0x01, 0xE3, 0xF8, 0x01,
  0xC7, 0xF0, 0x03, 0xCF, 0xE0, 0x03, 0x9F, 0xC0, 0x07, 0x3F, 0x80, 0x0F,
  0x7F, 0x00, 0x0E, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xC0, 0x0F,
  0xF8, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x7C,
  0x00, 0x7C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1B, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xC0, 0x1F, 0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x01, 0xF8, 0xF0, 0x07,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xF0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3F,
  0x80, 0x7E, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7,
  0x80, 0x03, 0xEF, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0xF7, 0x00, 0x7E,
  0x01, 0xEE, 0x00, 0xDC, 0x03, 0xDC, 0x01, 0xB8, 0x07, 0xBC, 0x03, 0x70,
  0x0E, 0x78, 0x0E, 0x60, 0x1C, 0xF0, 0x1C, 0xC0, 0x39, 0xE0, 0x39, 0x80,
  0x73, 0xC0, 0x73, 0x81, 0xE3, 0x80, 0xE7, 0x03, 0xC7, 0x01, 0x8E, 0x07,
  0x8E, 0x03, 0x1C, 0x0F, 0x1C, 0x06, 0x38, 0x1E, 0x3C, 0x1C, 0x30, 0x38,
  0x78, 0x38, 0x60, 0x70, 0xF0, 0x70, 0xC0, 0xE1, 0xE0, 0xE1, 0xC1, 0xC3,
  0xC1, 0x83, 0x87, 0x83, 0x83, 0x07, 0x0F, 0x07, 0x06, 0x0E, 0x1E, 0x0E,
  0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x18, 0x70, 0x3C, 0x70, 0x30, 0xE0, 0x78,
  0xE0, 0x71, 0xC0, 0xF1, 0xC0, 0xE3, 0x81, 0xE3, 0x01, 0xC7, 0x01, 0xC6,
  0x03, 0x9E, 0x03, 0x9C, 0x07, 0x3C, 0x07, 0x38, 0x0E, 0x78, 0x0E, 0x70,
  0x0C, 0xE0, 0x1E, 0xE0, 0x19, 0xC0, 0x3D, 0xC0, 0x3B, 0x80, 0x7B, 0x00,
  0x77, 0x00, 0xF6, 0x00, 0xEE, 0x00, 0xEC, 0x01, 0xDC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x07, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xF8, 0x03, 0xF0,
  0xF8, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0xEF, 0x80, 0x00, 0x77, 0x80,
  0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7,
  0xE0, 0x01, 0xB9, 0xF8, 0x03, 0xDC, 0x7F, 0xFF, 0xCE, 0x1F, 0xFF, 0xC7,
  0x03, 0xFF, 0x83, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x7F, 0x80, 0xF1, 0xFF, 0xE0, 0xF3, 0xFF, 0xF0, 0xF7, 0xC3,
  0xF8, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xFC, 0x00,
  0x3E, 0xFE, 0x00, 0x7C, 0xF7, 0x00, 0xF8, 0xF7, 0xFF, 0xF8, 0xF3, 0xFF,
  0xF0, 0xF0, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x7C, 0x00,
  0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x01,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xF0, 0x78, 0x3F, 0xF8, 0xF1,
  0xFF, 0xF9, 0xE7, 0xF8, 0xFB, 0xCF, 0x80, 0x3F, 0xBE, 0x00, 0x3F, 0x78,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xDF, 0x00, 0x1F, 0x9F, 0x80, 0xFF, 0x1F, 0xFF, 0xDE, 0x1F,
  0xFF, 0x3C, 0x1F, 0xFC, 0x78, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x3E, 0x00, 0xFC, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x3C, 0x7F, 0xFE,
  0x79, 0xFE, 0x3E, 0xF3, 0xE0, 0x0F, 0xEF, 0x80, 0x0F, 0xDE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0xFF, 0xFE,
  0xF0, 0xFF, 0xF9, 0xE0, 0xFF, 0xE3, 0xC0, 0x3E, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC1, 0xFE, 0x07, 0x8F, 0xFF, 0x0F, 0x3F, 0xFF,
  0x1E, 0xF8, 0x7F, 0x3D, 0x80, 0x3F, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x7C, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xF0, 0x3E, 0x1E, 0xFF, 0x0F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7E, 0x1F, 0x63,
  0xEF, 0x81, 0xF0, 0x3F, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80,
  0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07,
  0xF8, 0x07, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03,
  0x80, 0x7F, 0x80, 0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F,
  0xC0, 0x38, 0x07, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C,
  0x03, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xFE,
  0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0xE0,
  0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x70, 0x0F, 0xF0,
  0x0E, 0x01, 0xE0, 0x00, 0x7F, 0x81, 0xE3, 0xFF, 0xC3, 0xCF, 0xFF, 0xC7,
  0xBE, 0x1F, 0xCF, 0x60, 0x0F, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0E, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x80, 0xF1,
  0xFF, 0xE0, 0xF3, 0xFF, 0xF0, 0xF7, 0xC3, 0xF8, 0xFE, 0x00, 0xFC, 0xFC,
  0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7C, 0xF7,
  0x00, 0xF8, 0xF7, 0xFF, 0xF8, 0xF3, 0xFF, 0xF0, 0xF0, 0xFF, 0xC0, 0xF0,
  0x0C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xFE, 0x3C, 0x7F, 0xFE, 0x79, 0xFE, 0x3E, 0xF3, 0xE0, 0x0F, 0xEF, 0x80,
  0x0F, 0xDE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xE7, 0xE0, 0x3F, 0xC7, 0xFF,
  0xF7, 0x87, 0xFF, 0xCF, 0x03, 0xFE, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0xF1, 0xFF, 0xE0, 0xF3, 0xFF, 0xF0,
  0xF7, 0xC3, 0xF8, 0xF6, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xF1, 0xE0, 0x00,
  0x79, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0xF1, 0xF8, 0x01, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x1F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0x80,
  0x3F, 0xC0, 0x3E, 0x00, 0xEF, 0x00, 0xF8, 0x03, 0xBC, 0x03, 0xE0, 0x0E,
  0xF0, 0x0D, 0xC0, 0x39, 0xC0, 0x37, 0x01, 0xE7, 0x00, 0xDC, 0x07, 0x9C,
  0x07, 0x30, 0x1C, 0x78, 0x1C, 0xC0, 0x71, 0xE0, 0x73, 0x01, 0xC7, 0x81,
  0x8E, 0x07, 0x0E, 0x06, 0x38, 0x3C, 0x38, 0x38, 0xE0, 0xF0, 0xE0, 0xE1,
  0x83, 0x83, 0xC3, 0x86, 0x0E, 0x0F, 0x0E, 0x1C, 0x38, 0x3C, 0x30, 0x70,
  0xE0, 0x70, 0xC1, 0xC7, 0x81, 0xC7, 0x07, 0x1E, 0x07, 0x1C, 0x0C, 0x70,
  0x1C, 0x70, 0x31, 0xC0, 0x79, 0x80, 0xE7, 0x01, 0xE6, 0x03, 0x9C, 0x03,
  0x98, 0x0E, 0x70, 0x0E, 0xE0, 0x3B, 0xC0, 0x3B, 0x80, 0x6E, 0x00, 0xEE,
  0x01, 0xB8, 0x03, 0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xDF, 0xFC, 0x00, 0xF7, 0xFF, 0x80, 0x3F, 0xC1,
  0xF0, 0x0F, 0xF0, 0x3C, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x00, 0xF0, 0x3F,
  0x80, 0x3F, 0x3E, 0xE0, 0x07, 0xFF, 0xB8, 0x00, 0x7F, 0xCE, 0x00, 0x07,
  0xC0,
};

const GFXglyph JetBrainsMono_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 8, 43, 35, 14, -43 },
  { 44, 17, 18, 35, 9, -43 },
  { 83, 31, 43, 35, 2, -43 },
  { 250, 26, 59, 35, 5, -51 },
  { 442, 33, 43, 35, 1, -43 },
  { 620, 29, 45, 35, 4, -44 },
  { 784, 5, 18, 35, 15, -43 },
  { 796, 17, 57, 35, 12, -50 },
  { 918, 17, 57, 35, 7, -50 },
  { 1040, 31, 30, 35, 2, -36 },
  { 1157, 27, 27, 35, 4, -33 },
  { 1249, 10, 18, 35, 11, -9 },
  { 1272, 19, 3, 35, 8, -21 },
  { 1280, 9, 10, 35, 13, -9 },
  { 1292, 25, 55, 35, 5, -49 },
  { 1464, 25, 45, 35, 5, -44 },
  { 1605, 26, 43, 35, 6, -43 },
  { 1745, 26, 44, 35, 5, -44 },
  { 1888, 24, 44, 35, 5, -43 },
  { 2020, 24, 43, 35, 5, -43 },
  { 2149, 24, 44, 35, 6, -43 },
  { 2281, 26, 44, 35, 5, -43 },
  { 2424, 26, 43, 35, 5, -43 },
  { 2564, 25, 45, 35, 5, -44 },
  { 2705, 26, 44, 35, 5, -44 },
  { 2848, 9, 34, 35, 13, -33 },
  { 2887, 11, 42, 35, 11, -33 },
  { 2945, 25, 31, 35, 5, -35 },
  { 3042, 25, 17, 35, 5, -28 },
  { 3096, 25, 31, 35, 5, -35 },
  { 3193, 20, 43, 35, 9, -43 },
  { 3301, 30, 55, 35, 3, -44 },
  { 3508, 28, 43, 35, 4, -43 },
  { 3659, 25, 43, 35, 6, -43 },
  { 3794, 24, 45, 35, 6, -44 },
  { 3929, 24, 43, 35, 6, -43 },
  { 4058, 23, 43, 35, 7, -43 },
  { 4182, 25, 43, 35, 6, -43 },
  { 4317, 24, 45, 35, 6, -44 },
  { 4452, 23, 43, 35, 6, -43 },
  { 4576, 22, 43, 35, 7, -43 },
  { 4695, 25, 44, 35, 4, -43 },
  { 4833, 26, 43, 35, 6, -43 },
  { 4973, 24, 43, 35, 7, -43 },
  { 5102, 25, 43, 35, 5, -43 },
  { 5237, 23, 43, 35, 6, -43 },
  { 5361, 24, 45, 35, 6, -44 },
  { 5496, 26, 43, 35, 6, -43 },
  { 5636, 24, 55, 35, 6, -44 },
  { 5801, 26, 43, 35, 6, -43 },
  { 5941, 26, 45, 35, 5, -44 },
  { 6088, 29, 43, 35, 3, -43 },
  { 6244, 23, 44, 35, 6, -43 },
  { 6371, 28, 43, 35, 4, -43 },
  { 6522, 31, 43, 35, 2, -43 },
  { 6689, 30, 43, 35, 3, -43 },
  { 6851, 30, 43, 35, 3, -43 },
  { 7013, 25, 43, 35, 5, -43 },
  { 7148, 13, 55, 35, 13, -49 },
  { 7238, 25, 55, 35, 5, -49 },
  { 7410, 14, 55, 35, 9, -49 },
  { 7507, 25, 23, 35, 5, -43 },
  { 7579, 28, 4, 35, 4, 1 },
  { 7593, 11, 8, 35, 11, -46 },
  { 7604, 25, 34, 35, 4, -33 },
  { 7711, 24, 44, 35, 6, -43 },
  { 7843, 24, 34, 35, 6, -33 },
  { 7945, 23, 44, 35, 6, -43 },
  { 8072, 24, 34, 35, 6, -33 },
  { 8174, 27, 43, 35, 4, -43 },
  { 8320, 23, 44, 35, 6, -33 },
  { 8447, 23, 43, 35, 6, -43 },
  { 8571, 27, 45, 35, 5, -45 },
  { 8723, 22, 56, 35, 5, -45 },
  { 8877, 26, 43, 35, 6, -43 },
  { 9017, 30, 43, 35, 2, -43 },
  { 9179, 27, 33, 35, 4, -33 },
  { 9291, 23, 33, 35, 6, -33 },
  { 9386, 24, 34, 35, 6, -33 },
  { 9488, 24, 44, 35, 6, -33 },
  { 9620, 23, 44, 35, 6, -33 },
  { 9747, 24, 33, 35, 7, -33 },
  { 9846, 25, 34, 35, 5, -33 },
  { 9953, 26, 42, 35, 4, -42 },
  { 10090, 23, 33, 35, 6, -32 },
  { 10185, 27, 32, 35, 4, -32 },
  { 10293, 30, 32, 35, 3, -32 },
  { 10413, 28, 32, 35, 4, -32 },
  { 10525, 27, 43, 35, 4, -32 },
  { 10671, 24, 32, 35, 6, -32 },
  { 10767, 24, 55, 35, 6, -49 },
  { 10932, 4, 55, 35, 16, -49 },
  { 10960, 24, 55, 35, 6, -49 },
  { 11125, 26, 11, 35, 5, -26 },
};

const GFXfont JetBrainsMono_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_EXTRALIGHT59PT7B_H_
