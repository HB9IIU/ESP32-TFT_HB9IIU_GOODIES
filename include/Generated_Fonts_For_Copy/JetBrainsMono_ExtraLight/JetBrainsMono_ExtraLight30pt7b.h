#ifndef _JETBRAINSMONO_EXTRALIGHT30PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x02, 0x04, 0x06,
  0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x04, 0x08, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x10, 0x08, 0x10, 0x18, 0x30, 0x18,
  0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x20, 0x30, 0x60, 0x30, 0x60, 0x30,
  0x60, 0x30, 0x60, 0x20, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x0F, 0xC0, 0xFF, 0xC3, 0x33, 0x98, 0xC6, 0x63, 0x19, 0x8C, 0x66, 0x30,
  0x1C, 0xC0, 0x33, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0x70, 0x0C,
  0xE0, 0x31, 0x80, 0xC3, 0xC3, 0x0F, 0x0C, 0x36, 0x31, 0x9C, 0xCE, 0x3F,
  0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x03,
  0xFE, 0x02, 0xC2, 0x06, 0xC3, 0x0C, 0x83, 0x08, 0x83, 0x18, 0xC3, 0x30,
  0xC2, 0x20, 0x7E, 0x60, 0x3C, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x3C,
  0x06, 0x7E, 0x04, 0x43, 0x0C, 0xC3, 0x18, 0xC1, 0x10, 0xC1, 0x30, 0xC3,
  0x60, 0xC3, 0x40, 0x77, 0xC0, 0x3E, 0x0F, 0x80, 0x7F, 0xC0, 0xC1, 0x83,
  0x01, 0x86, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0x30, 0x7C, 0x30, 0xD8, 0x73, 0x30, 0x66, 0x60, 0x78,
  0xC0, 0x71, 0x80, 0xE3, 0x03, 0xC7, 0x0E, 0xC7, 0xF8, 0xC7, 0xE1, 0xC0,
  0xFF, 0xFF, 0xC0, 0x03, 0x83, 0xC7, 0x07, 0x03, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x08,
  0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x08, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x41, 0x82, 0xF9, 0x9F, 0x7F, 0xFE, 0x0F,
  0xF0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x30, 0x18,
  0x18, 0x18, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x1C, 0xE3, 0x8E, 0x31, 0xC6, 0x18, 0x63, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x1F,
  0x87, 0xFE, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x43, 0xCF, 0x3C, 0xF3, 0xC2, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x06, 0x7F, 0xE1, 0xF8, 0x07, 0x00, 0xF8, 0x0E,
  0xC0, 0xE6, 0x0C, 0x30, 0x41, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xC7,
  0x03, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x7F,
  0xF3, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x80, 0x3F, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0xC0, 0x1B, 0x00, 0xD8, 0x0E, 0xE0, 0x63, 0xFE, 0x0F, 0xE0, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x83, 0x30, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xDF, 0xCD, 0x9E, 0xE0,
  0x7E, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0,
  0x36, 0x06, 0x7F, 0xE1, 0xF8, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xDF, 0x87, 0xCF,
  0x1C, 0x0E, 0x60, 0x1B, 0x80, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80,
  0x66, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x06, 0xE0, 0x1B, 0x80, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x1F,
  0x87, 0xFE, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x70,
  0xE3, 0x9C, 0x0F, 0x01, 0xF8, 0x70, 0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x7F, 0xE3, 0xFC, 0x0F, 0xC0, 0xFF, 0xC3,
  0x03, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1D,
  0x80, 0x67, 0x03, 0x8E, 0x1E, 0x1F, 0xB0, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x6F,
  0xFF, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x18, 0xF3, 0xCF, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xF3, 0x8E, 0x30, 0xC7, 0x18, 0x63,
  0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x30, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0xC0, 0x08,
  0x00, 0xFC, 0x3F, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0xF0, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x1C, 0x00, 0x0F, 0xE0, 0x7D, 0xE1, 0xC0, 0x63, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x23, 0xC3, 0xF7, 0x86, 0x1F,
  0x18, 0x3E, 0x30, 0x3C, 0x60, 0x78, 0xC0, 0xF1, 0x81, 0xE3, 0x03, 0xC6,
  0x07, 0x8E, 0x1F, 0x0E, 0x7E, 0x0F, 0xBC, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x04, 0x80, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x18, 0x60,
  0x61, 0x81, 0x86, 0x06, 0x18, 0x30, 0x30, 0xC0, 0xC3, 0xFF, 0x0F, 0xFC,
  0x60, 0x19, 0x80, 0x66, 0x01, 0xB8, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0xFF,
  0x87, 0xFE, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0xC0, 0x66, 0x07, 0x3F, 0xE1, 0xFF, 0xCC, 0x07, 0x60, 0x1B, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0D, 0x80, 0xEF, 0xFE, 0x7F, 0xC0, 0x1F,
  0x83, 0xFE, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x07, 0x7F, 0xE1, 0xF8, 0xFF, 0x0F, 0xFC, 0xC0,
  0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x6C, 0x0E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEC, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x1F, 0x83, 0xFE, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x3F, 0xC3, 0xFC, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x07, 0x7F, 0xE1, 0xF8, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x1E, 0x01, 0xB0, 0x0C,
  0xC0, 0xE7, 0xFE, 0x0F, 0xE0, 0xC0, 0x1E, 0x01, 0xB0, 0x0D, 0x80, 0xCC,
  0x06, 0x60, 0x63, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x3F, 0xC1, 0xFE,
  0x0C, 0x18, 0x60, 0xC3, 0x07, 0x18, 0x18, 0xC0, 0xE6, 0x03, 0x30, 0x1D,
  0x80, 0x6C, 0x03, 0xE0, 0x0C, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x07, 0xA0, 0x5B, 0x05, 0xB0, 0xD9, 0x09, 0x99,
  0x99, 0x99, 0x89, 0x18, 0xF3, 0x8F, 0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xD0, 0x3D, 0x83, 0xD8, 0x3C, 0xC3, 0xCC,
  0x3C, 0x43, 0xC6, 0x3C, 0x63, 0xC2, 0x3C, 0x33, 0xC3, 0x3C, 0x1B, 0xC1,
  0xBC, 0x0B, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0x1F, 0x83, 0xFC, 0x60,
  0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x36, 0x06, 0x7F, 0xE1, 0xF8, 0xFF, 0x87, 0xFF, 0x30, 0x1D, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x3D, 0xFF,
  0xCF, 0xE0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F, 0x87, 0xFC, 0x60, 0x6C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x7F,
  0xE1, 0xF8, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0xFF, 0x87,
  0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xB0, 0x79, 0xFF, 0x8C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x18,
  0xC0, 0xC6, 0x03, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x1C, 0x0F, 0xC0,
  0xFF, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0xC0, 0x0F, 0x80, 0x36, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x7F, 0xE1,
  0xF8, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x63,
  0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC1, 0x86, 0x06, 0x18, 0x18, 0x60,
  0x61, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0C, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0xC3, 0xC3, 0xC3,
  0x43, 0xC2, 0x63, 0x42, 0x62, 0x46, 0x62, 0x46, 0x62, 0x46, 0x62, 0x46,
  0x62, 0x66, 0x66, 0x66, 0x26, 0x64, 0x24, 0x24, 0x34, 0x24, 0x34, 0x2C,
  0x34, 0x2C, 0x34, 0x2C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x18, 0x18,
  0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30,
  0x0E, 0x70, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18,
  0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06,
  0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30,
  0x0E, 0x30, 0x06, 0x60, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xF0, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x06, 0x00, 0xF0,
  0x0F, 0x00, 0x98, 0x19, 0x81, 0x88, 0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06,
  0xC0, 0x3C, 0x03, 0xFF, 0xFC, 0xC3, 0x1C, 0x61, 0x80, 0x07, 0x80, 0xFF,
  0x0E, 0x1C, 0xE0, 0x76, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x3F, 0xFB,
  0x80, 0xD8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xEF, 0x1B, 0x3F,
  0x98, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x78, 0xDF, 0xCF,
  0x0E, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x06, 0xDD, 0xEC, 0xFC, 0x0F, 0x03,
  0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0x60, 0x67, 0xFE, 0x1F, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xE3, 0x3F, 0xB7, 0x0F,
  0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x07, 0x7B, 0xB3, 0xF3, 0x0F, 0x03, 0xFC,
  0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x60, 0x67, 0x9E, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x3F,
  0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x0E, 0x33, 0xFB, 0x70, 0xFE, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x0F, 0x3F,
  0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x01, 0xE3, 0xFC, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x78, 0xDF, 0xCF, 0x0E, 0xE0,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xC0,
  0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x3C, 0x7F,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0F, 0x00,
  0xD8, 0x0E, 0xC0, 0x66, 0x06, 0x30, 0x71, 0x83, 0x0C, 0x30, 0x7F, 0x83,
  0x0C, 0x18, 0x30, 0xC1, 0xC6, 0x06, 0x30, 0x19, 0x80, 0xEC, 0x03, 0x60,
  0x0C, 0xFF, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0xDC, 0x73, 0xFB, 0xEE, 0x31,
  0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C,
  0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0C, 0xC7, 0x8D, 0xFC, 0xF0, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x30, 0x0F, 0x03, 0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x60, 0x67, 0xFE, 0x1F, 0x80, 0xC7, 0x8D, 0xFC, 0xF0, 0xEE, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x6D, 0xDE, 0xCF, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x0E, 0x33, 0xFB, 0x70, 0xFE, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x60,
  0x77, 0xBB, 0x3F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xCF,
  0x0D, 0xFC, 0xE0, 0xEC, 0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x1F, 0x83, 0xFE, 0x60, 0x7C, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x03, 0xE0, 0x37,
  0xFE, 0x3F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF,
  0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xF0,
  0x3F, 0x80, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x60,
  0x67, 0xFC, 0x1F, 0x80, 0xC0, 0x0F, 0x00, 0x36, 0x01, 0x98, 0x06, 0x60,
  0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x86, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0xC1, 0x83,
  0xC1, 0x83, 0x41, 0x82, 0x63, 0xC6, 0x63, 0xC6, 0x62, 0x46, 0x62, 0x46,
  0x62, 0x46, 0x22, 0x44, 0x36, 0x6C, 0x36, 0x6C, 0x34, 0x2C, 0x34, 0x2C,
  0x34, 0x28, 0x14, 0x28, 0x1C, 0x38, 0x1C, 0x38, 0xE0, 0x1D, 0x80, 0x63,
  0x03, 0x0E, 0x1C, 0x18, 0x60, 0x33, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0x30, 0x18, 0x60, 0xE1, 0xC3, 0x03, 0x18, 0x06,
  0xE0, 0x1C, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0x98, 0x06, 0x30, 0x30, 0xC0,
  0xC3, 0x83, 0x06, 0x18, 0x18, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x06,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x1F, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x0F, 0xE0, 0xFC, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x7F, 0x03, 0xF0, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3C,
  0x0F, 0x80, 0x7C, 0x0D, 0x98, 0x3C, 0x30, 0xF0, 0x76, 0xC0, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 8, 9, 18, 5, -22 },
  { 21, 16, 22, 18, 1, -22 },
  { 65, 14, 30, 18, 2, -26 },
  { 118, 16, 22, 18, 1, -22 },
  { 162, 15, 22, 18, 2, -22 },
  { 204, 2, 9, 18, 8, -22 },
  { 207, 9, 29, 18, 6, -25 },
  { 240, 9, 29, 18, 3, -25 },
  { 273, 16, 15, 18, 1, -18 },
  { 303, 14, 14, 18, 2, -17 },
  { 328, 6, 10, 18, 5, -5 },
  { 336, 10, 2, 18, 4, -11 },
  { 339, 4, 4, 18, 7, -4 },
  { 341, 12, 28, 18, 3, -25 },
  { 383, 12, 22, 18, 3, -22 },
  { 416, 13, 22, 18, 3, -22 },
  { 452, 14, 22, 18, 2, -22 },
  { 491, 13, 22, 18, 2, -22 },
  { 527, 12, 22, 18, 3, -22 },
  { 560, 12, 22, 18, 3, -22 },
  { 593, 14, 22, 18, 2, -22 },
  { 632, 14, 22, 18, 2, -22 },
  { 671, 12, 22, 18, 3, -22 },
  { 704, 14, 22, 18, 2, -22 },
  { 743, 4, 17, 18, 7, -17 },
  { 752, 6, 22, 18, 5, -17 },
  { 769, 12, 16, 18, 3, -18 },
  { 793, 12, 8, 18, 3, -14 },
  { 805, 12, 16, 18, 3, -18 },
  { 829, 10, 22, 18, 5, -22 },
  { 857, 15, 27, 18, 2, -22 },
  { 908, 14, 22, 18, 2, -22 },
  { 947, 13, 22, 18, 3, -22 },
  { 983, 12, 22, 18, 3, -22 },
  { 1016, 12, 22, 18, 3, -22 },
  { 1049, 12, 22, 18, 3, -22 },
  { 1082, 13, 22, 18, 3, -22 },
  { 1118, 12, 22, 18, 3, -22 },
  { 1151, 12, 22, 18, 3, -22 },
  { 1184, 12, 22, 18, 3, -22 },
  { 1217, 13, 22, 18, 2, -22 },
  { 1253, 13, 22, 18, 3, -22 },
  { 1289, 12, 22, 18, 4, -22 },
  { 1322, 12, 22, 18, 3, -22 },
  { 1355, 12, 22, 18, 3, -22 },
  { 1388, 12, 22, 18, 3, -22 },
  { 1421, 13, 22, 18, 3, -22 },
  { 1457, 12, 27, 18, 3, -22 },
  { 1498, 13, 22, 18, 3, -22 },
  { 1534, 14, 22, 18, 2, -22 },
  { 1573, 14, 22, 18, 2, -22 },
  { 1612, 12, 22, 18, 3, -22 },
  { 1645, 14, 22, 18, 2, -22 },
  { 1684, 16, 22, 18, 1, -22 },
  { 1728, 16, 22, 18, 1, -22 },
  { 1772, 16, 22, 18, 1, -22 },
  { 1816, 12, 22, 18, 3, -22 },
  { 1849, 7, 28, 18, 6, -25 },
  { 1874, 12, 28, 18, 3, -25 },
  { 1916, 7, 28, 18, 5, -25 },
  { 1941, 12, 12, 18, 3, -22 },
  { 1959, 14, 1, 18, 2, 1 },
  { 1961, 5, 5, 18, 6, -24 },
  { 1965, 13, 17, 18, 2, -17 },
  { 1993, 12, 22, 18, 3, -22 },
  { 2026, 12, 17, 18, 3, -17 },
  { 2052, 12, 22, 18, 3, -22 },
  { 2085, 12, 17, 18, 3, -17 },
  { 2111, 14, 22, 18, 2, -22 },
  { 2150, 12, 22, 18, 3, -17 },
  { 2183, 12, 22, 18, 3, -22 },
  { 2216, 13, 23, 18, 3, -23 },
  { 2254, 11, 28, 18, 3, -23 },
  { 2293, 13, 22, 18, 3, -22 },
  { 2329, 15, 22, 18, 1, -22 },
  { 2371, 14, 17, 18, 2, -17 },
  { 2401, 12, 17, 18, 3, -17 },
  { 2427, 12, 17, 18, 3, -17 },
  { 2453, 12, 22, 18, 3, -17 },
  { 2486, 12, 22, 18, 3, -17 },
  { 2519, 12, 17, 18, 4, -17 },
  { 2545, 12, 17, 18, 3, -17 },
  { 2571, 13, 21, 18, 2, -21 },
  { 2606, 12, 17, 18, 3, -17 },
  { 2632, 14, 17, 18, 2, -17 },
  { 2662, 16, 17, 18, 1, -17 },
  { 2696, 14, 17, 18, 2, -17 },
  { 2726, 14, 22, 18, 2, -17 },
  { 2765, 12, 17, 18, 3, -17 },
  { 2791, 12, 28, 18, 3, -25 },
  { 2833, 2, 28, 18, 8, -25 },
  { 2840, 12, 28, 18, 3, -25 },
  { 2882, 14, 5, 18, 2, -13 },
};

const GFXfont JetBrainsMono_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_EXTRALIGHT30PT7B_H_
