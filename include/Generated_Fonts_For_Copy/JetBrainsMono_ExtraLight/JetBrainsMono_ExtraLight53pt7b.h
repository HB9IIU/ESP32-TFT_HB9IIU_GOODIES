#ifndef _JETBRAINSMONO_EXTRALIGHT53PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0xC0, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x30, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x99, 0xF8, 0x1E, 0x18, 0x7C, 0x3C, 0x18, 0x3C, 0x38, 0x18, 0x1E,
  0x78, 0x18, 0x1E, 0x78, 0x18, 0x1E, 0x78, 0x18, 0x1E, 0x78, 0x18, 0x00,
  0x78, 0x18, 0x00, 0x38, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x3E, 0x18, 0x00,
  0x1F, 0x18, 0x00, 0x0F, 0xD8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1B, 0xF8, 0x00, 0x18, 0xF8,
  0x00, 0x18, 0x3C, 0x00, 0x18, 0x3E, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x0E,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x0F, 0xF0, 0x18, 0x0F, 0xF0, 0x18, 0x0F,
  0xF0, 0x18, 0x0E, 0x70, 0x18, 0x1E, 0x78, 0x18, 0x1E, 0x3C, 0x18, 0x3C,
  0x3F, 0x18, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x7F, 0xC0, 0x00, 0xE3, 0xFF, 0x80, 0x07, 0x1E, 0x0F, 0x00, 0x1C,
  0x70, 0x1C, 0x00, 0xE1, 0xC0, 0x70, 0x07, 0x0E, 0x01, 0xC0, 0x1C, 0x38,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x01,
  0xC0, 0xE0, 0x38, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x38, 0x01, 0xC0, 0x70,
  0xE0, 0x07, 0x83, 0x87, 0x00, 0x0F, 0xFE, 0x38, 0x00, 0x1F, 0xF0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC3, 0xFC, 0x00,
  0x07, 0x1F, 0xFC, 0x00, 0x38, 0xF8, 0xF0, 0x01, 0xC3, 0x80, 0xE0, 0x07,
  0x0E, 0x03, 0x80, 0x38, 0x38, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x01, 0xC0,
  0x38, 0x38, 0x03, 0x80, 0xE1, 0xC0, 0x0E, 0x03, 0x8E, 0x00, 0x3C, 0x1E,
  0x38, 0x00, 0x7F, 0xF1, 0xC0, 0x01, 0xFF, 0x8E, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x87, 0x80, 0x3C, 0xE0,
  0x78, 0x07, 0x3C, 0x07, 0x81, 0xE7, 0x80, 0xF0, 0x38, 0xF0, 0x0F, 0x0F,
  0x1E, 0x00, 0xF1, 0xC3, 0xC0, 0x0F, 0x78, 0x78, 0x01, 0xEE, 0x0F, 0x00,
  0x1F, 0xC1, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xFC, 0x0E, 0x00, 0x3F, 0xC1, 0xE0, 0x0F, 0x3C, 0x3E, 0x07,
  0xC7, 0x83, 0xFF, 0xF0, 0x78, 0x3F, 0xFC, 0x07, 0x83, 0xFE, 0x00, 0x78,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00,
  0xE7, 0xE0, 0xE0, 0x7E, 0xFF, 0x86, 0x1F, 0xF3, 0xFE, 0x67, 0xFC, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7C, 0x00,
  0xF1, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F,
  0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xF9, 0xC0, 0x03, 0xE3, 0x80, 0x1F, 0x87, 0x00, 0x7C, 0x0E, 0x00,
  0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x02, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0xE3, 0xC0, 0x07, 0x8F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x73, 0xC0, 0x03,
  0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x0F, 0xF8, 0x1C, 0xFF, 0xF0, 0x77, 0xFF, 0xE1, 0xDC,
  0x07, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x01, 0xE7, 0x80, 0x0F,
  0x0F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x0C, 0x00, 0x1E, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F,
  0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x3C, 0x00,
  0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x87, 0xC0, 0x1F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3E, 0x1F, 0x03,
  0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0x9F,
  0x80, 0x7C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81,
  0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x78, 0x01, 0xFC,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x0E, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x7F, 0x9F, 0x80, 0x3F,
  0xF7, 0xE0, 0x1F, 0x0F, 0xF8, 0x0F, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0x80,
  0xE0, 0x07, 0xE0, 0x38, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03, 0x80, 0x1F,
  0x80, 0xE0, 0x07, 0xE0, 0x38, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03, 0x80,
  0x1F, 0x80, 0xE0, 0x07, 0xE0, 0x38, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x03,
  0xC0, 0x3F, 0x80, 0xF0, 0x0F, 0xE0, 0x1E, 0x07, 0xF8, 0x07, 0xFF, 0x7E,
  0x00, 0xFF, 0xDF, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x1E,
  0x01, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x3C, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0x80, 0xFF, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x01, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x0E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x03, 0xE7, 0x80, 0x1F, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x3C, 0x00, 0xF9, 0xE0,
  0x01, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x7C,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3C, 0x0F, 0xF0, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C,
  0x03, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x3C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80,
  0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00,
  0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xF0, 0x07,
  0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x06, 0xF7, 0x00, 0x3B, 0xDC, 0x00, 0xFF, 0x70,
  0x03, 0x7C, 0xE0, 0x1D, 0xFB, 0x80, 0x77, 0xEE, 0x01, 0x9F, 0x9C, 0x0E,
  0x7E, 0x70, 0x39, 0xF9, 0xC0, 0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E,
  0x18, 0x61, 0xF8, 0x73, 0x87, 0xE1, 0xCE, 0x1F, 0x83, 0x30, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFE, 0xE0, 0x07, 0xF7, 0x00, 0x3F, 0x9C, 0x01, 0xFC,
  0xE0, 0x0F, 0xE7, 0x00, 0x7F, 0x1C, 0x03, 0xF8, 0xE0, 0x1F, 0xC7, 0x80,
  0xFE, 0x1C, 0x07, 0xF0, 0xE0, 0x3F, 0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0,
  0xE0, 0x7F, 0x03, 0x83, 0xF8, 0x1C, 0x1F, 0xC0, 0xF0, 0xFE, 0x03, 0x87,
  0xF0, 0x1C, 0x3F, 0x80, 0x71, 0xFC, 0x03, 0x8F, 0xE0, 0x1E, 0x7F, 0x00,
  0x73, 0xF8, 0x03, 0x9F, 0xC0, 0x1E, 0xFE, 0x00, 0x77, 0xF0, 0x03, 0xBF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE,
  0x0F, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC,
  0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00,
  0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x05, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x87, 0x80, 0x7F, 0x8F, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xF3, 0xC0, 0x0F,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3F, 0x00, 0x7C, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xCF,
  0x00, 0x3C, 0x7C, 0x03, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x0C, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x0F,
  0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x0F,
  0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0E, 0x70, 0x1F, 0x80, 0xE7, 0x01,
  0x98, 0x0E, 0x70, 0x19, 0x80, 0xE7, 0x01, 0x98, 0x0E, 0x70, 0x19, 0x80,
  0xE7, 0x01, 0x9C, 0x0E, 0x78, 0x39, 0xC1, 0xE7, 0x83, 0x9C, 0x1C, 0x38,
  0x39, 0xC1, 0xC3, 0x83, 0x0C, 0x1C, 0x38, 0x30, 0xC1, 0xC3, 0x83, 0x0C,
  0x1C, 0x38, 0x30, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0xC7, 0x0E, 0x38, 0x3C, 0x60, 0xE3, 0x81, 0xC6, 0x06, 0x38, 0x1C, 0x60,
  0x63, 0x81, 0xC6, 0x06, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x30, 0x1E, 0xC0, 0x37, 0x00, 0xEC,
  0x03, 0x70, 0x0E, 0xC0, 0x37, 0x00, 0xEC, 0x03, 0x70, 0x0F, 0xC0, 0x37,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1C, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80,
  0x70, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x78, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x1E, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x38, 0x03,
  0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x81, 0xC0, 0x0E, 0x0F, 0x00,
  0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x9C, 0x00, 0x0E,
  0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x00,
  0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3E, 0x00, 0x1D, 0xE0, 0x00,
  0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0,
  0x0D, 0xCF, 0xF3, 0xF7, 0x1F, 0xFF, 0x9C, 0x1F, 0xF8, 0x70, 0x04, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x0F, 0x1F, 0xF8, 0x3C, 0xFF, 0xF0, 0xF7, 0x87,
  0xE3, 0xF8, 0x07, 0xCF, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x3B,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0xC0,
  0x0F, 0x3F, 0x80, 0x7C, 0xF7, 0xFF, 0xE3, 0xCF, 0xFF, 0x0F, 0x1F, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9C, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x78, 0x00, 0x79,
  0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0x81, 0xC1, 0xFF, 0x8E, 0x1F, 0xFE,
  0x71, 0xF8, 0xFB, 0x9F, 0x00, 0xDD, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x70,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00,
  0x3E, 0x7C, 0x03, 0x71, 0xFF, 0xFB, 0x87, 0xFF, 0x9C, 0x1F, 0xF0, 0xE0,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE1,
  0xF8, 0x3C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x9C, 0x00, 0x0E,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x5C, 0x00, 0x0E, 0x78, 0x00, 0x79, 0xF0,
  0x01, 0xE3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF1, 0xC3,
  0xFF, 0xCE, 0x3F, 0x1F, 0x73, 0xE0, 0x1B, 0xBC, 0x00, 0x7D, 0xE0, 0x01,
  0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xE7, 0x80, 0x3F, 0x3F, 0x03, 0xB8,
  0xFF, 0xF9, 0xC3, 0xFF, 0x8E, 0x07, 0xF0, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x3C, 0x7F, 0xE1, 0xE7, 0xFF, 0x8F, 0x78,
  0x7E, 0x7F, 0x00, 0xFB, 0xF0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF7, 0x00,
  0x03, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x70, 0x01,
  0xF0, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x78,
  0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xF0, 0x1C, 0x01, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x60, 0xE7,
  0xE1, 0xFC, 0xEF, 0xF3, 0xFE, 0xF8, 0xFA, 0x1E, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xE0, 0x3C, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0x00, 0x3C, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF, 0x0F,
  0xCF, 0xE0, 0x1F, 0x7E, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x07, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0x9C, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x03, 0xC7,
  0xFE, 0x0F, 0x3F, 0xFC, 0x3D, 0xE1, 0xF8, 0xFE, 0x01, 0xF3, 0xF0, 0x03,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xF0, 0x03, 0xCF, 0xE0, 0x1F, 0x3D, 0xFF,
  0xF8, 0xF3, 0xFF, 0xC3, 0xC7, 0xFE, 0x0F, 0x01, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xF1, 0xC3, 0xFF, 0xCE, 0x3F, 0x1F, 0x73, 0xE0, 0x1B, 0xBC,
  0x00, 0x7D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00,
  0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x80, 0x6E, 0x3F, 0xFF, 0x70,
  0xFF, 0xF3, 0x83, 0xFE, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x03, 0xC7, 0xFE,
  0x0F, 0x3F, 0xFC, 0x3D, 0xE1, 0xF8, 0xFE, 0x01, 0xF3, 0xF0, 0x03, 0xEF,
  0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80,
  0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x0F, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x3C,
  0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0,
  0x07, 0x01, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0xC0,
  0x03, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0xEE, 0x01, 0xE0,
  0x1D, 0xC0, 0x3C, 0x03, 0xB8, 0x07, 0x80, 0x77, 0x01, 0xF0, 0x0E, 0xE0,
  0x37, 0x03, 0xDE, 0x06, 0x60, 0x71, 0xC0, 0xCC, 0x0E, 0x38, 0x19, 0x81,
  0xC7, 0x07, 0x30, 0x38, 0xE0, 0xE7, 0x07, 0x1C, 0x18, 0xE1, 0xE3, 0xC3,
  0x0C, 0x38, 0x38, 0x61, 0x87, 0x07, 0x0C, 0x30, 0xE0, 0xE3, 0x86, 0x1C,
  0x1C, 0x70, 0xE3, 0x83, 0x8C, 0x1C, 0x60, 0x79, 0x81, 0x9C, 0x07, 0x30,
  0x33, 0x80, 0xE6, 0x06, 0x70, 0x1D, 0xC0, 0xEE, 0x03, 0xB8, 0x1D, 0xC0,
  0x76, 0x03, 0xB0, 0x0E, 0xC0, 0x3E, 0x00, 0xD8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x9E,
  0x00, 0x07, 0x87, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x3F, 0xC0, 0x0F, 0x7F, 0xE0, 0x0F, 0x78, 0xF0, 0x0F, 0xF0, 0x78, 0x0F,
  0xE0, 0x3C, 0x0F, 0xE0, 0x1E, 0x0E, 0xE0, 0x0F, 0xFE, 0xE0, 0x07, 0xFC,
  0xE0, 0x03, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 6, 39, 32, 13, -39 },
  { 31, 15, 16, 32, 8, -39 },
  { 61, 28, 39, 32, 2, -39 },
  { 198, 24, 53, 32, 4, -46 },
  { 357, 30, 39, 32, 1, -39 },
  { 504, 27, 40, 32, 3, -39 },
  { 639, 4, 16, 32, 14, -39 },
  { 647, 16, 51, 32, 10, -45 },
  { 749, 15, 51, 32, 6, -45 },
  { 845, 28, 27, 32, 2, -32 },
  { 940, 24, 25, 32, 4, -30 },
  { 1015, 9, 16, 32, 10, -8 },
  { 1033, 17, 3, 32, 7, -19 },
  { 1040, 8, 9, 32, 12, -8 },
  { 1049, 22, 50, 32, 5, -44 },
  { 1187, 22, 40, 32, 5, -39 },
  { 1297, 23, 39, 32, 5, -39 },
  { 1410, 24, 39, 32, 4, -39 },
  { 1527, 22, 40, 32, 4, -39 },
  { 1637, 21, 39, 32, 5, -39 },
  { 1740, 22, 40, 32, 5, -39 },
  { 1850, 24, 40, 32, 4, -39 },
  { 1970, 24, 39, 32, 4, -39 },
  { 2087, 22, 40, 32, 5, -39 },
  { 2197, 24, 39, 32, 4, -39 },
  { 2314, 8, 31, 32, 12, -30 },
  { 2345, 10, 38, 32, 10, -30 },
  { 2393, 22, 27, 32, 5, -31 },
  { 2468, 22, 15, 32, 5, -25 },
  { 2510, 22, 27, 32, 5, -31 },
  { 2585, 18, 39, 32, 8, -39 },
  { 2673, 26, 48, 32, 3, -39 },
  { 2829, 26, 39, 32, 3, -39 },
  { 2956, 23, 39, 32, 5, -39 },
  { 3069, 22, 40, 32, 5, -39 },
  { 3179, 22, 39, 32, 5, -39 },
  { 3287, 21, 39, 32, 6, -39 },
  { 3390, 22, 39, 32, 6, -39 },
  { 3498, 22, 40, 32, 5, -39 },
  { 3608, 21, 39, 32, 5, -39 },
  { 3711, 20, 39, 32, 6, -39 },
  { 3809, 23, 40, 32, 3, -39 },
  { 3924, 24, 39, 32, 5, -39 },
  { 4041, 22, 39, 32, 6, -39 },
  { 4149, 22, 39, 32, 5, -39 },
  { 4257, 21, 39, 32, 5, -39 },
  { 4360, 22, 40, 32, 5, -39 },
  { 4470, 24, 39, 32, 5, -39 },
  { 4587, 22, 49, 32, 5, -39 },
  { 4722, 23, 39, 32, 5, -39 },
  { 4835, 24, 40, 32, 4, -39 },
  { 4955, 26, 39, 32, 3, -39 },
  { 5082, 21, 40, 32, 5, -39 },
  { 5187, 26, 39, 32, 3, -39 },
  { 5314, 28, 39, 32, 2, -39 },
  { 5451, 26, 39, 32, 3, -39 },
  { 5578, 27, 39, 32, 2, -39 },
  { 5710, 22, 39, 32, 5, -39 },
  { 5818, 13, 50, 32, 11, -44 },
  { 5900, 22, 50, 32, 5, -44 },
  { 6038, 12, 50, 32, 8, -44 },
  { 6113, 22, 21, 32, 5, -39 },
  { 6171, 26, 3, 32, 3, 1 },
  { 6181, 10, 8, 32, 10, -42 },
  { 6191, 22, 31, 32, 4, -30 },
  { 6277, 22, 40, 32, 5, -39 },
  { 6387, 22, 31, 32, 5, -30 },
  { 6473, 21, 40, 32, 5, -39 },
  { 6578, 22, 31, 32, 5, -30 },
  { 6664, 25, 39, 32, 3, -39 },
  { 6786, 21, 40, 32, 5, -30 },
  { 6891, 21, 39, 32, 5, -39 },
  { 6994, 24, 41, 32, 5, -41 },
  { 7117, 19, 51, 32, 5, -41 },
  { 7239, 23, 39, 32, 6, -39 },
  { 7352, 27, 39, 32, 2, -39 },
  { 7484, 24, 30, 32, 4, -30 },
  { 7574, 21, 30, 32, 5, -30 },
  { 7653, 22, 30, 32, 5, -30 },
  { 7736, 22, 40, 32, 5, -30 },
  { 7846, 21, 40, 32, 5, -30 },
  { 7951, 22, 30, 32, 6, -30 },
  { 8034, 22, 30, 32, 5, -30 },
  { 8117, 24, 37, 32, 3, -37 },
  { 8228, 21, 30, 32, 5, -29 },
  { 8307, 24, 29, 32, 4, -29 },
  { 8394, 27, 29, 32, 2, -29 },
  { 8492, 25, 29, 32, 3, -29 },
  { 8583, 24, 39, 32, 4, -29 },
  { 8700, 22, 29, 32, 5, -29 },
  { 8780, 22, 50, 32, 5, -44 },
  { 8918, 4, 50, 32, 14, -44 },
  { 8943, 22, 50, 32, 5, -44 },
  { 9081, 24, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_EXTRALIGHT53PT7B_H_
