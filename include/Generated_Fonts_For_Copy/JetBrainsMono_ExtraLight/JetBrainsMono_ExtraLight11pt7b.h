#ifndef _JETBRAINSMONO_EXTRALIGHT11PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x24, 0x97, 0xCA, 0x4B, 0xF4, 0x94, 0x21, 0x1D,
  0x5A, 0x30, 0xC5, 0xAB, 0x88, 0x40, 0x66, 0x9A, 0x94, 0x2C, 0xD5, 0x63,
  0x74, 0xA1, 0x8A, 0xDA, 0x5D, 0xE0, 0x2A, 0x49, 0x24, 0x44, 0xC4, 0x92,
  0x49, 0x38, 0x10, 0x4F, 0xC4, 0x29, 0x20, 0x21, 0x3E, 0x42, 0x00, 0x5A,
  0xE0, 0x70, 0x08, 0x84, 0x42, 0x11, 0x08, 0x84, 0x00, 0x74, 0x63, 0x5A,
  0xC6, 0x2E, 0x65, 0x08, 0x42, 0x10, 0x9F, 0x74, 0x42, 0x21, 0x11, 0x1F,
  0xF1, 0x23, 0x11, 0x97, 0x12, 0x45, 0x9F, 0x11, 0xF4, 0x21, 0xE0, 0x86,
  0x2E, 0x21, 0x11, 0xE8, 0xC6, 0x2E, 0xFC, 0x44, 0x22, 0x10, 0x88, 0x74,
  0x62, 0xE5, 0x46, 0x2E, 0x74, 0x63, 0x17, 0x08, 0x88, 0xC0, 0x70, 0xC0,
  0x5A, 0x1B, 0x20, 0xC1, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xE4,
  0x9D, 0x06, 0x74, 0x67, 0x5A, 0xD6, 0xB2, 0x83, 0x00, 0x23, 0x14, 0xA9,
  0x7A, 0x31, 0xF4, 0x63, 0xE9, 0x46, 0x3E, 0x74, 0x61, 0x08, 0x42, 0x2E,
  0xF4, 0xA3, 0x18, 0xC6, 0x5E, 0xFC, 0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21,
  0xE8, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6, 0x2E, 0x99, 0x9F, 0x99, 0x99,
  0xF2, 0x22, 0x22, 0x2F, 0x31, 0x11, 0x11, 0x9F, 0x8C, 0xA5, 0xCA, 0x4A,
  0x51, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x9C, 0xF7, 0x58, 0xC6, 0x31, 0x9D,
  0xDB, 0xBB, 0x99, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x1F, 0x42,
  0x10, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x10, 0xC0, 0xF4, 0x63, 0x2E, 0x4A,
  0x51, 0x74, 0x60, 0xC1, 0x06, 0x2E, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x99,
  0x99, 0x99, 0x97, 0x8C, 0x65, 0x25, 0x29, 0x84, 0x96, 0x57, 0x5D, 0x6D,
  0xB6, 0x92, 0x8C, 0x94, 0x42, 0x2A, 0x51, 0xC5, 0x22, 0x8C, 0x10, 0x41,
  0x04, 0xF0, 0x84, 0x44, 0x22, 0x1F, 0xF2, 0x49, 0x24, 0x9C, 0x84, 0x10,
  0x82, 0x10, 0x82, 0x10, 0xC0, 0xD5, 0x55, 0x70, 0x22, 0x95, 0x30, 0xF8,
  0x90, 0x79, 0x79, 0x9F, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74, 0x61, 0x08,
  0xB8, 0x11, 0x79, 0x99, 0x97, 0x74, 0x7F, 0x08, 0xB8, 0x3A, 0x3E, 0x84,
  0x21, 0x08, 0x79, 0x99, 0x97, 0x17, 0x88, 0xF9, 0x99, 0x99, 0x20, 0x38,
  0x42, 0x10, 0x9F, 0x10, 0xF1, 0x11, 0x11, 0x1E, 0x84, 0x23, 0x2E, 0x52,
  0x51, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x07, 0xFD, 0x6B, 0x5A, 0xD4, 0xF9,
  0x99, 0x99, 0x74, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x79,
  0x99, 0x97, 0x11, 0xF4, 0x61, 0x08, 0x40, 0xF4, 0x78, 0x20, 0xF8, 0x42,
  0x3E, 0x84, 0x21, 0x07, 0x99, 0x99, 0x97, 0x8C, 0xA4, 0xA6, 0x10, 0x95,
  0x57, 0x5B, 0x69, 0x20, 0x9A, 0x88, 0xC5, 0x44, 0x8C, 0x94, 0xA2, 0x10,
  0x88, 0xF0, 0x88, 0x84, 0x7C, 0x39, 0x08, 0x42, 0x70, 0x84, 0x21, 0xC0,
  0xFF, 0xC0, 0xC1, 0x10, 0x82, 0x1D, 0x08, 0x26, 0x00, 0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 3, 3, 7, 2, -8 },
  { 4, 6, 8, 7, 0, -8 },
  { 10, 5, 12, 7, 1, -10 },
  { 18, 6, 8, 7, 0, -8 },
  { 24, 5, 8, 7, 1, -8 },
  { 29, 1, 3, 7, 3, -8 },
  { 30, 3, 10, 7, 2, -9 },
  { 34, 3, 10, 7, 1, -9 },
  { 38, 6, 6, 7, 0, -7 },
  { 43, 5, 5, 7, 1, -6 },
  { 47, 2, 4, 7, 2, -2 },
  { 48, 3, 1, 7, 2, -4 },
  { 49, 2, 2, 7, 2, -2 },
  { 50, 5, 10, 7, 1, -9 },
  { 57, 5, 8, 7, 1, -8 },
  { 62, 5, 8, 7, 1, -8 },
  { 67, 5, 8, 7, 1, -8 },
  { 72, 4, 8, 7, 1, -8 },
  { 76, 4, 8, 7, 1, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 5, 8, 7, 1, -8 },
  { 105, 2, 6, 7, 2, -6 },
  { 107, 2, 8, 7, 2, -6 },
  { 109, 5, 5, 7, 1, -6 },
  { 113, 5, 3, 7, 1, -5 },
  { 115, 5, 5, 7, 1, -6 },
  { 119, 3, 8, 7, 2, -8 },
  { 122, 5, 10, 7, 1, -8 },
  { 129, 5, 8, 7, 1, -8 },
  { 134, 5, 8, 7, 1, -8 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 4, 8, 7, 1, -8 },
  { 168, 4, 8, 7, 1, -8 },
  { 172, 4, 8, 7, 1, -8 },
  { 176, 5, 8, 7, 1, -8 },
  { 181, 5, 8, 7, 1, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 4, 8, 7, 1, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 5, 10, 7, 1, -8 },
  { 212, 5, 8, 7, 1, -8 },
  { 217, 5, 8, 7, 1, -8 },
  { 222, 5, 8, 7, 1, -8 },
  { 227, 4, 8, 7, 1, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 6, 8, 7, 0, -8 },
  { 242, 5, 8, 7, 1, -8 },
  { 247, 6, 8, 7, 0, -8 },
  { 253, 5, 8, 7, 1, -8 },
  { 258, 3, 10, 7, 2, -9 },
  { 262, 5, 10, 7, 1, -9 },
  { 269, 2, 10, 7, 2, -9 },
  { 272, 5, 4, 7, 1, -8 },
  { 275, 5, 1, 7, 1, 0 },
  { 276, 2, 2, 7, 2, -9 },
  { 277, 4, 6, 7, 1, -6 },
  { 280, 5, 8, 7, 1, -8 },
  { 285, 5, 6, 7, 1, -6 },
  { 289, 4, 8, 7, 1, -8 },
  { 293, 5, 6, 7, 1, -6 },
  { 297, 5, 8, 7, 1, -8 },
  { 302, 4, 8, 7, 1, -6 },
  { 306, 4, 8, 7, 1, -8 },
  { 310, 5, 8, 7, 1, -8 },
  { 315, 4, 10, 7, 1, -8 },
  { 320, 5, 8, 7, 1, -8 },
  { 325, 6, 8, 7, 0, -8 },
  { 331, 5, 6, 7, 1, -6 },
  { 335, 4, 6, 7, 1, -6 },
  { 338, 5, 6, 7, 1, -6 },
  { 342, 5, 8, 7, 1, -6 },
  { 347, 4, 8, 7, 1, -6 },
  { 351, 5, 6, 7, 1, -6 },
  { 355, 5, 6, 7, 1, -6 },
  { 359, 5, 8, 7, 1, -8 },
  { 364, 4, 6, 7, 1, -6 },
  { 367, 5, 6, 7, 1, -6 },
  { 371, 6, 6, 7, 0, -6 },
  { 376, 5, 6, 7, 1, -6 },
  { 380, 5, 8, 7, 1, -6 },
  { 385, 5, 6, 7, 1, -6 },
  { 389, 5, 10, 7, 1, -9 },
  { 396, 1, 10, 7, 3, -9 },
  { 398, 5, 10, 7, 1, -9 },
  { 405, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_EXTRALIGHT11PT7B_H_
