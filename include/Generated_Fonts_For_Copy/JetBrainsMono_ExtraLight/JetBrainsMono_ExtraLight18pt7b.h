#ifndef _JETBRAINSMONO_EXTRALIGHT18PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x40, 0x6E, 0x9C, 0x63, 0x18, 0x80, 0x11, 0x08,
  0x84, 0x44, 0x2F, 0xF9, 0x10, 0x88, 0x44, 0xFF, 0xA2, 0x11, 0x08, 0x84,
  0x40, 0x08, 0x08, 0x08, 0x3E, 0x4B, 0x49, 0x48, 0x48, 0x38, 0x1E, 0x0B,
  0x09, 0x89, 0x49, 0x4B, 0x3E, 0x08, 0x08, 0x08, 0x78, 0x52, 0x2C, 0x8B,
  0x24, 0x4A, 0x0C, 0x80, 0x40, 0x2E, 0x12, 0x44, 0x92, 0x25, 0x09, 0xC3,
  0xC0, 0x3C, 0x21, 0x10, 0x88, 0x02, 0x01, 0x83, 0x43, 0x12, 0x8D, 0x43,
  0x20, 0x98, 0xA7, 0x98, 0xF8, 0x19, 0x91, 0x88, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x61, 0x04, 0x18, 0xC3, 0x04, 0x30, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x8C, 0x4C, 0xC0, 0x08, 0x04, 0x02, 0x19, 0x73, 0xE0, 0xC0, 0x50, 0x4C,
  0x63, 0x00, 0x08, 0x04, 0x02, 0x1F, 0xFF, 0xF8, 0x40, 0x20, 0x10, 0x36,
  0x64, 0x48, 0xF8, 0x5F, 0x80, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x08,
  0x10, 0x60, 0x81, 0x06, 0x08, 0x10, 0x40, 0x80, 0x7D, 0x8E, 0x0C, 0x18,
  0x32, 0x6C, 0xC1, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0x38, 0x78, 0x98, 0x98,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x3E, 0x21, 0x90,
  0x50, 0x20, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0xF8,
  0x7F, 0x02, 0x04, 0x08, 0x18, 0x1E, 0x03, 0x01, 0x01, 0x81, 0x41, 0x42,
  0x3E, 0x0C, 0x10, 0x40, 0x82, 0x0C, 0x50, 0xC1, 0x83, 0xFC, 0x08, 0x10,
  0x20, 0xFF, 0x02, 0x04, 0x09, 0x9D, 0xA0, 0x81, 0x02, 0x06, 0x0E, 0x37,
  0xC0, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x7E, 0x63, 0x41, 0xC1, 0xC1, 0x41,
  0x63, 0x3E, 0xFF, 0xE0, 0xB0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x7D, 0x0E, 0x0C, 0x1C, 0x6D, 0x8E, 0x62,
  0x83, 0x06, 0x0C, 0x37, 0xC0, 0x3E, 0x43, 0x41, 0xC1, 0xC1, 0x41, 0x63,
  0x3E, 0x06, 0x04, 0x08, 0x08, 0x10, 0xFD, 0x00, 0x00, 0xFC, 0x77, 0x20,
  0x00, 0x03, 0x66, 0x44, 0x80, 0x02, 0x0C, 0x73, 0x8C, 0x18, 0x18, 0x0C,
  0x06, 0x04, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x81, 0x81, 0x80, 0xC0,
  0x60, 0xC7, 0x38, 0xC1, 0x00, 0xF0, 0x20, 0x41, 0x04, 0x27, 0x90, 0x40,
  0x00, 0x18, 0x60, 0x3E, 0x20, 0xB0, 0x30, 0x18, 0x6C, 0x4E, 0x63, 0x21,
  0x90, 0xC8, 0x62, 0x71, 0xD8, 0x02, 0x01, 0x80, 0x78, 0x18, 0x0A, 0x05,
  0x02, 0x83, 0x41, 0x10, 0x88, 0x44, 0x7E, 0x20, 0x90, 0x58, 0x28, 0x18,
  0xFD, 0x0E, 0x0C, 0x18, 0x31, 0xBF, 0x41, 0x83, 0x06, 0x0C, 0x3F, 0xC0,
  0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x0E, 0x37, 0xC0,
  0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x2F, 0x80,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00,
  0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x27, 0xCF, 0x83, 0x06, 0x0E, 0x37, 0xC0,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0,
  0x1F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x83, 0x42,
  0x7C, 0x83, 0x82, 0x84, 0x84, 0x88, 0x88, 0xF8, 0x88, 0x8C, 0x84, 0x86,
  0x82, 0x83, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x87, 0x8F, 0x1E, 0x5A, 0xB5, 0x64, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0xC3, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC9, 0x8B, 0x16,
  0x2C, 0x38, 0x60, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0E, 0x37, 0xC0, 0xFC, 0x82, 0x83, 0x81, 0x83, 0x82, 0xFC, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0E, 0x37, 0xC1, 0x81, 0x03, 0xFC, 0x86, 0x82, 0x83, 0x82, 0x82,
  0xFC, 0x88, 0x88, 0x84, 0x84, 0x82, 0x83, 0x3E, 0x43, 0x41, 0x40, 0x40,
  0x30, 0x1E, 0x03, 0x01, 0x01, 0xC1, 0x43, 0x3E, 0xFF, 0x84, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0xC1,
  0xA0, 0x90, 0x48, 0x26, 0x21, 0x10, 0x88, 0x44, 0x34, 0x0A, 0x05, 0x02,
  0x81, 0x80, 0x88, 0xCC, 0x65, 0x32, 0x99, 0x4C, 0xAF, 0x54, 0xAA, 0x65,
  0x32, 0x98, 0xCC, 0x66, 0x30, 0xC1, 0xA0, 0x88, 0x84, 0xC1, 0x40, 0xC0,
  0x20, 0x28, 0x34, 0x11, 0x18, 0xC8, 0x28, 0x18, 0x81, 0xA0, 0x90, 0xC4,
  0x42, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFE,
  0x0C, 0x10, 0x60, 0x82, 0x04, 0x10, 0x60, 0x83, 0x04, 0x0F, 0xE0, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x03, 0x02, 0x06,
  0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x81, 0x03, 0x02, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x50, 0xA2, 0x64,
  0x50, 0xE0, 0x80, 0xFF, 0x80, 0xC3, 0x3E, 0x63, 0x41, 0x01, 0x3F, 0x61,
  0xC1, 0xC1, 0x43, 0x7D, 0x81, 0x02, 0x05, 0xEC, 0x70, 0x60, 0xC1, 0x83,
  0x06, 0x0E, 0x3B, 0xC0, 0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x20, 0x41, 0xC6,
  0xF8, 0x02, 0x04, 0x0B, 0xDC, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x37,
  0xA0, 0x7D, 0x8E, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0xC6, 0xF8, 0x0F, 0x8C,
  0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x7B, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x04, 0x08, 0x37,
  0xC0, 0x81, 0x02, 0x05, 0xEC, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0x18, 0x18, 0x00, 0x00, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x0C, 0x30, 0x00, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0xC2, 0xF0, 0x80, 0x80, 0x80, 0x83, 0x86, 0x84, 0x88, 0xF8,
  0x98, 0x88, 0x84, 0x86, 0x83, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0xF8, 0xB7, 0xC9, 0x89, 0x89,
  0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x04, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC6, 0xF8,
  0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC7, 0x7A, 0x04, 0x08, 0x00,
  0x7B, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC6, 0xF4, 0x08, 0x10, 0x20,
  0xBD, 0x8F, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x00, 0x7D, 0x8E, 0x04,
  0x07, 0x81, 0xC0, 0x81, 0x82, 0xF8, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xC6, 0xF8, 0xC1, 0xA0, 0x90, 0x4C, 0x42, 0x21, 0x10, 0xD0,
  0x28, 0x14, 0x0C, 0x00, 0x88, 0xC4, 0x65, 0x32, 0xA5, 0x52, 0xA9, 0x54,
  0xCA, 0x63, 0x31, 0x00, 0xC1, 0x31, 0x09, 0x82, 0x81, 0x80, 0xE0, 0x50,
  0x44, 0x63, 0x60, 0xC0, 0xC1, 0xA0, 0x90, 0xC4, 0x42, 0x21, 0xB0, 0x50,
  0x28, 0x08, 0x04, 0x06, 0x02, 0x03, 0x00, 0xFE, 0x0C, 0x30, 0x41, 0x06,
  0x08, 0x20, 0x81, 0xFC, 0x0E, 0x30, 0x40, 0x81, 0x83, 0x06, 0x08, 0xE0,
  0x20, 0x60, 0xC1, 0x82, 0x04, 0x0C, 0x0E, 0xFF, 0xFF, 0x80, 0xC0, 0x40,
  0xC1, 0x82, 0x04, 0x08, 0x18, 0x0E, 0x60, 0x81, 0x02, 0x06, 0x0C, 0x10,
  0xC0, 0x71, 0xC9, 0x8F,
};

const GFXglyph JetBrainsMono_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -13 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 8, 19, 11, 1, -16 },
  { 44, 10, 13, 11, 0, -13 },
  { 61, 9, 13, 11, 1, -13 },
  { 76, 1, 5, 11, 5, -13 },
  { 77, 5, 17, 11, 4, -15 },
  { 88, 5, 17, 11, 2, -15 },
  { 99, 9, 9, 11, 1, -11 },
  { 110, 9, 8, 11, 1, -10 },
  { 119, 4, 6, 11, 3, -3 },
  { 122, 5, 1, 11, 3, -6 },
  { 123, 3, 3, 11, 4, -3 },
  { 125, 7, 17, 11, 2, -15 },
  { 140, 7, 13, 11, 2, -13 },
  { 152, 8, 13, 11, 2, -13 },
  { 165, 9, 13, 11, 1, -13 },
  { 180, 8, 13, 11, 1, -13 },
  { 193, 7, 13, 11, 2, -13 },
  { 205, 7, 13, 11, 2, -13 },
  { 217, 8, 13, 11, 1, -13 },
  { 230, 9, 13, 11, 1, -13 },
  { 245, 7, 13, 11, 2, -13 },
  { 257, 8, 13, 11, 1, -13 },
  { 270, 3, 10, 11, 4, -10 },
  { 274, 4, 13, 11, 3, -10 },
  { 281, 7, 10, 11, 2, -11 },
  { 290, 7, 6, 11, 2, -9 },
  { 296, 7, 10, 11, 2, -11 },
  { 305, 6, 13, 11, 3, -13 },
  { 315, 9, 16, 11, 1, -13 },
  { 333, 9, 13, 11, 1, -13 },
  { 348, 7, 13, 11, 2, -13 },
  { 360, 7, 13, 11, 2, -13 },
  { 372, 7, 13, 11, 2, -13 },
  { 384, 7, 13, 11, 2, -13 },
  { 396, 7, 13, 11, 2, -13 },
  { 408, 7, 13, 11, 2, -13 },
  { 420, 7, 13, 11, 2, -13 },
  { 432, 7, 13, 11, 2, -13 },
  { 444, 8, 13, 11, 1, -13 },
  { 457, 8, 13, 11, 2, -13 },
  { 470, 8, 13, 11, 2, -13 },
  { 483, 7, 13, 11, 2, -13 },
  { 495, 7, 13, 11, 2, -13 },
  { 507, 7, 13, 11, 2, -13 },
  { 519, 8, 13, 11, 2, -13 },
  { 532, 7, 16, 11, 2, -13 },
  { 546, 8, 13, 11, 2, -13 },
  { 559, 8, 13, 11, 1, -13 },
  { 572, 9, 13, 11, 1, -13 },
  { 587, 7, 13, 11, 2, -13 },
  { 599, 9, 13, 11, 1, -13 },
  { 614, 9, 13, 11, 1, -13 },
  { 629, 9, 13, 11, 1, -13 },
  { 644, 9, 13, 11, 1, -13 },
  { 659, 7, 13, 11, 2, -13 },
  { 671, 4, 17, 11, 4, -15 },
  { 680, 7, 17, 11, 2, -15 },
  { 695, 4, 17, 11, 3, -15 },
  { 704, 7, 7, 11, 2, -13 },
  { 711, 9, 1, 11, 1, 0 },
  { 713, 4, 2, 11, 3, -14 },
  { 714, 8, 10, 11, 1, -10 },
  { 724, 7, 13, 11, 2, -13 },
  { 736, 7, 10, 11, 2, -10 },
  { 745, 7, 13, 11, 2, -13 },
  { 757, 7, 10, 11, 2, -10 },
  { 766, 9, 13, 11, 1, -13 },
  { 781, 7, 13, 11, 2, -10 },
  { 793, 7, 13, 11, 2, -13 },
  { 805, 8, 14, 11, 2, -14 },
  { 819, 6, 17, 11, 2, -14 },
  { 832, 8, 13, 11, 2, -13 },
  { 845, 9, 13, 11, 1, -13 },
  { 860, 8, 10, 11, 1, -10 },
  { 870, 7, 10, 11, 2, -10 },
  { 879, 7, 10, 11, 2, -10 },
  { 888, 7, 13, 11, 2, -10 },
  { 900, 7, 13, 11, 2, -10 },
  { 912, 7, 10, 11, 2, -10 },
  { 921, 7, 10, 11, 2, -10 },
  { 930, 8, 13, 11, 1, -13 },
  { 943, 7, 10, 11, 2, -10 },
  { 952, 9, 10, 11, 1, -10 },
  { 964, 9, 10, 11, 1, -10 },
  { 976, 9, 10, 11, 1, -10 },
  { 988, 9, 13, 11, 1, -10 },
  { 1003, 7, 10, 11, 2, -10 },
  { 1012, 7, 17, 11, 2, -15 },
  { 1027, 1, 17, 11, 5, -15 },
  { 1030, 7, 17, 11, 2, -15 },
  { 1045, 8, 3, 11, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_EXTRALIGHT18PT7B_H_
