#ifndef _JETBRAINSMONO_EXTRALIGHT52PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7C, 0x63, 0xE1, 0xE0, 0xC3,
  0xC3, 0xC1, 0x83, 0xCF, 0x03, 0x03, 0x9E, 0x06, 0x07, 0x3C, 0x0C, 0x0F,
  0x78, 0x18, 0x1E, 0xF0, 0x30, 0x01, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0xC1, 0x80, 0x07, 0xC3, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0x9F, 0x80, 0x03, 0x0F, 0x00, 0x06, 0x0F, 0x00, 0x0C, 0x0E, 0x00, 0x18,
  0x1E, 0x00, 0x30, 0x3C, 0x00, 0x60, 0x3F, 0x80, 0xC0, 0x7F, 0x01, 0x80,
  0xFE, 0x03, 0x03, 0xDC, 0x06, 0x07, 0xBC, 0x0C, 0x1E, 0x7C, 0x18, 0x3C,
  0x7C, 0x31, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x39,
  0xFF, 0x80, 0x03, 0x8F, 0xFE, 0x00, 0x1C, 0xE0, 0x70, 0x01, 0xC7, 0x01,
  0xC0, 0x1C, 0x70, 0x0E, 0x00, 0xC3, 0x80, 0x70, 0x0E, 0x1C, 0x03, 0x80,
  0xE0, 0xE0, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38, 0x07, 0x07, 0x01,
  0xC0, 0x38, 0x70, 0x07, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x38, 0x00, 0xFF,
  0xE3, 0x80, 0x07, 0xFE, 0x1C, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x71, 0xFF, 0x80, 0x07, 0x1F, 0xFE, 0x00,
  0x70, 0xE0, 0x70, 0x03, 0x8F, 0x03, 0xC0, 0x38, 0x70, 0x0E, 0x03, 0x83,
  0x80, 0x70, 0x18, 0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x1C, 0x07, 0x00,
  0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0xE0, 0x0E, 0x01, 0xCE,
  0x00, 0x38, 0x1C, 0x70, 0x01, 0xFF, 0xE7, 0x00, 0x07, 0xFE, 0x70, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x3C, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xE1, 0xE0, 0x0F, 0x78, 0x78, 0x03, 0xBC, 0x0F,
  0x01, 0xEF, 0x01, 0xE0, 0xF3, 0xC0, 0x3C, 0x38, 0xF0, 0x0F, 0x1E, 0x3C,
  0x01, 0xE7, 0x0F, 0x00, 0x3F, 0xC3, 0xC0, 0x07, 0xE0, 0xF0, 0x01, 0xF8,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x07, 0xE0, 0xF0, 0x01,
  0xFC, 0x1E, 0x00, 0xF7, 0x87, 0xC0, 0xF8, 0xF0, 0xFF, 0xFC, 0x1C, 0x1F,
  0xFE, 0x07, 0x83, 0xFE, 0x00, 0xF0, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x0C, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0xCF, 0x81, 0xC0,
  0x7F, 0xFC, 0x38, 0x7F, 0xBF, 0xE7, 0x3F, 0xF1, 0xFF, 0x4F, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x08, 0x00, 0x20, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x10, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0x80,
  0xFC, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x70,
  0x3F, 0x83, 0xE0, 0xFE, 0x0F, 0x83, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0x3F,
  0x81, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xEF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xC3,
  0xE0, 0x3F, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3E,
  0xE0, 0x01, 0xF9, 0xC0, 0x07, 0xC3, 0x80, 0x1F, 0x07, 0x00, 0x7C, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x02, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x78, 0x00,
  0x78, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x7F, 0x01, 0xCF,
  0xFE, 0x0E, 0xFF, 0xF8, 0x77, 0x07, 0xE3, 0xE0, 0x0F, 0x9E, 0x00, 0x3C,
  0xF0, 0x00, 0xF7, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00,
  0x73, 0xC0, 0x07, 0x8F, 0x00, 0x78, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x07, 0xE3,
  0xE0, 0x03, 0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00,
  0x0E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xF8, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x0F,
  0x3C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xC0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x07,
  0xC1, 0xF0, 0x03, 0xEF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7C, 0x7C, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0x3E, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xF8, 0x07, 0xC3, 0xC0, 0x07, 0x8F,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0xF0, 0x01, 0xF1, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xEE,
  0x00, 0xFF, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x0F, 0x83, 0xF8, 0x7F, 0x9F, 0xF1, 0xFE,
  0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0xFF, 0x9F, 0x80, 0x7F, 0xF7, 0xE0, 0x3C, 0x07, 0xF8, 0x0F, 0x00,
  0xFE, 0x03, 0x80, 0x3F, 0x80, 0xE0, 0x0F, 0xE0, 0x38, 0x03, 0xF8, 0x0E,
  0x00, 0xFE, 0x03, 0x80, 0x3F, 0x80, 0xE0, 0x0F, 0xE0, 0x38, 0x03, 0xF8,
  0x0E, 0x00, 0xFE, 0x03, 0x80, 0x3F, 0x80, 0xE0, 0x0F, 0xE0, 0x38, 0x03,
  0xF8, 0x0E, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0x80, 0xF8, 0x17, 0xE0, 0x1F,
  0xFD, 0xF8, 0x03, 0xFE, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x07, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x7F, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF1, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xE0, 0x1F, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0,
  0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x1F,
  0x3C, 0x03, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF1, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00,
  0x79, 0xF0, 0x01, 0xE3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x60, 0x03, 0xFE, 0xE0, 0x0E, 0xFD,
  0xC0, 0x1D, 0xF9, 0xC0, 0x3B, 0xF3, 0x80, 0xE7, 0xE7, 0x01, 0xCF, 0xE7,
  0x03, 0x9F, 0xCE, 0x0E, 0x3F, 0x9C, 0x1C, 0x7F, 0x1C, 0x30, 0xFE, 0x38,
  0xE3, 0xFC, 0x71, 0xC7, 0xF8, 0x73, 0x0F, 0xF0, 0xEE, 0x1F, 0xE0, 0xDC,
  0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7E, 0xE0, 0x03,
  0xF7, 0x00, 0x1F, 0xB8, 0x00, 0xFE, 0xE0, 0x07, 0xF7, 0x00, 0x3F, 0xBC,
  0x01, 0xFC, 0xE0, 0x0F, 0xE7, 0x00, 0x7F, 0x1C, 0x03, 0xF8, 0xE0, 0x1F,
  0xC7, 0x00, 0xFE, 0x1C, 0x07, 0xF0, 0xE0, 0x3F, 0x87, 0x81, 0xFC, 0x1C,
  0x0F, 0xE0, 0xE0, 0x7F, 0x03, 0x83, 0xF8, 0x1C, 0x1F, 0xC0, 0xF0, 0xFE,
  0x03, 0x87, 0xF0, 0x1C, 0x3F, 0x80, 0x71, 0xFC, 0x03, 0x8F, 0xE0, 0x1C,
  0x7F, 0x00, 0x73, 0xF8, 0x03, 0x9F, 0xC0, 0x1E, 0xFE, 0x00, 0x77, 0xF0,
  0x03, 0xBF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C,
  0x07, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xEE, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x80, 0x78, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0x80, 0x1F, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0,
  0x01, 0xF3, 0xC0, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x78,
  0x00, 0xF1, 0xE0, 0x01, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x03, 0xC3, 0xE0, 0x1E,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x06, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x80, 0x1F, 0x8F, 0x00, 0x0F,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDE,
  0x00, 0x03, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0,
  0x03, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x07, 0xC3,
  0xC0, 0x07, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF8,
  0x00, 0x78, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0xF0,
  0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x0F,
  0x00, 0xFC, 0x01, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xB0, 0x0F, 0xE0, 0x36, 0x01, 0xDC, 0x06, 0xE0, 0x3B, 0x80, 0xDC,
  0x0F, 0x70, 0x1B, 0x81, 0xCE, 0x07, 0x30, 0x39, 0xC0, 0xE6, 0x07, 0x38,
  0x1C, 0xC0, 0xE7, 0x03, 0x18, 0x1C, 0xF0, 0x63, 0x03, 0x8E, 0x0C, 0x70,
  0x71, 0xC1, 0x8E, 0x0E, 0x38, 0x31, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x87,
  0x0F, 0x18, 0x38, 0xE0, 0xE3, 0x07, 0x1C, 0x1C, 0xE0, 0xE3, 0x03, 0x9C,
  0x0C, 0xE0, 0x73, 0x01, 0x9C, 0x0E, 0x60, 0x33, 0x81, 0xCC, 0x06, 0x70,
  0x39, 0x80, 0xCE, 0x07, 0xB0, 0x1D, 0xC0, 0x7E, 0x03, 0xB8, 0x0F, 0xC0,
  0x36, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0,
  0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x38, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0E,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0xE0, 0x1C, 0x07,
  0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xF3, 0xC0, 0x03, 0x9C, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xE0, 0x7C, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0x80, 0x03,
  0xDE, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xE0,
  0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78,
  0x00, 0x5D, 0xF0, 0x07, 0x73, 0xF8, 0xF9, 0xC7, 0xFF, 0xC7, 0x0F, 0xFE,
  0x1C, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x87, 0xF0, 0x3C, 0xFF, 0xE1, 0xEF, 0xFF, 0x8F,
  0xE0, 0x3E, 0x7E, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x77, 0xE0, 0x07, 0xBF, 0x80, 0x79,
  0xEF, 0x9F, 0xCF, 0x3F, 0xFC, 0x78, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x07, 0xC3, 0xC0, 0x0F,
  0x3C, 0x00, 0x3D, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0xF1, 0xF0, 0x0F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0xC3, 0xC3, 0xFF, 0x9E, 0x3F,
  0xFE, 0xF3, 0xE0, 0x3F, 0xBE, 0x00, 0xFD, 0xE0, 0x03, 0xEE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xCF,
  0x00, 0xFE, 0x7F, 0xBE, 0xF1, 0xFF, 0xE7, 0x83, 0xFE, 0x3C, 0x03, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xC3,
  0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x87, 0xF7, 0xF8,
  0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xF3, 0xC7, 0xFF, 0xDE, 0x7C, 0x07,
  0xF7, 0xC0, 0x1F, 0xBC, 0x00, 0x7D, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xBC, 0x00, 0x7D,
  0xF0, 0x07, 0xE7, 0xC0, 0xFF, 0x1F, 0xFF, 0x78, 0x7F, 0xF3, 0xC0, 0xFE,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xF0, 0x3C, 0xFF, 0xE1, 0xEF,
  0xFF, 0x8F, 0xF0, 0x3E, 0x7E, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x3E, 0xE0,
  0x00, 0xF3, 0x80, 0x07, 0x8E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x07,
  0x83, 0x80, 0x3C, 0x0E, 0x01, 0xF0, 0x38, 0x07, 0x80, 0xE0, 0x3C, 0x03,
  0x81, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0x80,
  0xF0, 0x0E, 0x03, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0x3E,
  0x0E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0x8E,
  0x00, 0x0F, 0x38, 0x00, 0x3E, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xF0, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0xE7, 0xC1, 0xF1, 0xDF, 0xE7, 0xFB, 0xFF, 0xDF, 0xF7,
  0x83, 0xE0, 0xFF, 0x03, 0xC0, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0,
  0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01,
  0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C,
  0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0,
  0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07,
  0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E,
  0x03, 0x80, 0xE0, 0xF0, 0xFE, 0x07, 0x9F, 0xFC, 0x3D, 0xFF, 0xF1, 0xEE,
  0x07, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x07, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x78,
  0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xF0, 0xFE, 0x07, 0x9F, 0xFC, 0x3D, 0xFF, 0xF1, 0xFE, 0x07, 0xCF,
  0xC0, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0E, 0xFC, 0x00, 0xF7, 0xF0, 0x0F, 0x3D, 0xF3, 0xF9,
  0xE7, 0xFF, 0x8F, 0x1F, 0xF0, 0x78, 0x08, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xF3, 0xC7, 0xFF,
  0xDE, 0x7C, 0x07, 0xF7, 0xC0, 0x1F, 0xBC, 0x00, 0x7D, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xF9, 0xE0,
  0x1F, 0xC7, 0xF7, 0xDE, 0x1F, 0xFC, 0xF0, 0x7F, 0xC7, 0x80, 0x60, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xF0, 0xFE, 0x07,
  0x9F, 0xFC, 0x3D, 0xFF, 0xF1, 0xFC, 0x07, 0xCF, 0xC0, 0x1F, 0x7C, 0x00,
  0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x80,
  0x7C, 0x78, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x79, 0xF0,
  0x03, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFE, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0,
  0x01, 0xCF, 0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x1F, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x78,
  0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x1C,
  0x00, 0x78, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC7, 0x80, 0x01,
  0xC7, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xE0,
  0x0E, 0x00, 0xFE, 0x01, 0xE0, 0x1D, 0xC0, 0x3C, 0x03, 0xB8, 0x0F, 0x80,
  0xE7, 0x01, 0xB0, 0x1C, 0xE0, 0x36, 0x03, 0x9C, 0x06, 0xC0, 0x73, 0xC0,
  0xDC, 0x0E, 0x38, 0x39, 0x81, 0xC7, 0x07, 0x30, 0x70, 0xE0, 0xC6, 0x0E,
  0x1C, 0x18, 0xC1, 0xC3, 0x83, 0x18, 0x38, 0x78, 0x63, 0x87, 0x07, 0x1C,
  0x30, 0xE0, 0xE3, 0x86, 0x38, 0x1C, 0x60, 0xC7, 0x03, 0x8C, 0x18, 0xE0,
  0x71, 0x83, 0x9C, 0x0E, 0x70, 0x73, 0x80, 0xEE, 0x06, 0x70, 0x1D, 0x80,
  0xDC, 0x03, 0xB0, 0x1B, 0x80, 0x76, 0x03, 0x70, 0x0E, 0xC0, 0x7E, 0x01,
  0xD8, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0,
  0x07, 0x80, 0xF0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x07,
  0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1E,
  0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07,
  0x01, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0E, 0xFF,
  0xC0, 0x1D, 0xFF, 0xC0, 0x3F, 0x87, 0xC0, 0x7E, 0x07, 0x80, 0xFC, 0x07,
  0x81, 0xF8, 0x07, 0xC7, 0xF0, 0x07, 0xFE, 0xE0, 0x07, 0xF9, 0xC0, 0x01,
  0x80,
};

const GFXglyph JetBrainsMono_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 38, 31, 12, -38 },
  { 35, 15, 16, 31, 8, -38 },
  { 65, 27, 38, 31, 2, -38 },
  { 194, 23, 52, 31, 4, -45 },
  { 344, 29, 38, 31, 1, -38 },
  { 482, 26, 39, 31, 3, -38 },
  { 609, 5, 16, 31, 13, -38 },
  { 619, 15, 50, 31, 10, -44 },
  { 713, 15, 50, 31, 6, -44 },
  { 807, 27, 27, 31, 2, -32 },
  { 899, 24, 24, 31, 4, -29 },
  { 971, 10, 16, 31, 9, -8 },
  { 991, 17, 3, 31, 7, -19 },
  { 998, 8, 9, 31, 12, -8 },
  { 1007, 22, 49, 31, 5, -43 },
  { 1142, 22, 39, 31, 5, -38 },
  { 1250, 23, 38, 31, 5, -38 },
  { 1360, 23, 38, 31, 4, -38 },
  { 1470, 22, 39, 31, 4, -38 },
  { 1578, 21, 38, 31, 5, -38 },
  { 1678, 21, 39, 31, 5, -38 },
  { 1781, 23, 39, 31, 4, -38 },
  { 1894, 24, 38, 31, 4, -38 },
  { 2008, 23, 39, 31, 4, -38 },
  { 2121, 23, 38, 31, 4, -38 },
  { 2231, 8, 30, 31, 12, -29 },
  { 2261, 11, 37, 31, 9, -29 },
  { 2312, 22, 26, 31, 5, -30 },
  { 2384, 21, 15, 31, 5, -25 },
  { 2424, 22, 26, 31, 5, -30 },
  { 2496, 18, 38, 31, 8, -38 },
  { 2582, 26, 47, 31, 3, -38 },
  { 2735, 25, 38, 31, 3, -38 },
  { 2854, 22, 38, 31, 5, -38 },
  { 2959, 22, 39, 31, 5, -38 },
  { 3067, 21, 38, 31, 5, -38 },
  { 3167, 21, 38, 31, 6, -38 },
  { 3267, 21, 38, 31, 6, -38 },
  { 3367, 22, 39, 31, 5, -38 },
  { 3475, 21, 38, 31, 5, -38 },
  { 3575, 19, 38, 31, 6, -38 },
  { 3666, 22, 39, 31, 3, -38 },
  { 3774, 24, 38, 31, 5, -38 },
  { 3888, 22, 38, 31, 6, -38 },
  { 3993, 23, 38, 31, 4, -38 },
  { 4103, 21, 38, 31, 5, -38 },
  { 4203, 21, 39, 31, 5, -38 },
  { 4306, 23, 38, 31, 5, -38 },
  { 4416, 22, 47, 31, 5, -38 },
  { 4546, 23, 38, 31, 5, -38 },
  { 4656, 23, 39, 31, 4, -38 },
  { 4769, 25, 38, 31, 3, -38 },
  { 4888, 21, 39, 31, 5, -38 },
  { 4991, 25, 38, 31, 3, -38 },
  { 5110, 27, 38, 31, 2, -38 },
  { 5239, 27, 38, 31, 2, -38 },
  { 5368, 27, 38, 31, 2, -38 },
  { 5497, 22, 38, 31, 5, -38 },
  { 5602, 12, 49, 31, 11, -43 },
  { 5676, 22, 49, 31, 5, -43 },
  { 5811, 12, 49, 31, 8, -43 },
  { 5885, 21, 20, 31, 5, -38 },
  { 5938, 25, 3, 31, 3, 1 },
  { 5948, 10, 7, 31, 10, -41 },
  { 5957, 22, 30, 31, 4, -29 },
  { 6040, 21, 39, 31, 5, -38 },
  { 6143, 21, 30, 31, 5, -29 },
  { 6222, 21, 39, 31, 5, -38 },
  { 6325, 21, 30, 31, 5, -29 },
  { 6404, 24, 38, 31, 3, -38 },
  { 6518, 21, 38, 31, 5, -29 },
  { 6618, 21, 38, 31, 5, -38 },
  { 6718, 23, 40, 31, 5, -40 },
  { 6833, 19, 49, 31, 5, -40 },
  { 6950, 22, 38, 31, 6, -38 },
  { 7055, 26, 38, 31, 2, -38 },
  { 7179, 23, 29, 31, 4, -29 },
  { 7263, 21, 29, 31, 5, -29 },
  { 7340, 21, 29, 31, 5, -29 },
  { 7417, 21, 38, 31, 5, -29 },
  { 7517, 21, 38, 31, 5, -29 },
  { 7617, 21, 29, 31, 6, -29 },
  { 7694, 22, 29, 31, 5, -29 },
  { 7774, 24, 37, 31, 3, -37 },
  { 7885, 21, 30, 31, 5, -29 },
  { 7964, 24, 29, 31, 4, -29 },
  { 8051, 27, 29, 31, 2, -29 },
  { 8149, 25, 29, 31, 3, -29 },
  { 8240, 24, 38, 31, 4, -29 },
  { 8354, 21, 29, 31, 5, -29 },
  { 8431, 21, 49, 31, 5, -43 },
  { 8560, 3, 49, 31, 14, -43 },
  { 8579, 21, 49, 31, 5, -43 },
  { 8708, 23, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_EXTRALIGHT52PT7B_H_
