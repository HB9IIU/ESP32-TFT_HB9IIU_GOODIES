#ifndef _JETBRAINSMONO_EXTRALIGHT25PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB4, 0x92, 0x49, 0x24, 0x02, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x0C, 0x30, 0x61, 0x03, 0x08, 0x10, 0x40, 0x82, 0x3F,
  0xFC, 0x61, 0x83, 0x08, 0x10, 0x40, 0x82, 0x04, 0x30, 0x61, 0x8F, 0xFF,
  0x10, 0x40, 0x82, 0x04, 0x30, 0x61, 0x83, 0x08, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x03, 0xF8, 0xC9, 0x99, 0x12, 0x23, 0xC4, 0x08, 0x81, 0x90,
  0x1E, 0x01, 0xF0, 0x0F, 0x01, 0x30, 0x23, 0x04, 0x78, 0x8F, 0x11, 0xE2,
  0x37, 0x5C, 0x7F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x3C, 0x06, 0xCC,
  0x11, 0x08, 0x62, 0x10, 0x84, 0x22, 0x08, 0x4C, 0x19, 0xB0, 0x1E, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x09, 0xE0, 0x26, 0x60, 0xC8, 0x41, 0x10, 0x84,
  0x21, 0x18, 0x42, 0x60, 0xCD, 0x80, 0xF0, 0x04, 0x03, 0xF0, 0x61, 0x86,
  0x08, 0x40, 0x86, 0x00, 0x60, 0x03, 0x00, 0x30, 0x0F, 0x80, 0xCC, 0x38,
  0x66, 0x86, 0x48, 0x3C, 0x81, 0x88, 0x18, 0x83, 0xCC, 0x66, 0x7C, 0x30,
  0xFF, 0x54, 0x02, 0x1C, 0x61, 0x86, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x03, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xC0, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x30, 0x61, 0x86, 0x38, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x81, 0x04, 0x1E, 0x23, 0xBD, 0x78, 0x3C, 0x00, 0xA0, 0x0D, 0x80, 0xC6,
  0x06, 0x30, 0x60, 0xC1, 0x04, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x39,
  0xCC, 0x66, 0x31, 0x98, 0xFF, 0x80, 0x5F, 0xF0, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x04, 0x07, 0xF1, 0xC7, 0x30, 0x6C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC4, 0x79, 0xCF, 0x39, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x60, 0xCE, 0x38, 0xFE, 0x00, 0x0E, 0x03, 0xC1, 0xD8,
  0x23, 0x08, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x04, 0x07, 0xF1,
  0x83, 0x60, 0x2C, 0x07, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x3E, 0x01, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x70, 0x1C, 0x07, 0x03, 0x71, 0x8F, 0xC0, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x41, 0x30, 0x58, 0x16,
  0x07, 0x01, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7F, 0xC8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x13, 0xC2, 0xDE, 0x60, 0xC8, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xF0, 0x13, 0x06, 0x71, 0xC7, 0xE0, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x7C, 0x71, 0xDC,
  0x1B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1B, 0x06, 0x71, 0xC3, 0xE0,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x2C, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x04, 0x07, 0xF1, 0x83, 0x30, 0x24, 0x06, 0x80, 0xD8, 0x13, 0x06,
  0x3B, 0x81, 0xC0, 0xEE, 0x30, 0x64, 0x05, 0x80, 0xF0, 0x1E, 0x03, 0x40,
  0x4E, 0x38, 0xFE, 0x00, 0x04, 0x07, 0xF1, 0x83, 0x20, 0x2C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x6C, 0x19, 0xFF, 0x0F, 0x40, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0x72, 0x00, 0x00, 0x00, 0x77, 0x66, 0xCC, 0xC8, 0x00, 0x20,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x08, 0x00, 0xFC, 0x0E, 0x03, 0x01,
  0x01, 0x01, 0x03, 0x03, 0x1E, 0x3C, 0x20, 0x20, 0x20, 0x00, 0x00, 0x20,
  0x70, 0x70, 0x02, 0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x01, 0x20, 0x0F,
  0x00, 0x78, 0x7B, 0xC7, 0x3E, 0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3,
  0x0F, 0x18, 0x78, 0xC3, 0xC3, 0xFE, 0x04, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x0E, 0x01, 0x40, 0x28, 0x0D, 0x81, 0xB0, 0x22,
  0x04, 0x41, 0x8C, 0x31, 0x84, 0x10, 0x82, 0x3F, 0xE7, 0xFC, 0x80, 0xB0,
  0x1E, 0x03, 0xC0, 0x70, 0x04, 0xFF, 0x20, 0xE8, 0x1A, 0x03, 0x80, 0xE0,
  0x38, 0x1A, 0x0E, 0xFE, 0x20, 0xE8, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x06, 0xFF, 0xBF, 0x80, 0x04, 0x07, 0xF1, 0xC3, 0x30, 0x24, 0x07, 0x80,
  0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x1A, 0x03, 0x60, 0xC6, 0x38, 0x7E, 0x00, 0xFE, 0x21, 0xC8, 0x1A, 0x02,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x28, 0x1A, 0x06, 0xFF, 0x3F, 0x80, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xBF, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x00, 0x04, 0x07, 0xF1, 0xC3, 0x30, 0x24, 0x07, 0x80,
  0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x1F, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1A, 0x03, 0x60, 0xC6, 0x38, 0x7E, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x06, 0x80, 0xD0, 0x1B, 0x03, 0x31,
  0xC3, 0xF0, 0x80, 0xD0, 0x1A, 0x06, 0x40, 0xC8, 0x31, 0x06, 0x21, 0x84,
  0x30, 0xFC, 0x10, 0xC2, 0x18, 0x41, 0x88, 0x31, 0x03, 0x20, 0x64, 0x04,
  0x80, 0xD0, 0x0C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0xF0, 0xE0, 0xF4, 0x17, 0x83, 0xF8, 0xFD, 0x17, 0xA2, 0xF6, 0xDE,
  0x53, 0xCA, 0x78, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0C, 0xC0, 0xE0, 0x78, 0x34, 0x1B, 0x0D, 0x86, 0x43, 0x31,
  0x88, 0xC6, 0x63, 0x30, 0x98, 0x6C, 0x16, 0x0B, 0x07, 0x81, 0xC0, 0xC0,
  0x04, 0x07, 0xF1, 0x87, 0x30, 0x64, 0x05, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1A, 0x02, 0x60, 0xCE,
  0x38, 0x7C, 0x00, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0,
  0x14, 0x06, 0x83, 0x9F, 0xE2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x04, 0x07, 0xF1, 0xC7, 0x30, 0x6C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1A, 0x02, 0x60, 0xCE, 0x38, 0x7C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0xFF, 0x20, 0xE8, 0x0E, 0x03, 0x80, 0x60, 0x38, 0x0E, 0x07, 0xFF,
  0xBF, 0x88, 0x62, 0x18, 0x83, 0x20, 0xC8, 0x1A, 0x06, 0x80, 0xE0, 0x30,
  0x04, 0x07, 0xF1, 0x83, 0x20, 0x24, 0x07, 0x80, 0x10, 0x03, 0x00, 0x38,
  0x03, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x6E,
  0x38, 0xFE, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x83, 0x63, 0x1F, 0x00, 0x80, 0x38, 0x0F, 0x01, 0xA0, 0x24,
  0x04, 0xC1, 0x98, 0x31, 0x04, 0x30, 0x86, 0x30, 0xC6, 0x08, 0x81, 0xB0,
  0x36, 0x06, 0xC0, 0x50, 0x0A, 0x01, 0xC0, 0xC3, 0x0E, 0x38, 0xF1, 0x47,
  0x8A, 0x3C, 0x51, 0xA2, 0x89, 0x14, 0x48, 0xB2, 0x4C, 0x93, 0x44, 0x9A,
  0x2C, 0xD1, 0x66, 0x8B, 0x14, 0x50, 0xA2, 0x87, 0x1C, 0x30, 0x61, 0x83,
  0x00, 0x60, 0x31, 0x01, 0x0C, 0x18, 0x20, 0x81, 0x8C, 0x06, 0x40, 0x36,
  0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x01, 0x8C, 0x0C, 0x60,
  0xC1, 0x84, 0x04, 0x60, 0x36, 0x00, 0xC0, 0xC0, 0x1B, 0x01, 0x98, 0x0C,
  0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x01, 0xB0, 0x0D, 0x80, 0x38, 0x01,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xFF, 0xC0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x0E,
  0x01, 0x40, 0x6C, 0x0D, 0x81, 0x10, 0x63, 0x08, 0x23, 0x06, 0x40, 0x58,
  0x0C, 0xFF, 0xF8, 0xC6, 0x23, 0x1F, 0x0E, 0xE6, 0x0D, 0x01, 0x00, 0x40,
  0x13, 0xFD, 0xC1, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x61, 0x4F, 0xD0, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x9E, 0x2D, 0xCC, 0x1A, 0x02, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0B, 0x06, 0xA3, 0xAF, 0xC0, 0x1F, 0x07,
  0xF1, 0x83, 0x20, 0x3C, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0D,
  0x01, 0xB0, 0x67, 0x1C, 0x3F, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x1E,
  0x4E, 0xD6, 0x0D, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14,
  0x05, 0x83, 0x71, 0x4F, 0xD0, 0x1F, 0x07, 0x71, 0x83, 0x20, 0x2C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x01, 0x00, 0xB0, 0x67, 0x1C, 0x3E,
  0x00, 0x07, 0xE1, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x3F, 0xF8, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x1E, 0x4E, 0xD6, 0x0D, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x50, 0x16, 0x0C, 0xED, 0x1E, 0x40, 0x10, 0x04, 0x01, 0x00, 0xCF,
  0xE3, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x09, 0xE5, 0xBB, 0x07, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x0E,
  0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xC0, 0x40, 0x00, 0x03, 0xFD, 0xFE,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x1B, 0xF9, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x0D, 0x01, 0xA0, 0x64, 0x18, 0x86, 0x10, 0xC3, 0xF0, 0x7E, 0x08,
  0x61, 0x06, 0x20, 0xC4, 0x0C, 0x80, 0xD0, 0x1C, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xF8,
  0x1F, 0xC0, 0xB9, 0xD9, 0xCF, 0x19, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x40, 0x9E, 0x5B,
  0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x04, 0x1F, 0x07, 0x71, 0x83, 0x20, 0x2C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0D, 0x01, 0x30, 0x67, 0x1C, 0x3E, 0x00, 0x9E, 0x2D,
  0xCC, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0B,
  0x06, 0xA3, 0xAF, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1E, 0x4E,
  0xD6, 0x0D, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x05,
  0x83, 0x71, 0x4F, 0xD0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0xDF, 0x3C,
  0xEC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x1F, 0x8F, 0xF9, 0x81, 0x20, 0x14, 0x00, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x37, 0x0C, 0x7F, 0x00,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xFF, 0xFF, 0xC2, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xE0,
  0xFC, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x36, 0x31, 0xF0, 0x80, 0x38, 0x0F, 0x01, 0xA0, 0x26, 0x0C,
  0xC1, 0x8C, 0x21, 0x8C, 0x11, 0x02, 0x20, 0x6C, 0x05, 0x00, 0xA0, 0x1C,
  0x00, 0xC2, 0x1E, 0x38, 0xF1, 0x46, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x94,
  0xCD, 0xB6, 0x68, 0xB1, 0x45, 0x0A, 0x28, 0x51, 0x42, 0x8A, 0x18, 0x30,
  0xC0, 0x6C, 0x19, 0x83, 0x18, 0xC1, 0xB0, 0x16, 0x03, 0x80, 0x70, 0x1B,
  0x03, 0x60, 0xC6, 0x30, 0x66, 0x0D, 0x80, 0xC0, 0xC0, 0x78, 0x0D, 0x01,
  0x30, 0x66, 0x0C, 0x61, 0x0C, 0x60, 0x8C, 0x19, 0x03, 0x60, 0x28, 0x07,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x00, 0x7F,
  0xCF, 0xF8, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x7C, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x7E, 0x0F,
  0xC0, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0x03, 0xF0,
  0x7E, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x3E, 0x07, 0x00, 0x78, 0x39, 0x86, 0x19, 0xC1, 0xF8, 0x08,
};

const GFXglyph JetBrainsMono_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 7, 15, 4, -18 },
  { 15, 13, 18, 15, 1, -18 },
  { 45, 11, 26, 15, 2, -22 },
  { 81, 15, 18, 15, 0, -18 },
  { 115, 12, 19, 15, 2, -19 },
  { 144, 2, 7, 15, 6, -18 },
  { 146, 7, 24, 15, 5, -21 },
  { 167, 7, 24, 15, 3, -21 },
  { 188, 13, 13, 15, 1, -15 },
  { 210, 11, 12, 15, 2, -14 },
  { 227, 5, 8, 15, 4, -4 },
  { 232, 9, 1, 15, 3, -9 },
  { 234, 3, 4, 15, 6, -4 },
  { 236, 11, 24, 15, 2, -21 },
  { 269, 11, 19, 15, 2, -19 },
  { 296, 11, 18, 15, 2, -18 },
  { 321, 11, 19, 15, 2, -19 },
  { 348, 10, 18, 15, 2, -18 },
  { 371, 10, 18, 15, 2, -18 },
  { 394, 11, 18, 15, 2, -18 },
  { 419, 11, 18, 15, 2, -18 },
  { 444, 11, 18, 15, 2, -18 },
  { 469, 11, 19, 15, 2, -19 },
  { 496, 11, 19, 15, 2, -19 },
  { 523, 3, 14, 15, 6, -14 },
  { 529, 4, 18, 15, 5, -14 },
  { 538, 11, 13, 15, 2, -15 },
  { 556, 11, 7, 15, 2, -12 },
  { 566, 11, 13, 15, 2, -15 },
  { 584, 8, 18, 15, 4, -18 },
  { 602, 13, 23, 15, 1, -19 },
  { 640, 11, 18, 15, 2, -18 },
  { 665, 10, 18, 15, 3, -18 },
  { 688, 11, 19, 15, 2, -19 },
  { 715, 10, 18, 15, 3, -18 },
  { 738, 10, 18, 15, 3, -18 },
  { 761, 10, 18, 15, 3, -18 },
  { 784, 11, 19, 15, 2, -19 },
  { 811, 9, 18, 15, 3, -18 },
  { 832, 9, 18, 15, 3, -18 },
  { 853, 11, 18, 15, 1, -18 },
  { 878, 11, 18, 15, 3, -18 },
  { 903, 10, 18, 15, 3, -18 },
  { 926, 11, 18, 15, 2, -18 },
  { 951, 9, 18, 15, 3, -18 },
  { 972, 11, 19, 15, 2, -19 },
  { 999, 11, 18, 15, 3, -18 },
  { 1024, 11, 24, 15, 2, -19 },
  { 1057, 10, 18, 15, 3, -18 },
  { 1080, 11, 19, 15, 2, -19 },
  { 1107, 13, 18, 15, 1, -18 },
  { 1137, 9, 18, 15, 3, -18 },
  { 1158, 11, 18, 15, 2, -18 },
  { 1183, 13, 18, 15, 1, -18 },
  { 1213, 13, 18, 15, 1, -18 },
  { 1243, 13, 18, 15, 1, -18 },
  { 1273, 11, 18, 15, 2, -18 },
  { 1298, 6, 24, 15, 5, -21 },
  { 1316, 11, 24, 15, 2, -21 },
  { 1349, 6, 24, 15, 4, -21 },
  { 1367, 11, 10, 15, 2, -18 },
  { 1381, 13, 1, 15, 1, 1 },
  { 1383, 4, 4, 15, 5, -20 },
  { 1385, 10, 14, 15, 2, -14 },
  { 1403, 10, 18, 15, 3, -18 },
  { 1426, 11, 14, 15, 2, -14 },
  { 1446, 10, 18, 15, 2, -18 },
  { 1469, 11, 14, 15, 2, -14 },
  { 1489, 11, 18, 15, 2, -18 },
  { 1514, 10, 19, 15, 2, -14 },
  { 1538, 9, 18, 15, 3, -18 },
  { 1559, 12, 19, 15, 2, -19 },
  { 1588, 9, 24, 15, 2, -19 },
  { 1615, 11, 18, 15, 3, -18 },
  { 1640, 13, 18, 15, 1, -18 },
  { 1670, 11, 14, 15, 2, -14 },
  { 1690, 9, 14, 15, 3, -14 },
  { 1706, 11, 14, 15, 2, -14 },
  { 1726, 10, 19, 15, 3, -14 },
  { 1750, 10, 19, 15, 2, -14 },
  { 1774, 10, 14, 15, 3, -14 },
  { 1792, 11, 14, 15, 2, -14 },
  { 1812, 11, 18, 15, 2, -18 },
  { 1837, 9, 14, 15, 3, -14 },
  { 1853, 11, 14, 15, 2, -14 },
  { 1873, 13, 14, 15, 1, -14 },
  { 1896, 11, 14, 15, 2, -14 },
  { 1916, 11, 19, 15, 2, -14 },
  { 1943, 11, 14, 15, 2, -14 },
  { 1963, 11, 24, 15, 2, -21 },
  { 1996, 1, 24, 15, 7, -21 },
  { 1999, 11, 24, 15, 2, -21 },
  { 2032, 11, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_EXTRALIGHT25PT7B_H_
