#ifndef _JETBRAINSMONO_EXTRALIGHT14PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x54, 0x70, 0x99, 0x99, 0x12, 0x12, 0x12, 0x6F, 0x24, 0x24,
  0xFE, 0x24, 0x44, 0x48, 0x10, 0x47, 0xA5, 0x91, 0x47, 0x07, 0x16, 0x59,
  0x5E, 0x10, 0x40, 0x71, 0x92, 0x94, 0x54, 0x28, 0x16, 0x19, 0x29, 0x49,
  0x87, 0x78, 0x91, 0x02, 0x06, 0x12, 0xE5, 0x44, 0x8D, 0xE4, 0xF0, 0x16,
  0x48, 0x88, 0x88, 0x88, 0x84, 0x61, 0x84, 0x22, 0x11, 0x11, 0x11, 0x22,
  0xC8, 0x10, 0x20, 0x47, 0xF1, 0x05, 0x12, 0x22, 0x10, 0x41, 0x3F, 0x10,
  0x41, 0x00, 0xEA, 0xF0, 0xF0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x42, 0x00, 0x7A, 0x18, 0x61, 0xB6, 0x58, 0x61, 0xC5, 0xE0,
  0x31, 0x49, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x7A, 0x18, 0x41, 0x04,
  0x21, 0x08, 0x43, 0xF0, 0x7C, 0x21, 0x0C, 0x08, 0x10, 0x61, 0x85, 0xE0,
  0x08, 0x41, 0x08, 0x45, 0x18, 0x7F, 0x04, 0x10, 0x7D, 0x04, 0x2E, 0x4C,
  0x10, 0x41, 0x85, 0xE0, 0x18, 0xC2, 0x10, 0x7A, 0x18, 0x61, 0x85, 0xE0,
  0xFE, 0x18, 0x42, 0x08, 0x21, 0x04, 0x20, 0x80, 0x7A, 0x18, 0x51, 0x39,
  0x28, 0x61, 0x85, 0xE0, 0x7A, 0x18, 0x61, 0xC5, 0xF0, 0x84, 0x10, 0x80,
  0xF0, 0x0F, 0xF0, 0x0E, 0xA0, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC,
  0x00, 0x3F, 0xC0, 0xC0, 0x81, 0x19, 0x88, 0x00, 0xF0, 0x42, 0x11, 0x31,
  0x00, 0x43, 0x00, 0x7D, 0x0A, 0x0C, 0xFA, 0x34, 0x68, 0xD1, 0x9F, 0x02,
  0x03, 0x01, 0x80, 0x30, 0x60, 0xA1, 0x44, 0x89, 0x1F, 0x42, 0x85, 0x0C,
  0xFA, 0x18, 0x61, 0xFA, 0x18, 0x61, 0x87, 0xE0, 0x7A, 0x18, 0x60, 0x82,
  0x08, 0x21, 0x45, 0xE0, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x87, 0xE0,
  0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xFE, 0x08, 0x20, 0xFE, 0x08,
  0x20, 0x82, 0x00, 0x7A, 0x18, 0x60, 0x82, 0x78, 0x61, 0x45, 0xE0, 0x86,
  0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0x27, 0xC0, 0x3C, 0x10, 0x41, 0x04, 0x10, 0x61, 0x85, 0xE0, 0x87, 0x0A,
  0x24, 0x4F, 0x12, 0x22, 0x44, 0x85, 0x0C, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0xC0, 0xC7, 0x3A, 0xEB, 0xB6, 0x18, 0x61, 0x86, 0x10, 0xC7, 0x1A,
  0x69, 0x96, 0x59, 0x63, 0x8E, 0x10, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x45, 0xE0, 0xFD, 0x0A, 0x0C, 0x28, 0x5F, 0x20, 0x40, 0x81, 0x00, 0x7A,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0x81, 0x04, 0xFD, 0x0A, 0x14,
  0x28, 0xDE, 0x22, 0x44, 0x85, 0x0C, 0x7A, 0x18, 0x10, 0x70, 0x30, 0x61,
  0x85, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0x87, 0x09, 0x12, 0x24, 0x89,
  0x0A, 0x14, 0x30, 0x60, 0x89, 0x59, 0x59, 0x59, 0x56, 0x56, 0x56, 0x66,
  0x66, 0x26, 0x86, 0x89, 0x21, 0x81, 0x06, 0x0A, 0x24, 0x45, 0x0C, 0x87,
  0x09, 0x22, 0x43, 0x06, 0x04, 0x08, 0x10, 0x20, 0xFC, 0x10, 0x84, 0x10,
  0x82, 0x10, 0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x81, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49,
  0x24, 0x93, 0xC0, 0x30, 0xA4, 0x92, 0xC4, 0xFE, 0x90, 0x39, 0x18, 0x4F,
  0xC6, 0x18, 0x5F, 0x82, 0x0B, 0xB1, 0x86, 0x18, 0x61, 0xC6, 0xE0, 0x39,
  0x18, 0x60, 0x82, 0x14, 0x5E, 0x04, 0x13, 0x53, 0x86, 0x18, 0x61, 0x45,
  0xF0, 0x39, 0x18, 0x7F, 0x82, 0x04, 0x5E, 0x1C, 0x82, 0x3F, 0x20, 0x82,
  0x08, 0x20, 0x80, 0x35, 0x38, 0x61, 0x86, 0x14, 0xCD, 0x04, 0x37, 0x00,
  0x82, 0x0B, 0xB1, 0x86, 0x18, 0x61, 0x86, 0x10, 0x10, 0x20, 0x03, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x08, 0x40, 0xF0, 0x84, 0x21, 0x08,
  0x42, 0x11, 0x60, 0x81, 0x02, 0x1C, 0x28, 0x92, 0x3C, 0x44, 0x8D, 0x0C,
  0xE0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x3C, 0xEE, 0x59, 0x65,
  0x96, 0x59, 0x65, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x39, 0x18, 0x61,
  0x86, 0x14, 0x5E, 0xBB, 0x18, 0x61, 0x86, 0x1C, 0x6E, 0x82, 0x08, 0x00,
  0x35, 0x38, 0x61, 0x86, 0x14, 0x5F, 0x04, 0x10, 0x40, 0xF4, 0x63, 0x08,
  0x42, 0x10, 0x39, 0x18, 0x18, 0x1C, 0x18, 0x5F, 0x20, 0x8F, 0xC8, 0x20,
  0x82, 0x08, 0x20, 0x70, 0x86, 0x18, 0x61, 0x86, 0x14, 0x5E, 0x86, 0x14,
  0x52, 0x48, 0xA3, 0x0C, 0x93, 0x26, 0xCD, 0xAA, 0xD5, 0x93, 0x26, 0x85,
  0x32, 0x8C, 0x30, 0xA4, 0xA1, 0x86, 0x14, 0x52, 0x28, 0xA3, 0x04, 0x20,
  0x82, 0x00, 0xFC, 0x10, 0x84, 0x20, 0x84, 0x3F, 0x0C, 0x41, 0x04, 0x10,
  0x4F, 0x04, 0x10, 0x41, 0x04, 0x18, 0x10, 0xFF, 0xFC, 0xC0, 0x82, 0x08,
  0x20, 0x81, 0xC4, 0x20, 0x82, 0x08, 0x23, 0x00, 0xE6, 0x70,
};

const GFXglyph JetBrainsMono_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 14, 8, 1, -12 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 7, 10, 8, 1, -10 },
  { 46, 1, 4, 8, 4, -10 },
  { 47, 4, 14, 8, 3, -12 },
  { 54, 4, 14, 8, 2, -12 },
  { 61, 7, 8, 8, 1, -9 },
  { 68, 6, 7, 8, 1, -8 },
  { 74, 2, 4, 8, 3, -2 },
  { 75, 4, 1, 8, 2, -5 },
  { 76, 2, 2, 8, 3, -2 },
  { 77, 6, 14, 8, 1, -12 },
  { 88, 6, 10, 8, 1, -10 },
  { 96, 6, 10, 8, 1, -10 },
  { 104, 6, 10, 8, 1, -10 },
  { 112, 6, 10, 8, 1, -10 },
  { 120, 6, 10, 8, 1, -10 },
  { 128, 6, 10, 8, 1, -10 },
  { 136, 6, 10, 8, 1, -10 },
  { 144, 6, 10, 8, 1, -10 },
  { 152, 6, 10, 8, 1, -10 },
  { 160, 6, 10, 8, 1, -10 },
  { 168, 2, 8, 8, 3, -8 },
  { 170, 2, 10, 8, 3, -8 },
  { 173, 6, 7, 8, 1, -8 },
  { 179, 6, 4, 8, 1, -7 },
  { 182, 6, 7, 8, 1, -8 },
  { 188, 5, 10, 8, 2, -10 },
  { 195, 7, 13, 8, 1, -10 },
  { 207, 7, 10, 8, 1, -10 },
  { 216, 6, 10, 8, 1, -10 },
  { 224, 6, 10, 8, 1, -10 },
  { 232, 6, 10, 8, 1, -10 },
  { 240, 5, 10, 8, 2, -10 },
  { 247, 6, 10, 8, 1, -10 },
  { 255, 6, 10, 8, 1, -10 },
  { 263, 6, 10, 8, 1, -10 },
  { 271, 5, 10, 8, 2, -10 },
  { 278, 6, 10, 8, 1, -10 },
  { 286, 7, 10, 8, 1, -10 },
  { 295, 5, 10, 8, 2, -10 },
  { 302, 6, 10, 8, 1, -10 },
  { 310, 6, 10, 8, 1, -10 },
  { 318, 6, 10, 8, 1, -10 },
  { 326, 7, 10, 8, 1, -10 },
  { 335, 6, 13, 8, 1, -10 },
  { 345, 7, 10, 8, 1, -10 },
  { 354, 6, 10, 8, 1, -10 },
  { 362, 7, 10, 8, 1, -10 },
  { 371, 6, 10, 8, 1, -10 },
  { 379, 7, 10, 8, 1, -10 },
  { 388, 8, 10, 8, 0, -10 },
  { 398, 7, 10, 8, 1, -10 },
  { 407, 7, 10, 8, 1, -10 },
  { 416, 6, 10, 8, 1, -10 },
  { 424, 3, 14, 8, 3, -12 },
  { 430, 6, 14, 8, 1, -12 },
  { 441, 3, 14, 8, 2, -12 },
  { 447, 6, 5, 8, 1, -10 },
  { 451, 7, 1, 8, 1, 0 },
  { 452, 2, 2, 8, 3, -11 },
  { 453, 6, 8, 8, 1, -8 },
  { 459, 6, 10, 8, 1, -10 },
  { 467, 6, 8, 8, 1, -8 },
  { 473, 6, 10, 8, 1, -10 },
  { 481, 6, 8, 8, 1, -8 },
  { 487, 6, 10, 8, 1, -10 },
  { 495, 6, 11, 8, 1, -8 },
  { 504, 6, 10, 8, 1, -10 },
  { 512, 7, 11, 8, 1, -11 },
  { 522, 5, 14, 8, 1, -11 },
  { 531, 7, 10, 8, 1, -10 },
  { 540, 7, 10, 8, 1, -10 },
  { 549, 6, 8, 8, 1, -8 },
  { 555, 6, 8, 8, 1, -8 },
  { 561, 6, 8, 8, 1, -8 },
  { 567, 6, 11, 8, 1, -8 },
  { 576, 6, 11, 8, 1, -8 },
  { 585, 5, 8, 8, 2, -8 },
  { 590, 6, 8, 8, 1, -8 },
  { 596, 6, 10, 8, 1, -10 },
  { 604, 6, 8, 8, 1, -8 },
  { 610, 6, 8, 8, 1, -8 },
  { 616, 7, 8, 8, 1, -8 },
  { 623, 6, 8, 8, 1, -8 },
  { 629, 6, 11, 8, 1, -8 },
  { 638, 6, 8, 8, 1, -8 },
  { 644, 6, 14, 8, 1, -12 },
  { 655, 1, 14, 8, 4, -12 },
  { 657, 6, 14, 8, 1, -12 },
  { 668, 6, 2, 8, 1, -6 },
};

const GFXfont JetBrainsMono_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_EXTRALIGHT14PT7B_H_
