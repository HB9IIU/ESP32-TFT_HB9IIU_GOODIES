#ifndef _JETBRAINSMONO_EXTRALIGHT64PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFC, 0x71, 0xF8, 0x1F, 0x07, 0x07, 0xC3, 0xE0, 0x70, 0x3E, 0x3C,
  0x07, 0x03, 0xE3, 0xC0, 0x70, 0x1E, 0x3C, 0x07, 0x01, 0xE7, 0xC0, 0x70,
  0x1F, 0x7C, 0x07, 0x01, 0xF7, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x07,
  0x00, 0x01, 0xF8, 0x70, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x73, 0xF8, 0x00, 0x07, 0x0F,
  0xC0, 0x00, 0x70, 0x7E, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x1E, 0x00,
  0x07, 0x01, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70,
  0x0F, 0xF0, 0x07, 0x00, 0xFF, 0x00, 0x70, 0x0F, 0xF8, 0x07, 0x00, 0xF7,
  0x80, 0x70, 0x0F, 0x78, 0x07, 0x01, 0xF7, 0xC0, 0x70, 0x3E, 0x3E, 0x07,
  0x03, 0xE3, 0xF8, 0x70, 0xFC, 0x1F, 0xE7, 0x3F, 0x80, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x0E,
  0x1F, 0xFF, 0x00, 0x01, 0xE3, 0xF1, 0xF0, 0x00, 0x3C, 0x7C, 0x07, 0x80,
  0x03, 0x87, 0x80, 0x78, 0x00, 0x78, 0x78, 0x03, 0x80, 0x0F, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x03, 0xC0,
  0x70, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x70, 0x03, 0xC0,
  0xF0, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0x78, 0x07, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x70, 0x00,
  0x3F, 0xFF, 0x0F, 0x00, 0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x07, 0xF8, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xFE, 0x00, 0x00, 0x38, 0x3F, 0xF8, 0x00, 0x07, 0x87,
  0xFF, 0xC0, 0x00, 0xF0, 0xF8, 0x7C, 0x00, 0x0E, 0x0F, 0x01, 0xE0, 0x01,
  0xE1, 0xE0, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x03, 0x81, 0xE0, 0x0F,
  0x00, 0x70, 0x1C, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x0E,
  0x1E, 0x00, 0x0F, 0x01, 0xE1, 0xC0, 0x00, 0xF8, 0x3E, 0x38, 0x00, 0x07,
  0xFF, 0xC7, 0x80, 0x00, 0x3F, 0xF8, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x1E, 0x78, 0x1F, 0x00, 0x3E, 0xF8, 0x0F, 0x80, 0x3C, 0xF0,
  0x07, 0xC0, 0x78, 0xF0, 0x03, 0xC0, 0x78, 0xF0, 0x03, 0xE0, 0xF0, 0xF0,
  0x01, 0xF1, 0xF0, 0xF0, 0x00, 0xF9, 0xE0, 0xF0, 0x00, 0x7B, 0xE0, 0xF0,
  0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7D, 0xE0, 0x78, 0x00, 0xF9, 0xF0, 0x7C,
  0x01, 0xF8, 0xF8, 0x3F, 0x87, 0xF0, 0x78, 0x3F, 0xFF, 0xE0, 0x3C, 0x1F,
  0xFF, 0x80, 0x3E, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x08, 0x00, 0x78, 0x00, 0x23, 0x80, 0x1E, 0x00, 0x79, 0xFC, 0x07,
  0x80, 0x7E, 0x7F, 0xC0, 0xE0, 0xFF, 0xFF, 0xFC, 0x38, 0xFF, 0xF1, 0xFF,
  0xCC, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x83, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x7E,
  0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFE,
  0x07, 0xE0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x7E,
  0x78, 0x00, 0x1F, 0xC7, 0x80, 0x03, 0xF0, 0x78, 0x00, 0x7E, 0x07, 0x80,
  0x0F, 0xC0, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xE1, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x1F, 0xFC,
  0x07, 0x9F, 0xFF, 0xC1, 0xEF, 0xFF, 0xF8, 0x7B, 0xC0, 0xFF, 0x1F, 0xC0,
  0x07, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0x7F, 0x03,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF9, 0xFF, 0x80,
  0x0F, 0x7F, 0xFE, 0x01, 0xEF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x07, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC1,
  0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xF7, 0x80, 0x1F, 0xFC, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE,
  0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x3F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFE, 0x0C,
  0x00, 0x07, 0xC1, 0xFE, 0x1F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0x3F, 0x80, 0x3F, 0x8F, 0x7F, 0x00,
  0xF8, 0x07, 0xFE, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07,
  0x80, 0x0F, 0xF0, 0x0F, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0xC0, 0x3C,
  0x00, 0x7F, 0x80, 0x78, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xE0,
  0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0x80, 0x0F, 0xF0, 0x0F, 0x00,
  0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x7F, 0x80, 0x78, 0x00,
  0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xE0, 0x0F,
  0xF8, 0x03, 0xE0, 0x77, 0xF0, 0x07, 0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0x9F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFE, 0x3C, 0x00, 0x0F,
  0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF8, 0xF0, 0x00,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x3C, 0x00, 0x1F, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x07,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xF9, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x00, 0x3F, 0x87,
  0x80, 0x07, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0x3C, 0x00, 0x7F, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7C,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x77, 0xFF, 0x00, 0x07, 0x7F, 0x70,
  0x00, 0xF7, 0xF7, 0x80, 0x0E, 0xFF, 0x78, 0x00, 0xEF, 0xF3, 0x80, 0x1E,
  0xFF, 0x3C, 0x01, 0xCF, 0xF3, 0xC0, 0x1C, 0xFF, 0x1C, 0x03, 0xCF, 0xF1,
  0xE0, 0x38, 0xFF, 0x0E, 0x03, 0x8F, 0xF0, 0xE0, 0x78, 0xFF, 0x0F, 0x07,
  0x0F, 0xF0, 0x70, 0xF0, 0xFF, 0x07, 0x0F, 0x0F, 0xF8, 0x78, 0xE0, 0xFF,
  0x83, 0x8E, 0x0F, 0xF8, 0x39, 0xE0, 0xFF, 0x83, 0xDC, 0x0F, 0xF8, 0x1D,
  0xC0, 0xFF, 0x81, 0xF8, 0x0F, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0xF8, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xBC, 0x00, 0x1F,
  0xDE, 0x00, 0x0F, 0xE7, 0x00, 0x07, 0xFB, 0xC0, 0x03, 0xFD, 0xE0, 0x01,
  0xFE, 0x70, 0x00, 0xFF, 0x3C, 0x00, 0x7F, 0x9E, 0x00, 0x3F, 0xC7, 0x80,
  0x1F, 0xE3, 0xC0, 0x0F, 0xF0, 0xE0, 0x07, 0xF8, 0x78, 0x03, 0xFC, 0x3C,
  0x01, 0xFE, 0x0F, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x81, 0xC0, 0x3F, 0xC0,
  0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x1C, 0x07, 0xF8, 0x0F, 0x03, 0xFC,
  0x07, 0x81, 0xFE, 0x01, 0xE0, 0xFF, 0x00, 0xF0, 0x7F, 0x80, 0x38, 0x3F,
  0xC0, 0x1E, 0x1F, 0xE0, 0x0F, 0x0F, 0xF0, 0x03, 0xC7, 0xF8, 0x01, 0xE3,
  0xFC, 0x00, 0xF1, 0xFE, 0x00, 0x3C, 0xFF, 0x00, 0x1E, 0x7F, 0x80, 0x07,
  0x3F, 0xC0, 0x03, 0xDF, 0xE0, 0x01, 0xEF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D,
  0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xF0, 0x03,
  0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x7F, 0x0F, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF8, 0xF0, 0x00,
  0x7F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xF9, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xEF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x7E,
  0x3C, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0xF8, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0x9F, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0x7F, 0x83, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x3D, 0xE0, 0x07, 0xC0, 0x0F,
  0x78, 0x03, 0xB0, 0x03, 0xDE, 0x00, 0xEC, 0x00, 0xF7, 0x80, 0x3B, 0x80,
  0x39, 0xE0, 0x0E, 0xE0, 0x1E, 0x78, 0x03, 0xB8, 0x07, 0x9E, 0x00, 0xEE,
  0x01, 0xE7, 0x80, 0x33, 0x80, 0x78, 0xE0, 0x1C, 0xE0, 0x1E, 0x3C, 0x07,
  0x38, 0x07, 0x8F, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0x71, 0xC0, 0x70, 0xF0,
  0x1C, 0x70, 0x1C, 0x3C, 0x07, 0x1C, 0x0F, 0x0F, 0x01, 0xC7, 0x03, 0xC3,
  0xC0, 0xE1, 0xC0, 0xF0, 0xF0, 0x38, 0x70, 0x3C, 0x1E, 0x0E, 0x0C, 0x0F,
  0x07, 0x83, 0x83, 0x83, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x38,
  0x38, 0x1E, 0x0E, 0x0E, 0x0E, 0x07, 0x83, 0x03, 0x87, 0x81, 0xE1, 0xC0,
  0xE1, 0xE0, 0x78, 0x70, 0x38, 0x78, 0x0E, 0x1C, 0x06, 0x1E, 0x03, 0xC7,
  0x01, 0xC7, 0x80, 0xF1, 0xC0, 0x71, 0xE0, 0x3C, 0x70, 0x1C, 0x70, 0x0F,
  0x18, 0x07, 0x1C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x71, 0xC0,
  0x3C, 0xE0, 0x1C, 0xF0, 0x07, 0x38, 0x03, 0x3C, 0x01, 0xCE, 0x00, 0xEF,
  0x00, 0x7B, 0x80, 0x3B, 0xC0, 0x1E, 0xC0, 0x0E, 0xE0, 0x07, 0xB0, 0x03,
  0xB8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xE0, 0x00, 0xF7,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0xEF, 0x3F, 0x80, 0x7D, 0xE3, 0xFF, 0xFF, 0x3C, 0x3F,
  0xFF, 0xC7, 0x81, 0xFF, 0xE0, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xF0, 0x0F, 0x0F,
  0xFE, 0x07, 0x9F, 0xFF, 0xC3, 0xDF, 0xFF, 0xF1, 0xEF, 0x01, 0xFC, 0xFE,
  0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x80, 0x0F, 0x9E,
  0xF0, 0x1F, 0xCF, 0x3F, 0xFF, 0xC7, 0x8F, 0xFF, 0xC3, 0xC3, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x1F,
  0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0x03, 0xFF, 0xC3, 0xC1, 0xFF,
  0xF8, 0xF0, 0xFF, 0xFF, 0x3C, 0x7E, 0x01, 0xEF, 0x3F, 0x00, 0x3B, 0xCF,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xF3, 0xF0, 0x03, 0xBC,
  0x7F, 0x03, 0xEF, 0x0F, 0xFF, 0xF3, 0xC1, 0xFF, 0xF8, 0xF0, 0x3F, 0xF8,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x07, 0xC3,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x7F, 0xFE, 0x3C,
  0x3F, 0xFF, 0xCF, 0x1F, 0x80, 0x7B, 0xCF, 0xC0, 0x0E, 0xF3, 0xE0, 0x01,
  0xBD, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x6F, 0x3F, 0x00, 0x3B,
  0xC7, 0xF0, 0x3E, 0xF0, 0xFF, 0xFF, 0x3C, 0x1F, 0xFF, 0x8F, 0x01, 0xFF,
  0x83, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x03, 0xF0, 0x0F, 0x0F, 0xFE, 0x07, 0x9F, 0xFF, 0xC3, 0xDF, 0xFF,
  0xF1, 0xEF, 0x01, 0xFC, 0xFE, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0xF0, 0x0F, 0x07, 0x1F, 0xE1, 0xFE, 0x39,
  0xFF, 0x1F, 0xF9, 0xDF, 0xFD, 0xFF, 0xEE, 0x81, 0xEC, 0x1F, 0x7C, 0x07,
  0xC0, 0x7B, 0xC0, 0x3C, 0x03, 0xDE, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00,
  0x7F, 0x80, 0x78, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0xFF,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x01, 0xFE, 0x01,
  0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x78, 0x03, 0xFC, 0x03, 0xC0,
  0x1F, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0x80, 0x3F,
  0xC0, 0x3C, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80,
  0x78, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0xF0,
  0x07, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x01, 0xFE, 0x01, 0xE0, 0x0F,
  0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x78, 0x03, 0xFC, 0x03, 0xC0, 0x1F, 0xE0,
  0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x78, 0x7F, 0xF0, 0x3C, 0xFF, 0xFE,
  0x1E, 0xFF, 0xFF, 0x8F, 0x78, 0x0F, 0xE7, 0xF0, 0x01, 0xF3, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x78, 0x7F, 0xF0, 0x3C, 0xFF, 0xFE, 0x1E, 0xFF, 0xFF, 0x8F, 0x78, 0x0F,
  0xE7, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xFC, 0x00,
  0x7C, 0xF7, 0x80, 0xFE, 0x79, 0xFF, 0xFE, 0x3C, 0x7F, 0xFC, 0x1E, 0x1F,
  0xFC, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x7F, 0xFE,
  0x3C, 0x3F, 0xFF, 0xCF, 0x1F, 0x80, 0x7B, 0xCF, 0xC0, 0x0E, 0xF3, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0xEF, 0x1F,
  0xC0, 0xFB, 0xC3, 0xFF, 0xFC, 0xF0, 0x7F, 0xFE, 0x3C, 0x07, 0xFE, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3C, 0x3F, 0xF8, 0x0F, 0x1F, 0xFF,
  0x83, 0xCF, 0xFF, 0xF0, 0xF7, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E,
  0x3F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0xF8, 0x01, 0xF0, 0x03, 0xBC, 0x00, 0xF8, 0x03, 0xDE, 0x00,
  0xFC, 0x01, 0xE7, 0x00, 0x7E, 0x00, 0xF3, 0xC0, 0x3B, 0x00, 0x79, 0xE0,
  0x1D, 0xC0, 0x38, 0xF0, 0x0E, 0xE0, 0x1C, 0x78, 0x06, 0x70, 0x1E, 0x3C,
  0x07, 0x38, 0x0F, 0x0E, 0x03, 0x9C, 0x07, 0x87, 0x81, 0xC6, 0x03, 0xC3,
  0xC0, 0xE3, 0x81, 0xC1, 0xE0, 0x61, 0xC0, 0xE0, 0xF0, 0x30, 0xE0, 0xF0,
  0x78, 0x38, 0x70, 0x78, 0x1C, 0x1C, 0x38, 0x3C, 0x0F, 0x0E, 0x0C, 0x1E,
  0x07, 0x87, 0x07, 0x0E, 0x03, 0xC3, 0x03, 0x87, 0x01, 0xE3, 0x81, 0xC3,
  0x80, 0xF1, 0xC0, 0xE3, 0xC0, 0x38, 0xE0, 0x71, 0xE0, 0x1C, 0x70, 0x1C,
  0xF0, 0x0F, 0x38, 0x0E, 0x70, 0x07, 0x98, 0x07, 0x38, 0x03, 0xDC, 0x03,
  0x9C, 0x01, 0xEE, 0x01, 0xDE, 0x00, 0x77, 0x00, 0xEF, 0x00, 0x3B, 0x80,
  0x3F, 0x80, 0x1D, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x71, 0xFF, 0x00, 0x07, 0x3F, 0xF8, 0x00,
  0x77, 0xFF, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x7F, 0x01, 0xF0, 0x07, 0xF0,
  0x0F, 0x80, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0x03, 0xE1, 0xFF, 0x00, 0x3F,
  0xFE, 0xF0, 0x01, 0xFF, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 8, 47, 38, 15, -47 },
  { 48, 18, 19, 38, 10, -47 },
  { 91, 34, 47, 38, 2, -47 },
  { 291, 28, 65, 38, 5, -56 },
  { 519, 36, 47, 38, 1, -47 },
  { 731, 32, 48, 38, 4, -47 },
  { 923, 5, 19, 38, 17, -47 },
  { 935, 18, 62, 38, 13, -54 },
  { 1075, 19, 62, 38, 7, -54 },
  { 1223, 34, 33, 38, 2, -39 },
  { 1364, 29, 30, 38, 5, -36 },
  { 1473, 11, 20, 38, 12, -10 },
  { 1501, 20, 4, 38, 9, -23 },
  { 1511, 10, 10, 38, 14, -9 },
  { 1524, 27, 60, 38, 6, -53 },
  { 1727, 27, 48, 38, 6, -47 },
  { 1889, 28, 47, 38, 6, -47 },
  { 2054, 29, 47, 38, 5, -47 },
  { 2225, 27, 48, 38, 5, -47 },
  { 2387, 25, 47, 38, 6, -47 },
  { 2534, 26, 48, 38, 6, -47 },
  { 2690, 28, 48, 38, 5, -47 },
  { 2858, 29, 47, 38, 5, -47 },
  { 3029, 28, 48, 38, 5, -47 },
  { 3197, 28, 47, 38, 5, -47 },
  { 3362, 10, 37, 38, 14, -36 },
  { 3409, 12, 46, 38, 12, -36 },
  { 3478, 27, 33, 38, 6, -38 },
  { 3590, 27, 18, 38, 6, -30 },
  { 3651, 27, 33, 38, 6, -38 },
  { 3763, 22, 47, 38, 10, -47 },
  { 3893, 31, 58, 38, 4, -47 },
  { 4118, 31, 47, 38, 4, -47 },
  { 4301, 26, 47, 38, 7, -47 },
  { 4454, 27, 48, 38, 6, -47 },
  { 4616, 25, 47, 38, 7, -47 },
  { 4763, 26, 47, 38, 7, -47 },
  { 4916, 27, 47, 38, 7, -47 },
  { 5075, 27, 48, 38, 6, -47 },
  { 5237, 25, 47, 38, 7, -47 },
  { 5384, 24, 47, 38, 7, -47 },
  { 5525, 27, 48, 38, 4, -47 },
  { 5687, 28, 47, 38, 7, -47 },
  { 5852, 26, 47, 38, 8, -47 },
  { 6005, 28, 47, 38, 5, -47 },
  { 6170, 25, 47, 38, 7, -47 },
  { 6317, 26, 48, 38, 6, -47 },
  { 6473, 28, 47, 38, 7, -47 },
  { 6638, 27, 59, 38, 6, -47 },
  { 6838, 27, 47, 38, 7, -47 },
  { 6997, 28, 48, 38, 5, -47 },
  { 7165, 31, 47, 38, 4, -47 },
  { 7348, 26, 48, 38, 6, -47 },
  { 7504, 31, 47, 38, 4, -47 },
  { 7687, 34, 47, 38, 2, -47 },
  { 7887, 32, 47, 38, 3, -47 },
  { 8075, 33, 47, 38, 3, -47 },
  { 8269, 27, 47, 38, 6, -47 },
  { 8428, 15, 60, 38, 14, -53 },
  { 8541, 27, 60, 38, 6, -53 },
  { 8744, 15, 60, 38, 10, -53 },
  { 8857, 27, 25, 38, 6, -47 },
  { 8942, 31, 3, 38, 4, 2 },
  { 8954, 12, 9, 38, 12, -50 },
  { 8968, 27, 37, 38, 5, -36 },
  { 9093, 25, 48, 38, 7, -47 },
  { 9243, 26, 37, 38, 6, -36 },
  { 9364, 26, 48, 38, 6, -47 },
  { 9520, 26, 37, 38, 6, -36 },
  { 9641, 30, 47, 38, 4, -47 },
  { 9818, 26, 48, 38, 6, -36 },
  { 9974, 25, 47, 38, 7, -47 },
  { 10121, 29, 49, 38, 6, -49 },
  { 10299, 23, 61, 38, 6, -49 },
  { 10475, 28, 47, 38, 7, -47 },
  { 10640, 32, 47, 38, 3, -47 },
  { 10828, 29, 36, 38, 5, -36 },
  { 10959, 25, 36, 38, 7, -36 },
  { 11072, 26, 37, 38, 6, -36 },
  { 11193, 25, 48, 38, 7, -36 },
  { 11343, 26, 48, 38, 6, -36 },
  { 11499, 26, 36, 38, 8, -36 },
  { 11616, 27, 37, 38, 6, -36 },
  { 11741, 29, 45, 38, 4, -45 },
  { 11905, 26, 36, 38, 6, -35 },
  { 12022, 30, 35, 38, 4, -35 },
  { 12154, 33, 35, 38, 3, -35 },
  { 12299, 30, 35, 38, 4, -35 },
  { 12431, 30, 47, 38, 4, -35 },
  { 12608, 26, 35, 38, 6, -35 },
  { 12722, 26, 60, 38, 6, -53 },
  { 12917, 4, 60, 38, 17, -53 },
  { 12947, 26, 60, 38, 6, -53 },
  { 13142, 28, 13, 38, 5, -29 },
};

const GFXfont JetBrainsMono_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_EXTRALIGHT64PT7B_H_
