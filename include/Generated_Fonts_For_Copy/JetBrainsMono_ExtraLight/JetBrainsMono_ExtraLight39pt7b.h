#ifndef _JETBRAINSMONO_EXTRALIGHT39PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x18, 0xC6, 0x31,
  0x8C, 0x60, 0x00, 0x00, 0x7F, 0xFE, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60, 0xEC, 0x1D, 0x83, 0x80, 0x00,
  0xC0, 0x60, 0x0E, 0x07, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0x60, 0x0E, 0x07, 0x00, 0x60, 0x30, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x70, 0x38, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x70, 0x38, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x70, 0x38, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x70, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x38, 0xCF, 0x38, 0x63, 0x9C, 0x30,
  0xEE, 0x18, 0x76, 0x0C, 0x3B, 0x86, 0x01, 0xC3, 0x00, 0xF1, 0x80, 0x38,
  0xC0, 0x0F, 0x60, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x06, 0xF0,
  0x03, 0x1C, 0x01, 0x87, 0x00, 0xC3, 0x80, 0x60, 0xC0, 0x30, 0x7C, 0x18,
  0x3E, 0x0C, 0x3B, 0x06, 0x1D, 0xC3, 0x1C, 0x79, 0x9E, 0x1F, 0xFE, 0x07,
  0xFC, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x04, 0xFE, 0x00, 0x67, 0x3C, 0x03, 0x38, 0x30, 0x1C, 0xC0,
  0xC0, 0x63, 0x03, 0x03, 0x0C, 0x0C, 0x1C, 0x30, 0x30, 0x60, 0xC0, 0xC3,
  0x03, 0x03, 0x18, 0x0E, 0x1C, 0x60, 0x1F, 0xE3, 0x00, 0x3F, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE3, 0xC0, 0x03,
  0x1F, 0xC0, 0x18, 0xE3, 0x80, 0xE7, 0x06, 0x03, 0x18, 0x18, 0x18, 0x60,
  0x60, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x18, 0x18, 0x18, 0xC0, 0x70, 0x67,
  0x00, 0xC3, 0x98, 0x03, 0xFC, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x7F,
  0x80, 0x0F, 0x3C, 0x01, 0xC0, 0xE0, 0x18, 0x07, 0x03, 0x80, 0x70, 0x38,
  0x07, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0x1C, 0x07,
  0x60, 0xE0, 0xEE, 0x06, 0x0C, 0xE0, 0x71, 0xCE, 0x03, 0xB8, 0xE0, 0x1F,
  0x8E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x87, 0x01,
  0xD8, 0x78, 0x79, 0xC3, 0xFF, 0x0E, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x20, 0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0x40, 0x80, 0x0F, 0x00, 0xFC, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x3E, 0x0F,
  0xC0, 0xF0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0xE0, 0x2F, 0x86, 0x1F,
  0xFE, 0x67, 0xF3, 0xF5, 0xF8, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xB0,
  0x00, 0x3B, 0x80, 0x07, 0x1C, 0x00, 0x71, 0xE0, 0x0E, 0x0E, 0x01, 0xE0,
  0x70, 0x1C, 0x07, 0x80, 0x80, 0x30, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x3C, 0xF1, 0xE3, 0x87, 0x1E, 0x38, 0x70, 0xC3, 0x87, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x33, 0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x80,
  0x1D, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x1F, 0x87, 0x8F, 0xC3, 0xC7, 0xE0, 0xC3,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D, 0x80,
  0x0E, 0xC0, 0x07, 0x70, 0x07, 0x3C, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xB0, 0x0F, 0x18, 0x0F, 0x0C,
  0x07, 0x06, 0x02, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x03, 0xF7, 0xE1, 0xE0, 0x3C, 0x70,
  0x07, 0x38, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x0F, 0x3C, 0x1E,
  0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x67, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xFF, 0xFE, 0xFF,
  0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE1, 0xE0, 0xEF, 0xF8, 0xFF, 0xFC, 0xF8, 0x1E, 0xF0,
  0x0E, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x78,
  0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x7F, 0x03, 0xFF, 0xE3, 0xE0, 0x79, 0xC0,
  0x1C, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0E, 0xE0, 0x07, 0x78, 0x07, 0x1E, 0x0F,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xCE, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x07, 0xFE,
  0x07, 0xDF, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x81, 0xC0, 0xE3, 0xC0,
  0x3F, 0x80, 0x0F, 0x80, 0x1E, 0xF0, 0x1C, 0x1C, 0x1C, 0x07, 0x9C, 0x01,
  0xCC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x60,
  0x03, 0xB8, 0x03, 0x8F, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xE0,
  0x07, 0xFE, 0x07, 0xDF, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x3C, 0x7C, 0x7E, 0x1F, 0xF6, 0x03, 0xE7,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xFF, 0xFF, 0xE0, 0x1C, 0x3E, 0x3F, 0x3F, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x60, 0x60, 0xE0, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0x87, 0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x0F, 0xF0, 0x7E, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3C, 0x3E, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xDC,
  0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF9, 0xF0,
  0x3F, 0xBE, 0x0F, 0x1F, 0xC1, 0x81, 0xF8, 0x30, 0x1F, 0x0E, 0x03, 0xE1,
  0xC0, 0x7C, 0x38, 0x0F, 0x87, 0x01, 0xF0, 0xE0, 0x3E, 0x1C, 0x07, 0xC3,
  0x80, 0xF8, 0x30, 0x1F, 0x07, 0x07, 0xE0, 0xF1, 0xFC, 0x0F, 0xEF, 0x80,
  0x78, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x80, 0x07,
  0x30, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE1, 0x80, 0x1C,
  0x30, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x1C, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0x60, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0x80,
  0x38, 0x70, 0x03, 0x0C, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0xF0, 0x00, 0x70, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x1C,
  0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x1C, 0xFF, 0xF8, 0xFF, 0xF0, 0xE0, 0xFC,
  0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x7E, 0xFF, 0xF8,
  0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x70, 0x1E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x06, 0x70, 0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0x70, 0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D, 0x80, 0x0E, 0xE0,
  0x06, 0x70, 0x07, 0x1E, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x63, 0x80,
  0x71, 0xC0, 0x30, 0xE0, 0x38, 0x70, 0x18, 0x38, 0x1C, 0x1C, 0x0C, 0x0E,
  0x0E, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0x38,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xEC, 0x03,
  0xF6, 0x03, 0xFB, 0x01, 0xBE, 0xC0, 0xDF, 0x60, 0xEF, 0xB0, 0x67, 0xCC,
  0x33, 0xE6, 0x39, 0xF3, 0x18, 0xF8, 0xCC, 0x7C, 0x6C, 0x3E, 0x36, 0x1F,
  0x0F, 0x0F, 0x87, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x30, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1E, 0xC0, 0x3D, 0x80, 0x7B, 0x80, 0xF3, 0x01, 0xE6, 0x03, 0xC6,
  0x07, 0x8C, 0x0F, 0x1C, 0x1E, 0x18, 0x3C, 0x30, 0x78, 0x70, 0xF0, 0x61,
  0xE0, 0xE3, 0xC0, 0xC7, 0x81, 0x8F, 0x03, 0x9E, 0x03, 0x3C, 0x06, 0x78,
  0x0E, 0xF0, 0x0D, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x70, 0x07, 0xC0, 0x1F, 0xF0, 0x3E, 0xFC, 0x70, 0x1C, 0xE0, 0x0E, 0xE0,
  0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x06, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x38, 0x03, 0xDC, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xEE, 0x00, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xC0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0xF8, 0x3E, 0xFC, 0x70, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0,
  0x0E, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xF8, 0x7F, 0xFE, 0x38, 0x07, 0x9C, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1B,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x00,
  0xEE, 0x01, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x70, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xDF, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x1D,
  0xC0, 0x0E, 0xC0, 0x07, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0x60, 0x03, 0xB8, 0x03, 0x8F, 0x03, 0xC3, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0x70, 0x0E, 0xF0, 0x78, 0xFF, 0xE0, 0x7F,
  0x80, 0xE0, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00, 0xE3, 0x00,
  0x1C, 0x70, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x80,
  0x60, 0x70, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0C, 0x03, 0x81,
  0x80, 0x30, 0x70, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x01, 0x8E,
  0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xB0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x70, 0x1B, 0x03,
  0xC1, 0xD8, 0x1E, 0x0E, 0xC0, 0xF0, 0x76, 0x05, 0x83, 0x30, 0x2C, 0x19,
  0xC3, 0x60, 0xCE, 0x19, 0x06, 0x70, 0xC8, 0x31, 0x86, 0x61, 0x8C, 0x33,
  0x1C, 0x61, 0x18, 0xE3, 0x08, 0xC7, 0x18, 0xC6, 0x30, 0xC6, 0x31, 0x87,
  0x30, 0x8C, 0x39, 0x84, 0x61, 0xCC, 0x33, 0x06, 0x41, 0x98, 0x32, 0x0D,
  0xC1, 0xB0, 0x6E, 0x0D, 0x83, 0x60, 0x6C, 0x1B, 0x03, 0xE0, 0x58, 0x1F,
  0x02, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x00,
  0xE7, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x38, 0x1C, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0x80, 0x01,
  0xB8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xB8, 0x00, 0x31, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xE0,
  0x0E, 0x06, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x03, 0x80, 0x38, 0x38, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x76, 0x00,
  0x0E, 0x70, 0x00, 0xC3, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x38, 0x1C,
  0x03, 0x00, 0xC0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00,
  0x31, 0xC0, 0x03, 0x98, 0x00, 0x1B, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x30, 0x18,
  0x38, 0x38, 0x18, 0x38, 0x18, 0x30, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0xE0,
  0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x38, 0x0E, 0x70, 0x07,
  0x70, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x1F, 0xFF,
  0x3F, 0xFF, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0x78, 0x1B, 0x3F, 0xFB, 0x1F, 0xE3, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0,
  0xEF, 0xF8, 0xFE, 0xFC, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xF0, 0x0E,
  0xF8, 0x1C, 0xEF, 0xF8, 0xE7, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x70, 0x1E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC1, 0xE1, 0x8F, 0xF3, 0x3E, 0xF6, 0xE0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x70,
  0x0E, 0xF0, 0x6C, 0xFF, 0xD8, 0xFF, 0x30, 0x07, 0xC0, 0x1F, 0xF0, 0x3E,
  0x7C, 0x70, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x06, 0x70, 0x0E, 0x78, 0x1C, 0x3F,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x3F, 0xCC, 0xFB, 0xDB,
  0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0x70, 0x0E, 0xF0, 0x2C, 0xFF, 0xD8, 0xFF, 0x30, 0x30, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0xFF, 0xE1, 0xFF,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0xF8, 0x77, 0xFC, 0xFE, 0x7D, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x3F,
  0xF0, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07,
  0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC1,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07,
  0x01, 0xC3, 0x80, 0xF1, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x01,
  0xDC, 0x00, 0x70, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0x0E,
  0x37, 0xEF, 0xCF, 0x3A, 0x3B, 0x87, 0x06, 0xC1, 0xC1, 0xB0, 0x30, 0x7C,
  0x0C, 0x1F, 0x03, 0x07, 0xC0, 0xC1, 0xF0, 0x30, 0x7C, 0x0C, 0x1F, 0x03,
  0x07, 0xC0, 0xC1, 0xF0, 0x30, 0x7C, 0x0C, 0x1F, 0x03, 0x07, 0xC0, 0xC1,
  0xF0, 0x30, 0x7C, 0x0C, 0x1F, 0x03, 0x07, 0xC0, 0xC1, 0xF0, 0x30, 0x70,
  0x03, 0xE1, 0xDF, 0xF3, 0xFB, 0xF7, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xC0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC,
  0x70, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8,
  0x0F, 0xF0, 0x03, 0xE0, 0xEF, 0xF8, 0xFE, 0xFC, 0xF0, 0x1E, 0xF0, 0x0E,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0xE0, 0x0E, 0xF0, 0x0E, 0xF8, 0x1C, 0xEF, 0xF8, 0xE7, 0xF0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x3F, 0xCC, 0xFB, 0xDB, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x3B,
  0xC1, 0xB3, 0xFF, 0x63, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0xE1, 0x9F, 0xF3, 0x7B,
  0xF7, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x70, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x7F, 0xFC, 0x1F, 0xF8, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0E, 0xE0, 0x1D, 0xE0, 0xF1,
  0xFF, 0xC0, 0xFF, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xE6, 0x00, 0x39, 0xC0,
  0x0C, 0x70, 0x07, 0x0C, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x18, 0x0E,
  0x07, 0x03, 0x01, 0xC1, 0xC0, 0x30, 0x70, 0x0E, 0x18, 0x03, 0x8E, 0x00,
  0x63, 0x80, 0x1C, 0xC0, 0x07, 0x70, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0xC0, 0xE0, 0x7C, 0x0E, 0x06, 0xE0, 0xF0, 0x6E,
  0x0B, 0x06, 0x60, 0xB0, 0x66, 0x1B, 0x0E, 0x61, 0x90, 0xE6, 0x19, 0x0C,
  0x71, 0x98, 0xC7, 0x11, 0x8C, 0x33, 0x18, 0xC3, 0x31, 0x9C, 0x33, 0x09,
  0xC3, 0x30, 0x98, 0x32, 0x0D, 0x83, 0xA0, 0xD8, 0x1E, 0x0D, 0x81, 0xE0,
  0xD8, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0xF0, 0x03, 0x9C,
  0x01, 0xC3, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x03, 0x86, 0x00, 0x73,
  0x80, 0x1D, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0x70, 0x01, 0xCE, 0x00, 0xE1, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x0E,
  0x01, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xF8,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x30, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x03, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x60,
  0x06, 0x38, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x3F, 0x80,
  0xDF, 0xE0, 0x7C, 0x78, 0x3C, 0x1C, 0x1E, 0x07, 0x9F, 0x01, 0xFD, 0x80,
  0x3C,
};

const GFXglyph JetBrainsMono_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 11, 11, 23, 6, -28 },
  { 35, 21, 28, 23, 1, -28 },
  { 109, 17, 39, 23, 3, -34 },
  { 192, 22, 29, 23, 1, -29 },
  { 272, 20, 29, 23, 2, -29 },
  { 345, 3, 11, 23, 10, -28 },
  { 350, 11, 38, 23, 8, -33 },
  { 403, 12, 38, 23, 4, -33 },
  { 460, 20, 20, 23, 2, -24 },
  { 510, 18, 18, 23, 3, -22 },
  { 551, 7, 12, 23, 7, -6 },
  { 562, 13, 2, 23, 5, -14 },
  { 566, 6, 6, 23, 9, -6 },
  { 571, 17, 36, 23, 3, -32 },
  { 648, 17, 29, 23, 3, -29 },
  { 710, 17, 28, 23, 4, -28 },
  { 770, 18, 29, 23, 3, -29 },
  { 836, 16, 28, 23, 3, -28 },
  { 892, 15, 28, 23, 4, -28 },
  { 945, 16, 28, 23, 4, -28 },
  { 1001, 17, 28, 23, 3, -28 },
  { 1061, 18, 28, 23, 3, -28 },
  { 1124, 17, 29, 23, 3, -29 },
  { 1186, 17, 29, 23, 3, -29 },
  { 1248, 6, 22, 23, 9, -22 },
  { 1265, 8, 28, 23, 7, -22 },
  { 1293, 17, 20, 23, 3, -23 },
  { 1336, 16, 12, 23, 4, -19 },
  { 1360, 17, 20, 23, 3, -23 },
  { 1403, 13, 28, 23, 6, -28 },
  { 1449, 19, 36, 23, 2, -29 },
  { 1535, 19, 28, 23, 2, -28 },
  { 1602, 16, 28, 23, 4, -28 },
  { 1658, 16, 29, 23, 4, -29 },
  { 1716, 16, 28, 23, 4, -28 },
  { 1772, 16, 28, 23, 4, -28 },
  { 1828, 16, 28, 23, 4, -28 },
  { 1884, 16, 29, 23, 4, -29 },
  { 1942, 15, 28, 23, 4, -28 },
  { 1995, 15, 29, 23, 4, -29 },
  { 2050, 17, 28, 23, 2, -28 },
  { 2110, 17, 29, 23, 4, -29 },
  { 2172, 16, 28, 23, 5, -28 },
  { 2228, 17, 28, 23, 3, -28 },
  { 2288, 15, 28, 23, 4, -28 },
  { 2341, 16, 29, 23, 4, -29 },
  { 2399, 17, 28, 23, 4, -28 },
  { 2459, 16, 36, 23, 4, -29 },
  { 2531, 17, 28, 23, 4, -28 },
  { 2591, 17, 29, 23, 3, -29 },
  { 2653, 19, 28, 23, 2, -28 },
  { 2720, 15, 28, 23, 4, -28 },
  { 2773, 19, 28, 23, 2, -28 },
  { 2840, 21, 28, 23, 1, -28 },
  { 2914, 20, 28, 23, 2, -28 },
  { 2984, 20, 28, 23, 2, -28 },
  { 3054, 17, 28, 23, 3, -28 },
  { 3114, 9, 36, 23, 8, -32 },
  { 3155, 17, 36, 23, 3, -32 },
  { 3232, 9, 36, 23, 6, -32 },
  { 3273, 16, 15, 23, 4, -28 },
  { 3303, 19, 2, 23, 2, 1 },
  { 3308, 7, 6, 23, 8, -31 },
  { 3314, 16, 22, 23, 3, -22 },
  { 3358, 16, 28, 23, 4, -28 },
  { 3414, 16, 22, 23, 4, -22 },
  { 3458, 15, 28, 23, 4, -28 },
  { 3511, 16, 22, 23, 4, -22 },
  { 3555, 18, 28, 23, 3, -28 },
  { 3618, 15, 29, 23, 4, -22 },
  { 3673, 15, 28, 23, 4, -28 },
  { 3726, 17, 30, 23, 4, -30 },
  { 3790, 14, 37, 23, 4, -30 },
  { 3855, 17, 28, 23, 4, -28 },
  { 3915, 19, 28, 23, 2, -28 },
  { 3982, 18, 22, 23, 3, -22 },
  { 4032, 15, 22, 23, 4, -22 },
  { 4074, 16, 22, 23, 4, -22 },
  { 4118, 16, 29, 23, 4, -22 },
  { 4176, 15, 29, 23, 4, -22 },
  { 4231, 15, 22, 23, 5, -22 },
  { 4273, 16, 22, 23, 4, -22 },
  { 4317, 18, 28, 23, 2, -28 },
  { 4380, 15, 21, 23, 4, -21 },
  { 4420, 18, 21, 23, 3, -21 },
  { 4468, 20, 21, 23, 2, -21 },
  { 4521, 18, 21, 23, 3, -21 },
  { 4569, 18, 28, 23, 3, -21 },
  { 4632, 16, 21, 23, 4, -21 },
  { 4674, 16, 36, 23, 4, -32 },
  { 4746, 3, 36, 23, 10, -32 },
  { 4760, 16, 36, 23, 4, -32 },
  { 4832, 17, 8, 23, 3, -18 },
};

const GFXfont JetBrainsMono_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_EXTRALIGHT39PT7B_H_
