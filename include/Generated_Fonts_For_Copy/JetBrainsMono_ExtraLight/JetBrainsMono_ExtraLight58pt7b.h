#ifndef _JETBRAINSMONO_EXTRALIGHT58PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF,
  0xFE, 0xF8, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x3C, 0xE0, 0x1E,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x07,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xE3, 0x8F, 0xC3,
  0xE1, 0xC3, 0xE1, 0xE0, 0xE0, 0xF9, 0xE0, 0x70, 0x3C, 0xF0, 0x38, 0x1E,
  0x78, 0x1C, 0x07, 0x3C, 0x0E, 0x03, 0xDE, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x81, 0xC0, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x7C, 0x38,
  0x00, 0x1F, 0x1C, 0x00, 0x0F, 0xEE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x39, 0xF8, 0x00, 0x1C, 0x3E, 0x00, 0x0E, 0x0F, 0x80, 0x07, 0x03, 0xC0,
  0x03, 0x81, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1F,
  0xC0, 0x38, 0x0F, 0xF0, 0x1C, 0x07, 0xF8, 0x0E, 0x03, 0xFC, 0x07, 0x01,
  0xFF, 0x03, 0x81, 0xE7, 0x81, 0xC0, 0xF3, 0xF0, 0xE1, 0xF0, 0xFE, 0x71,
  0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x87, 0xFC, 0x00, 0x03, 0x87, 0xFF, 0x00, 0x03,
  0x87, 0xCF, 0xC0, 0x01, 0xC7, 0x81, 0xE0, 0x01, 0xC3, 0x80, 0x70, 0x01,
  0xC1, 0xC0, 0x3C, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x78, 0x38, 0x01, 0xC0, 0x38,
  0x38, 0x00, 0xF0, 0x1C, 0x38, 0x00, 0x3C, 0x3E, 0x3C, 0x00, 0x1F, 0xFE,
  0x1C, 0x00, 0x07, 0xFE, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x07, 0x07, 0xFE, 0x00,
  0x03, 0x87, 0xFF, 0x80, 0x03, 0x87, 0x83, 0xC0, 0x03, 0x87, 0x80, 0xF0,
  0x03, 0xC3, 0xC0, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x0E,
  0x01, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x01,
  0xC0, 0xF0, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x70, 0x03, 0xC0,
  0x38, 0x70, 0x01, 0xE0, 0x3C, 0x78, 0x00, 0x78, 0x3C, 0x38, 0x00, 0x3F,
  0xFE, 0x38, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x03, 0xDE, 0x07, 0x80,
  0x3C, 0xF0, 0x1E, 0x01, 0xE7, 0x80, 0xF8, 0x1E, 0x38, 0x03, 0xC0, 0xF1,
  0xC0, 0x0F, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x70, 0x01, 0xF7, 0x83, 0x80,
  0x07, 0xBC, 0x1C, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x7C, 0x07, 0x00, 0x03,
  0xE0, 0x38, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xF0,
  0x78, 0x00, 0xF7, 0xC3, 0xE0, 0x0F, 0x9E, 0x0F, 0x81, 0xF8, 0x78, 0x3F,
  0xFF, 0x81, 0xE0, 0xFF, 0xF8, 0x0F, 0x83, 0xFF, 0x00, 0x3E, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE,
  0x70, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20,
  0x07, 0x80, 0x08, 0xF0, 0x07, 0x00, 0x79, 0xFC, 0x0E, 0x07, 0xF7, 0xFE,
  0x1C, 0x7F, 0xF3, 0xFF, 0x39, 0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x07, 0xC0, 0xFF, 0x07, 0xE0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x1C, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xF9,
  0xE0, 0x01, 0xF8, 0xF0, 0x01, 0xF8, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x70, 0x0F, 0x00, 0x20, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x3F,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x38, 0x7C, 0x00,
  0x70, 0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x80, 0x03, 0x9E, 0x00, 0x07,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x1F,
  0x80, 0x78, 0xFF, 0xE0, 0x79, 0xFF, 0xF8, 0x7B, 0xFF, 0xFC, 0x7F, 0x80,
  0x7C, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1F, 0x80,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x3F, 0xF0, 0x0F, 0x7F, 0xFE,
  0x07, 0xFC, 0x7F, 0x87, 0xF0, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC7, 0xE0,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x8F, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7E,
  0x01, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x05, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0x3F, 0xFF, 0xBC, 0x0F, 0xFF, 0xBC, 0x01, 0xFF, 0x9E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x08, 0x00, 0x1F, 0xC7, 0xF8, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x03, 0xFF, 0x3F, 0x80, 0x3F, 0xFD, 0xFC, 0x03, 0xE0,
  0x6F, 0xE0, 0x1E, 0x01, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0x00, 0x3F,
  0xC0, 0x78, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0x7F, 0x80,
  0xF0, 0x03, 0xFC, 0x07, 0x80, 0x1F, 0xE0, 0x3C, 0x00, 0xFF, 0x01, 0xE0,
  0x07, 0xF8, 0x0F, 0x00, 0x3F, 0xC0, 0x78, 0x01, 0xFE, 0x03, 0xC0, 0x0F,
  0xF0, 0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x03, 0xFC, 0x03, 0x80, 0x3F, 0xE0,
  0x1E, 0x01, 0xFF, 0x00, 0xFC, 0x3B, 0xF8, 0x03, 0xFF, 0x9F, 0xC0, 0x0F,
  0xF8, 0xFE, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0xFC, 0xF0, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x80, 0x3F, 0x8F, 0x00, 0x1F, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3C, 0x0F,
  0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x01,
  0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0x7E, 0xE0, 0x03, 0xBF, 0x70, 0x01, 0xDF, 0x9C,
  0x01, 0xCF, 0xCE, 0x00, 0xE7, 0xE7, 0x00, 0xF7, 0xF1, 0xC0, 0x73, 0xF8,
  0xE0, 0x39, 0xFC, 0x70, 0x3C, 0xFF, 0x1C, 0x1C, 0x7F, 0x8E, 0x0E, 0x3F,
  0xC7, 0x0F, 0x1F, 0xE1, 0xC7, 0x0F, 0xF0, 0xE3, 0x87, 0xF8, 0x7B, 0x83,
  0xFC, 0x1D, 0xC1, 0xFE, 0x0E, 0xE0, 0xFF, 0x07, 0x60, 0x7F, 0x81, 0xF0,
  0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFE, 0xE0, 0x01, 0xFD, 0xC0, 0x03, 0xFB, 0xC0, 0x07,
  0xF3, 0x80, 0x0F, 0xF7, 0x00, 0x1F, 0xEF, 0x00, 0x3F, 0xCE, 0x00, 0x7F,
  0x9E, 0x00, 0xFF, 0x1C, 0x01, 0xFE, 0x38, 0x03, 0xFC, 0x78, 0x07, 0xF8,
  0x70, 0x0F, 0xF0, 0xF0, 0x1F, 0xE1, 0xE0, 0x3F, 0xC1, 0xC0, 0x7F, 0x83,
  0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0F, 0x07, 0xF8, 0x0E,
  0x0F, 0xF0, 0x1E, 0x1F, 0xE0, 0x3C, 0x3F, 0xC0, 0x38, 0x7F, 0x80, 0x78,
  0xFF, 0x00, 0x71, 0xFE, 0x00, 0xE3, 0xFC, 0x01, 0xE7, 0xF8, 0x01, 0xCF,
  0xF0, 0x03, 0xDF, 0xE0, 0x07, 0xBF, 0xC0, 0x07, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x9E, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1E, 0x1F, 0x80, 0xFC,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x1F,
  0xCF, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE,
  0x00, 0x0F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3F, 0x01, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1E, 0x00, 0x3F, 0x8F, 0x00, 0x07, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x79, 0xF8, 0x00, 0x78, 0x7F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xC7, 0x80,
  0x0F, 0x0F, 0xC0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F,
  0x00, 0x77, 0x80, 0x36, 0x00, 0xE7, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xDC,
  0x03, 0x9C, 0x03, 0xB8, 0x07, 0x38, 0x07, 0x70, 0x1E, 0x78, 0x0E, 0xE0,
  0x3C, 0xF0, 0x1D, 0xC0, 0x79, 0xE0, 0x39, 0x80, 0xF3, 0xC0, 0x63, 0x01,
  0xC3, 0x80, 0xC6, 0x03, 0x87, 0x03, 0x8E, 0x07, 0x0E, 0x07, 0x1C, 0x0E,
  0x1C, 0x0E, 0x38, 0x1C, 0x3C, 0x1C, 0x70, 0x78, 0x78, 0x38, 0xE0, 0xF0,
  0xF0, 0x60, 0xC1, 0xE1, 0xE0, 0xC1, 0x83, 0x83, 0xC1, 0x83, 0x07, 0x03,
  0x87, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x38, 0x1C,
  0x38, 0x38, 0x70, 0x3C, 0x60, 0x71, 0xE0, 0x78, 0xC0, 0x63, 0xC0, 0xF1,
  0x80, 0xC7, 0x01, 0xE7, 0x01, 0x8E, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0x9C,
  0x07, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x60, 0x1C, 0xE0, 0x1C, 0xC0,
  0x3B, 0xC0, 0x3D, 0x80, 0x37, 0x80, 0x7B, 0x00, 0x6E, 0x00, 0xFE, 0x00,
  0xDC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF7,
  0x80, 0x01, 0xE3, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC1,
  0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0x00, 0x03,
  0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xF3, 0xF0, 0x07, 0x78, 0xFF,
  0xFF, 0xBC, 0x3F, 0xFF, 0x9E, 0x07, 0xFF, 0x0F, 0x00, 0x30, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC3, 0xFE, 0x07, 0x9F, 0xFF, 0x0F, 0x7F,
  0xFF, 0x1E, 0xE0, 0x3F, 0x3F, 0x80, 0x1F, 0x7E, 0x00, 0x1E, 0xF8, 0x00,
  0x3D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x80,
  0x0F, 0xBF, 0xC0, 0x7E, 0x7B, 0xFF, 0xF8, 0xF3, 0xFF, 0xE1, 0xE1, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xF8, 0x0F, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xE0, 0x03,
  0xE3, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0xF8, 0x78, 0x7F,
  0xF8, 0xF1, 0xFF, 0xF9, 0xE7, 0xE0, 0x3B, 0xDF, 0x00, 0x3F, 0xBC, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80,
  0x07, 0xEF, 0x80, 0x1F, 0xCF, 0xC0, 0x77, 0x8F, 0xFF, 0xEF, 0x0F, 0xFF,
  0x9E, 0x0F, 0xFC, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0xF3, 0xE0, 0x03, 0xE3, 0xF0, 0x0F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFE, 0x1E, 0x1F, 0xFF, 0x3C, 0x7F, 0xFF,
  0x79, 0xF8, 0x0E, 0xF7, 0xC0, 0x0F, 0xEF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0x7C, 0x00, 0x7E, 0x7C, 0x03, 0xBC, 0xFF, 0xFF, 0x78, 0xFF, 0xFC,
  0xF0, 0x7F, 0xF1, 0xE0, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC3, 0xFE,
  0x07, 0x9F, 0xFF, 0x0F, 0x7F, 0xFF, 0x1E, 0xE0, 0x3F, 0x3F, 0x00, 0x1F,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xC0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0xF3, 0xF8, 0x7F, 0x1E, 0xFF, 0x9F, 0xF3,
  0xFF, 0xF7, 0xFE, 0x7C, 0x1F, 0xC3, 0xEF, 0x81, 0xF0, 0x3D, 0xE0, 0x3C,
  0x03, 0xBC, 0x03, 0x80, 0x77, 0x80, 0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xFE,
  0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0xE0,
  0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x70, 0x0F, 0xF0,
  0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8, 0x07, 0x00,
  0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x7F, 0x80,
  0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07,
  0xF8, 0x07, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03,
  0x80, 0x7F, 0x80, 0x70, 0x0F, 0xF0, 0xFF, 0x81, 0xE7, 0xFF, 0xC3, 0xDF,
  0xFF, 0xC7, 0xB8, 0x0F, 0xCF, 0xE0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xF8, 0x0F,
  0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xC3, 0xF0, 0x1F,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0xF0, 0xFF, 0x81, 0xE7, 0xFF, 0xC3, 0xDF, 0xFF, 0xC7, 0xB8, 0x0F, 0xCF,
  0xE0, 0x07, 0xDF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xE0, 0x03, 0xEF, 0xF0, 0x1F, 0x9E,
  0xFF, 0xFE, 0x3C, 0xFF, 0xF8, 0x78, 0x7F, 0xC0, 0xF0, 0x08, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x1E, 0x1F, 0xFE, 0x3C, 0x7F, 0xFF, 0x79, 0xF8, 0x0E,
  0xF7, 0xC0, 0x0F, 0xEF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xFB, 0xE0, 0x07, 0xF3, 0xF0, 0x1D,
  0xE3, 0xFF, 0xFB, 0xC3, 0xFF, 0xE7, 0x83, 0xFF, 0x0F, 0x00, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0xF0, 0xFF, 0x81, 0xE7, 0xFF, 0xC3, 0xDF, 0xFF, 0xC7, 0xB8,
  0x0F, 0xCF, 0xC0, 0x07, 0xDF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xC3, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x80,
  0x03, 0xE3, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xF1, 0xE0, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x00, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0xD8,
  0x07, 0xF8, 0x06, 0xC0, 0x39, 0xC0, 0x76, 0x01, 0xCE, 0x03, 0xB8, 0x0E,
  0x70, 0x1D, 0xC0, 0xF3, 0xC0, 0xCE, 0x07, 0x9E, 0x06, 0x30, 0x3C, 0xF0,
  0x71, 0x81, 0xC3, 0x83, 0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x70, 0xE0, 0xC3,
  0x83, 0x87, 0x86, 0x0C, 0x3C, 0x3C, 0x30, 0x61, 0xC1, 0xE3, 0x83, 0x0E,
  0x07, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0xE3, 0x81, 0xC6, 0x07, 0x1C, 0x0E,
  0x30, 0x19, 0xE0, 0x79, 0x80, 0xCE, 0x03, 0xDC, 0x07, 0x70, 0x0E, 0xE0,
  0x3B, 0x80, 0x77, 0x01, 0xDC, 0x03, 0xB0, 0x0E, 0xE0, 0x1D, 0x80, 0x37,
  0x00, 0xEC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xC7, 0xFC, 0x00, 0x73, 0xFF, 0x80, 0x1D, 0xF1, 0xF0,
  0x07, 0x78, 0x3E, 0x01, 0xDC, 0x07, 0xC0, 0x7F, 0x00, 0xF8, 0x3F, 0xC0,
  0x1F, 0x1F, 0xF0, 0x03, 0xFF, 0xBC, 0x00, 0x7F, 0xCF, 0x00, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 7, 42, 35, 14, -42 },
  { 38, 17, 17, 35, 9, -42 },
  { 75, 31, 42, 35, 2, -42 },
  { 238, 25, 58, 35, 5, -50 },
  { 420, 33, 43, 35, 1, -43 },
  { 598, 29, 44, 35, 4, -43 },
  { 758, 5, 17, 35, 15, -42 },
  { 769, 17, 56, 35, 11, -49 },
  { 888, 16, 56, 35, 7, -49 },
  { 1000, 31, 29, 35, 2, -35 },
  { 1113, 27, 27, 35, 4, -33 },
  { 1205, 11, 18, 35, 10, -9 },
  { 1230, 19, 4, 35, 8, -21 },
  { 1240, 9, 9, 35, 13, -8 },
  { 1251, 25, 54, 35, 5, -48 },
  { 1420, 25, 44, 35, 5, -43 },
  { 1558, 25, 42, 35, 6, -42 },
  { 1690, 26, 43, 35, 5, -43 },
  { 1830, 24, 43, 35, 5, -42 },
  { 1959, 23, 42, 35, 5, -42 },
  { 2080, 24, 43, 35, 5, -42 },
  { 2209, 25, 43, 35, 5, -42 },
  { 2344, 26, 42, 35, 5, -42 },
  { 2481, 25, 44, 35, 5, -43 },
  { 2619, 25, 43, 35, 5, -43 },
  { 2754, 9, 33, 35, 13, -32 },
  { 2792, 11, 41, 35, 11, -32 },
  { 2849, 25, 30, 35, 5, -34 },
  { 2943, 25, 17, 35, 5, -28 },
  { 2997, 25, 30, 35, 5, -34 },
  { 3091, 20, 42, 35, 9, -42 },
  { 3196, 29, 53, 35, 3, -43 },
  { 3389, 27, 42, 35, 4, -42 },
  { 3531, 24, 42, 35, 6, -42 },
  { 3657, 24, 44, 35, 6, -43 },
  { 3789, 23, 42, 35, 6, -42 },
  { 3910, 24, 42, 35, 6, -42 },
  { 4036, 24, 42, 35, 6, -42 },
  { 4162, 24, 44, 35, 6, -43 },
  { 4294, 23, 42, 35, 6, -42 },
  { 4415, 21, 42, 35, 7, -42 },
  { 4526, 25, 43, 35, 3, -42 },
  { 4661, 26, 42, 35, 6, -42 },
  { 4798, 24, 42, 35, 7, -42 },
  { 4924, 25, 42, 35, 5, -42 },
  { 5056, 23, 42, 35, 6, -42 },
  { 5177, 23, 44, 35, 6, -43 },
  { 5304, 25, 42, 35, 6, -42 },
  { 5436, 24, 53, 35, 6, -43 },
  { 5595, 25, 42, 35, 6, -42 },
  { 5727, 25, 44, 35, 5, -43 },
  { 5865, 28, 42, 35, 3, -42 },
  { 6012, 23, 43, 35, 6, -42 },
  { 6136, 27, 42, 35, 4, -42 },
  { 6278, 31, 42, 35, 2, -42 },
  { 6441, 29, 42, 35, 3, -42 },
  { 6594, 29, 42, 35, 3, -42 },
  { 6747, 25, 42, 35, 5, -42 },
  { 6879, 14, 54, 35, 12, -48 },
  { 6974, 25, 54, 35, 5, -48 },
  { 7143, 13, 54, 35, 9, -48 },
  { 7231, 24, 22, 35, 5, -42 },
  { 7297, 28, 4, 35, 3, 1 },
  { 7311, 11, 9, 35, 11, -46 },
  { 7324, 25, 33, 35, 4, -32 },
  { 7428, 23, 43, 35, 6, -42 },
  { 7552, 23, 33, 35, 6, -32 },
  { 7647, 23, 43, 35, 6, -42 },
  { 7771, 23, 33, 35, 6, -32 },
  { 7866, 27, 42, 35, 4, -42 },
  { 8008, 23, 42, 35, 6, -32 },
  { 8129, 23, 42, 35, 6, -42 },
  { 8250, 27, 45, 35, 5, -45 },
  { 8402, 21, 55, 35, 5, -45 },
  { 8547, 25, 42, 35, 6, -42 },
  { 8679, 30, 42, 35, 2, -42 },
  { 8837, 27, 32, 35, 4, -32 },
  { 8945, 23, 32, 35, 6, -32 },
  { 9037, 23, 33, 35, 6, -32 },
  { 9132, 23, 42, 35, 6, -32 },
  { 9253, 23, 42, 35, 6, -32 },
  { 9374, 23, 32, 35, 7, -32 },
  { 9466, 25, 33, 35, 5, -32 },
  { 9570, 26, 41, 35, 4, -41 },
  { 9704, 23, 33, 35, 6, -32 },
  { 9799, 27, 32, 35, 4, -32 },
  { 9907, 29, 32, 35, 3, -32 },
  { 10023, 27, 32, 35, 4, -32 },
  { 10131, 27, 42, 35, 4, -32 },
  { 10273, 23, 32, 35, 6, -32 },
  { 10365, 24, 54, 35, 5, -48 },
  { 10527, 4, 54, 35, 15, -48 },
  { 10554, 24, 54, 35, 5, -48 },
  { 10716, 26, 11, 35, 4, -26 },
};

const GFXfont JetBrainsMono_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_EXTRALIGHT58PT7B_H_
