#ifndef _JETBRAINSMONO_EXTRALIGHT44PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xF7,
  0xDE, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0xC0, 0x38,
  0x01, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x18, 0x07, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x80, 0xE0, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0,
  0x18, 0x01, 0xC0, 0x70, 0x03, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x38, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x38, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x0E, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x60, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF8,
  0x3E, 0xCF, 0x8F, 0x18, 0x71, 0xC3, 0x07, 0x38, 0x60, 0xEE, 0x0C, 0x1D,
  0xC1, 0x81, 0xB8, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0F, 0x18, 0x00,
  0xF3, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x06, 0xF8, 0x00, 0xC7, 0x80, 0x18, 0x78, 0x03, 0x07, 0x00, 0x60, 0xF0,
  0x0C, 0x0E, 0x01, 0x81, 0xF0, 0x30, 0x3F, 0x06, 0x07, 0xE0, 0xC1, 0xFE,
  0x18, 0x39, 0xE3, 0x0F, 0x1F, 0x67, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0x80, 0x03, 0xBF, 0xE0, 0x03, 0x1C, 0x38, 0x03, 0x9C,
  0x0C, 0x01, 0x8E, 0x07, 0x01, 0x87, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0xC1,
  0xC0, 0xE0, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0xE0, 0x38, 0x18, 0x60,
  0x0E, 0x1C, 0x70, 0x07, 0xFC, 0x70, 0x00, 0xFC, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x1C,
  0x7F, 0x00, 0x1C, 0x7F, 0xC0, 0x0C, 0x70, 0x70, 0x0E, 0x30, 0x38, 0x0E,
  0x18, 0x0C, 0x06, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x07, 0x03, 0x01, 0x83,
  0x01, 0x80, 0xC3, 0x00, 0xC0, 0x63, 0x80, 0x70, 0x71, 0x80, 0x3C, 0x79,
  0x80, 0x0F, 0xF9, 0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xC7, 0x00, 0xEE, 0x0E, 0x03, 0xB8, 0x1C,
  0x1C, 0xE0, 0x78, 0xF3, 0x80, 0xE3, 0x8E, 0x01, 0xDC, 0x38, 0x03, 0xF0,
  0xE0, 0x0F, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xF0, 0xE0,
  0x0F, 0xC3, 0xC0, 0x73, 0x87, 0x87, 0x87, 0x0F, 0xFC, 0x1E, 0x1F, 0xE0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x60, 0x00, 0x10, 0x0F, 0x01,
  0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x1C, 0x0E, 0xFC, 0x30, 0x7D, 0xFE, 0x67,
  0xFC, 0x7F, 0xDF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0xE7, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x0F, 0x00,
  0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x0F, 0xC7,
  0x80, 0x78, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x10, 0x3F, 0x0F, 0x07, 0xE1, 0xF0, 0xFC, 0x3C, 0x1F, 0x87, 0x83, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x00, 0xE7, 0x00, 0x3C, 0xF0,
  0x0F, 0x0F, 0xC7, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF7, 0x00, 0x3C, 0x70, 0x07, 0x87, 0x00,
  0xF0, 0x70, 0x0C, 0x07, 0x00, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xE0, 0x7C, 0x3C, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3B, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87, 0xC1,
  0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC7, 0xF0, 0x77, 0xFE, 0x1F, 0xFF, 0xC7,
  0xC0, 0x79, 0xE0, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87, 0xC1,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x10,
  0x01, 0xDF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0, 0x7C, 0x3C, 0x01, 0xE7, 0x80,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xE3,
  0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0x07, 0x87, 0x80, 0x38, 0xE0, 0x07, 0x9C, 0x00, 0x73, 0x00, 0x0E, 0x60,
  0x01, 0xCC, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x38,
  0x1E, 0x03, 0xC7, 0x80, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x78,
  0x78, 0x1E, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xEF, 0x00,
  0x1C, 0xF0, 0x07, 0x0F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0x78, 0x3C, 0x01, 0xC3,
  0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0xE7, 0x80, 0x0E, 0x3C, 0x01, 0xE1, 0xE0, 0x7C, 0x1F, 0xFD, 0xC0, 0x7F,
  0xB8, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFB,
  0xF7, 0xFF, 0xDF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xCF, 0xDF, 0xFF, 0xFE, 0x7C, 0x0E, 0x1F, 0x8F, 0xE7,
  0xF3, 0xF9, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3C, 0x07, 0xC3, 0xC0, 0x0E, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x03, 0xF9, 0xE0, 0x3F, 0xEF, 0x03, 0xC1, 0x78, 0x1C, 0x07, 0xC0, 0xE0,
  0x3E, 0x06, 0x01, 0xF0, 0x30, 0x07, 0x81, 0x80, 0x3C, 0x0C, 0x01, 0xE0,
  0x60, 0x0F, 0x03, 0x00, 0x78, 0x18, 0x03, 0xC0, 0xC0, 0x3E, 0x07, 0x01,
  0xF0, 0x38, 0x0F, 0x81, 0xE0, 0xBC, 0x07, 0xFD, 0xE0, 0x1F, 0xCF, 0x00,
  0x10, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x73,
  0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0x60, 0x03, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x01, 0xC0, 0x1C, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x00, 0x18, 0x38, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x00,
  0x3C, 0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x03,
  0xB0, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x1E, 0xC0, 0x07, 0x30, 0x07, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xFE, 0x30, 0x03, 0xCC, 0x00, 0x7B, 0x00,
  0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3B, 0x00, 0x1E, 0xC0, 0x0F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0x07, 0xC7, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x38, 0x00, 0xE7, 0x00,
  0x3C, 0x70, 0x07, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x18, 0x03, 0xCC, 0x00, 0xF6, 0x00, 0x3B,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xD8, 0x01, 0xEC, 0x01,
  0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x3C, 0x70, 0x07, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0x8F, 0x87, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF0, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x0E, 0x60, 0x01, 0xCC,
  0x00, 0x71, 0x80, 0x0E, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x1C, 0x18,
  0x03, 0x83, 0x00, 0xE0, 0x60, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xE0, 0x60,
  0x1C, 0x0C, 0x03, 0x81, 0x80, 0x38, 0x30, 0x07, 0x06, 0x00, 0x70, 0xC0,
  0x0E, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x01, 0xCC, 0x00, 0x39, 0x80,
  0x03, 0xB0, 0x00, 0x76, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xEC, 0x03, 0xFD, 0x80, 0x6F, 0xB8, 0x0D, 0xF3, 0x03, 0xBE, 0x60,
  0x67, 0xCE, 0x0C, 0xF8, 0xC3, 0x9F, 0x1C, 0x63, 0xF3, 0x8C, 0x7E, 0x33,
  0x8F, 0xC7, 0x61, 0xF8, 0x6C, 0x3F, 0x0F, 0x87, 0xE1, 0xE0, 0xFC, 0x1C,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xEC, 0x01, 0xFB, 0x80, 0x7E,
  0xE0, 0x1F, 0x98, 0x07, 0xE7, 0x01, 0xF9, 0xC0, 0x7E, 0x30, 0x1F, 0x8E,
  0x07, 0xE1, 0x81, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x83, 0x07, 0xE0, 0xE1,
  0xF8, 0x38, 0x7E, 0x07, 0x1F, 0x81, 0xC7, 0xE0, 0x31, 0xF8, 0x0E, 0x7E,
  0x03, 0x9F, 0x80, 0x67, 0xE0, 0x1D, 0xF8, 0x03, 0x7E, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x60,
  0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xE7,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0,
  0x07, 0x70, 0x03, 0x8E, 0x01, 0xE3, 0xE1, 0xF0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x60, 0x03, 0xCC, 0x00,
  0x3D, 0x80, 0x03, 0xB0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80, 0x07, 0xB0, 0x01,
  0xE6, 0x01, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x07, 0x1C, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0x38, 0xF0, 0x0F, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x60, 0x03, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x76,
  0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEC,
  0x00, 0x3D, 0x80, 0x07, 0x30, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x03, 0x81, 0x80, 0x70, 0x30,
  0x07, 0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x3C, 0x60,
  0x03, 0x8C, 0x00, 0x79, 0x80, 0x07, 0x30, 0x00, 0xF6, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x38, 0xE0,
  0x03, 0x9C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1C, 0xF0, 0x07, 0x8F, 0x83,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x38, 0x07, 0x8F,
  0x87, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x38,
  0x03, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00,
  0x0C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x1C, 0x07, 0x60, 0x3C, 0x07,
  0x70, 0x3C, 0x07, 0x70, 0x34, 0x06, 0x70, 0x36, 0x06, 0x70, 0x36, 0x06,
  0x70, 0x36, 0x0E, 0x70, 0x36, 0x0E, 0x30, 0x66, 0x0E, 0x30, 0x66, 0x0E,
  0x30, 0x66, 0x0E, 0x38, 0x66, 0x0E, 0x38, 0x63, 0x0C, 0x38, 0x63, 0x0C,
  0x38, 0x63, 0x0C, 0x38, 0x63, 0x1C, 0x18, 0xC3, 0x1C, 0x18, 0xC3, 0x1C,
  0x18, 0xC3, 0x1C, 0x1C, 0xC1, 0x9C, 0x1C, 0xC1, 0x98, 0x1C, 0xC1, 0x98,
  0x1C, 0xC1, 0x98, 0x1D, 0x81, 0x98, 0x1D, 0x81, 0xB8, 0x0D, 0x81, 0xB8,
  0x0D, 0x81, 0xB8, 0x0D, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xF0,
  0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x73, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x71,
  0xC0, 0x38, 0x70, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x60, 0x1C,
  0x38, 0x07, 0x0E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07, 0xE0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F,
  0x03, 0xC3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x77, 0x00, 0x1E, 0xF0, 0x07, 0xCF, 0x03, 0xB8, 0xFF,
  0xF7, 0x0F, 0xF8, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0xC0, 0xC7, 0xF8, 0x67,
  0xFF, 0x36, 0x07, 0xDE, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xED, 0x00, 0xF6, 0xE0, 0xF3, 0x3F, 0xF1, 0x8F, 0xF0,
  0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x03, 0x9C,
  0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0xDE,
  0x01, 0xE3, 0xF1, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x06, 0x07, 0x0F, 0xF9, 0xC7, 0xFF, 0x73, 0xC0, 0xDD, 0xE0, 0x1F,
  0x70, 0x03, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0F,
  0x78, 0x07, 0xCF, 0x83, 0x71, 0xFF, 0xDC, 0x3F, 0xC7, 0x01, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0x70, 0x03, 0xDE, 0x00, 0xE3, 0xE0,
  0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x71, 0xFF, 0xDC, 0xF0, 0x37, 0x78,
  0x07, 0xDC, 0x00, 0xF7, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1F, 0x3E,
  0x1D, 0xC7, 0xFE, 0x70, 0xFF, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0xC0, 0xC7, 0xF8,
  0x67, 0xFF, 0x36, 0x07, 0xDA, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xDC,
  0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x3C, 0x38,
  0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0,
  0x3C, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x8E, 0x00, 0x79, 0xC0,
  0x07, 0x38, 0x00, 0xF7, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0x01,
  0x0E, 0xFC, 0x7C, 0xFF, 0xEF, 0xEF, 0x0F, 0x0F, 0xE0, 0x70, 0x7E, 0x07,
  0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60,
  0x70, 0x00, 0xE0, 0x63, 0xFC, 0x33, 0xFF, 0x9B, 0x83, 0xED, 0x00, 0xF7,
  0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0xE1, 0xF0, 0x7F,
  0xF8, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x63, 0xFC, 0x33, 0xFF, 0x9B, 0x03,
  0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x76, 0x80, 0x7B, 0x70, 0x79, 0x9F, 0xF8, 0xC7, 0xF8, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x71, 0xFF, 0xDC, 0xF0, 0x37,
  0x78, 0x07, 0xDC, 0x00, 0xF7, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x0F,
  0x70, 0x03, 0xDE, 0x01, 0xF3, 0xE0, 0xDC, 0x7F, 0xF7, 0x0F, 0xF1, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x38, 0xFF, 0x0E, 0xFF,
  0xF3, 0xB0, 0x3C, 0xF8, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E, 0x03,
  0xC7, 0x00, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xF0, 0x00, 0x6F, 0x00, 0x1C, 0xE0, 0x03, 0x9F, 0x01, 0xE1, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D,
  0xC0, 0x0E, 0x38, 0x07, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xE0,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x81, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x06,
  0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xC0, 0x03, 0x9C, 0x00, 0x1D,
  0xC0, 0x01, 0xD8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xE0,
  0x38, 0x0F, 0x81, 0xE0, 0x3E, 0x07, 0x81, 0xD8, 0x1E, 0x07, 0x60, 0x68,
  0x1D, 0xC1, 0xB0, 0x77, 0x06, 0xC1, 0x9C, 0x33, 0x06, 0x70, 0xCC, 0x38,
  0xC3, 0x30, 0xE3, 0x0C, 0x63, 0x8C, 0x31, 0x8C, 0x39, 0x86, 0x30, 0xE6,
  0x18, 0xC3, 0x98, 0x63, 0x06, 0x61, 0x9C, 0x19, 0x83, 0x70, 0x66, 0x0D,
  0x81, 0xF0, 0x36, 0x07, 0xC0, 0xD8, 0x1F, 0x03, 0x60, 0x3C, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0xF0, 0x00, 0xF1, 0xC0, 0x07, 0x0F, 0x00,
  0x70, 0x38, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x83, 0x80, 0x1C, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0xDC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07,
  0x0E, 0x00, 0x78, 0x38, 0x03, 0x81, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x1C,
  0x1C, 0x00, 0xF1, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x1C,
  0x01, 0xC1, 0xC0, 0x3C, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0x80, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x73, 0xF8, 0x07, 0x7F, 0xC0, 0x77, 0x0E, 0x07, 0xE0, 0x70,
  0x7E, 0x07, 0x87, 0xE0, 0x3F, 0xEE, 0x01, 0xFE, 0xE0, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 32, 26, 10, -32 },
  { 25, 12, 13, 26, 7, -32 },
  { 45, 23, 32, 26, 2, -32 },
  { 137, 19, 44, 26, 4, -38 },
  { 242, 25, 32, 26, 1, -32 },
  { 342, 22, 33, 26, 3, -33 },
  { 433, 4, 13, 26, 11, -32 },
  { 440, 12, 42, 26, 9, -37 },
  { 503, 13, 42, 26, 5, -37 },
  { 572, 23, 23, 26, 2, -27 },
  { 639, 20, 21, 26, 3, -25 },
  { 692, 8, 14, 26, 8, -7 },
  { 706, 14, 3, 26, 6, -16 },
  { 712, 7, 6, 26, 10, -6 },
  { 718, 19, 42, 26, 4, -37 },
  { 818, 19, 33, 26, 4, -33 },
  { 897, 20, 32, 26, 4, -32 },
  { 977, 20, 33, 26, 3, -33 },
  { 1060, 18, 32, 26, 4, -32 },
  { 1132, 18, 32, 26, 4, -32 },
  { 1204, 18, 32, 26, 4, -32 },
  { 1276, 20, 32, 26, 3, -32 },
  { 1356, 19, 32, 26, 4, -32 },
  { 1432, 19, 33, 26, 4, -33 },
  { 1511, 20, 33, 26, 3, -33 },
  { 1594, 7, 25, 26, 10, -25 },
  { 1616, 9, 32, 26, 8, -25 },
  { 1652, 19, 23, 26, 4, -26 },
  { 1707, 18, 13, 26, 4, -21 },
  { 1737, 19, 23, 26, 4, -26 },
  { 1792, 15, 32, 26, 7, -32 },
  { 1852, 21, 41, 26, 3, -33 },
  { 1960, 21, 32, 26, 3, -32 },
  { 2044, 18, 32, 26, 5, -32 },
  { 2116, 19, 33, 26, 4, -33 },
  { 2195, 17, 32, 26, 5, -32 },
  { 2263, 18, 32, 26, 5, -32 },
  { 2335, 18, 32, 26, 5, -32 },
  { 2407, 19, 33, 26, 4, -33 },
  { 2486, 17, 32, 26, 5, -32 },
  { 2554, 16, 32, 26, 5, -32 },
  { 2618, 18, 32, 26, 3, -32 },
  { 2690, 19, 32, 26, 5, -32 },
  { 2766, 18, 32, 26, 5, -32 },
  { 2838, 19, 32, 26, 4, -32 },
  { 2914, 18, 32, 26, 4, -32 },
  { 2986, 18, 33, 26, 4, -33 },
  { 3061, 19, 32, 26, 5, -32 },
  { 3137, 19, 41, 26, 4, -33 },
  { 3235, 19, 32, 26, 5, -32 },
  { 3311, 19, 33, 26, 4, -33 },
  { 3390, 21, 32, 26, 3, -32 },
  { 3474, 18, 32, 26, 4, -32 },
  { 3546, 21, 32, 26, 3, -32 },
  { 3630, 24, 32, 26, 1, -32 },
  { 3726, 22, 32, 26, 2, -32 },
  { 3814, 22, 32, 26, 2, -32 },
  { 3902, 18, 32, 26, 4, -32 },
  { 3974, 11, 42, 26, 9, -37 },
  { 4032, 19, 42, 26, 4, -37 },
  { 4132, 10, 42, 26, 7, -37 },
  { 4185, 18, 17, 26, 4, -32 },
  { 4224, 21, 3, 26, 3, 1 },
  { 4232, 9, 7, 26, 8, -35 },
  { 4240, 19, 25, 26, 3, -25 },
  { 4300, 17, 32, 26, 5, -32 },
  { 4368, 18, 25, 26, 4, -25 },
  { 4425, 18, 32, 26, 4, -32 },
  { 4497, 18, 25, 26, 4, -25 },
  { 4554, 20, 32, 26, 3, -32 },
  { 4634, 18, 33, 26, 4, -25 },
  { 4709, 17, 32, 26, 5, -32 },
  { 4777, 20, 34, 26, 4, -34 },
  { 4862, 16, 42, 26, 4, -34 },
  { 4946, 19, 32, 26, 5, -32 },
  { 5022, 22, 32, 26, 2, -32 },
  { 5110, 20, 25, 26, 3, -25 },
  { 5173, 17, 25, 26, 5, -25 },
  { 5227, 18, 25, 26, 4, -25 },
  { 5284, 17, 33, 26, 5, -25 },
  { 5355, 18, 33, 26, 4, -25 },
  { 5430, 18, 25, 26, 5, -25 },
  { 5487, 19, 25, 26, 4, -25 },
  { 5547, 19, 31, 26, 3, -31 },
  { 5621, 18, 24, 26, 4, -24 },
  { 5675, 20, 24, 26, 3, -24 },
  { 5735, 22, 24, 26, 2, -24 },
  { 5801, 21, 24, 26, 3, -24 },
  { 5864, 20, 32, 26, 3, -24 },
  { 5944, 18, 24, 26, 4, -24 },
  { 5998, 18, 42, 26, 4, -37 },
  { 6093, 3, 42, 26, 12, -37 },
  { 6109, 18, 42, 26, 4, -37 },
  { 6204, 20, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_EXTRALIGHT44PT7B_H_
