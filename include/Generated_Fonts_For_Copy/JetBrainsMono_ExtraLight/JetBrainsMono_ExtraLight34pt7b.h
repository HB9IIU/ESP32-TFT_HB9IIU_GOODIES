#ifndef _JETBRAINSMONO_EXTRALIGHT34PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x06,
  0xFF, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x61, 0xD8, 0x76, 0x1D, 0x87,
  0x60, 0xD8, 0x30, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0xC0, 0x80, 0x60, 0x61, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1,
  0x81, 0x80, 0x60, 0x40, 0x10, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0x81, 0x80, 0x60, 0x60,
  0x18, 0x18, 0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x01, 0xFC, 0x0F,
  0xFC, 0x3C, 0x9C, 0x61, 0x1C, 0xC2, 0x1B, 0x84, 0x37, 0x08, 0x06, 0x10,
  0x0C, 0x20, 0x1C, 0x40, 0x1E, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xC0,
  0x09, 0xC0, 0x11, 0xC0, 0x21, 0x80, 0x43, 0x80, 0x87, 0xC1, 0x0F, 0x82,
  0x1B, 0x84, 0x33, 0x88, 0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x6F, 0xE0, 0x1B, 0x0C,
  0x06, 0x60, 0xC0, 0x8C, 0x18, 0x31, 0x83, 0x0C, 0x30, 0x63, 0x06, 0x0C,
  0x60, 0xC1, 0x98, 0x0E, 0xE6, 0x01, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x67, 0xE0, 0x19, 0xFE, 0x02, 0x30, 0xC0, 0xC6,
  0x18, 0x30, 0x81, 0x0C, 0x10, 0x21, 0x82, 0x04, 0x60, 0x61, 0x98, 0x0C,
  0x33, 0x01, 0xFE, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x0E, 0x0E,
  0x06, 0x03, 0x03, 0x01, 0xC1, 0x80, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x07, 0x70, 0x07, 0x1C, 0x1F,
  0x06, 0x0D, 0x81, 0x8C, 0xC0, 0xEE, 0x60, 0x3E, 0x30, 0x0F, 0x18, 0x03,
  0x0C, 0x03, 0xC7, 0x03, 0xF1, 0x83, 0x98, 0xFF, 0x86, 0x3F, 0x83, 0x80,
  0xFF, 0xFF, 0xF0, 0x00, 0x80, 0xC1, 0xE1, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0x00, 0x80, 0x80, 0x38, 0x0F, 0x80, 0xF0, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x30,
  0x17, 0x8C, 0x3F, 0xFB, 0x3F, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x0E, 0x00,
  0x06, 0xC0, 0x03, 0x38, 0x01, 0xC6, 0x00, 0xE1, 0xC0, 0x30, 0x38, 0x1C,
  0x06, 0x02, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x1C, 0xF3, 0x8E, 0x31, 0xC7, 0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFC, 0x77,
  0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x0F,
  0xE0, 0xFF, 0xC7, 0x83, 0x98, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xE3, 0xC7, 0x8F, 0x0E, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0D,
  0x80, 0x77, 0x03, 0x8F, 0xFC, 0x1F, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x7E,
  0x01, 0xCC, 0x07, 0x18, 0x1C, 0x30, 0x20, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xE1, 0xC0, 0xE7,
  0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x67, 0x03, 0x8F, 0xFC, 0x1F,
  0xE0, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x07, 0x38, 0x1D,
  0xC0, 0x76, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x7F, 0xF9, 0xFF,
  0xE6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x9F, 0x86, 0xFF, 0x9E, 0x0E, 0x70, 0x1D, 0x80, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xE0, 0x0D, 0x80, 0x77,
  0x03, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xDF, 0x83, 0xFF, 0x87, 0x03, 0x9C, 0x03, 0xB8, 0x03, 0x60, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xCC, 0x03, 0x9C, 0x0E,
  0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xD8, 0x03, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0x83, 0x98, 0x07, 0x60, 0x0F,
  0x80, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x18, 0xC0, 0xE1, 0xC7, 0x03, 0xF0,
  0x07, 0xC0, 0x73, 0x83, 0x83, 0x98, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x77, 0x03, 0x8F, 0xFE, 0x1F, 0xE0, 0x0F,
  0xC0, 0x7F, 0xE1, 0xE0, 0xE3, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x37, 0x00, 0xE7, 0x03, 0xC7,
  0xFF, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0xF7, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x9E, 0xFF, 0xFC, 0x3C, 0x7D,
  0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1E,
  0x38, 0x70, 0xE3, 0x87, 0x0C, 0x18, 0x60, 0x00, 0x04, 0x00, 0x30, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xC0,
  0x00, 0xFE, 0x0F, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x1F, 0xC1, 0xF0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xE6,
  0x00, 0x33, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7E,
  0xF0, 0x71, 0x78, 0x30, 0x7C, 0x30, 0x1E, 0x18, 0x0F, 0x0C, 0x07, 0x86,
  0x03, 0xC3, 0x01, 0xE1, 0x80, 0xF0, 0xC0, 0x78, 0x70, 0x7C, 0x18, 0x3E,
  0x0F, 0xEF, 0x03, 0xE7, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x70, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x0E, 0x30,
  0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE3, 0x81, 0xE7, 0x00, 0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03,
  0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0xE7, 0xFF, 0x8F, 0xFF, 0x1C,
  0x0F, 0x38, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xDC, 0x03, 0xB8, 0x0E, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xE0,
  0xFF, 0xC3, 0x83, 0x9C, 0x07, 0x60, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0x60, 0x0D, 0x80,
  0x77, 0x03, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xFF, 0x8E, 0x0F, 0x38,
  0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x07, 0x3F, 0xF8,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xEF, 0xFF, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0x83, 0x9C, 0x07, 0x60, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x87, 0xFE, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0x60, 0x0D, 0x80, 0x77, 0x03, 0x8F, 0xFC, 0x0F, 0xE0, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0C, 0xFF, 0xFF, 0xFF, 0xC1, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x6E, 0x00, 0xCC, 0x03, 0x9C, 0x0E, 0x1F, 0xF8, 0x1F, 0xE0, 0xE0,
  0x06, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0x30, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xE1, 0xC0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70, 0xE0,
  0x30, 0xE0, 0x38, 0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0,
  0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0x7C, 0x0D, 0xD8, 0x37, 0x60, 0x9D, 0x86, 0xF3, 0x1B, 0xCC,
  0x4F, 0x33, 0x3C, 0x6C, 0xF1, 0xA3, 0xC3, 0x8F, 0x0E, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xB0, 0x3E, 0xC0, 0xFB, 0x03, 0xE6, 0x0F, 0x98, 0x3E, 0x60,
  0xF8, 0xC3, 0xE3, 0x0F, 0x86, 0x3E, 0x18, 0xF8, 0x63, 0xE0, 0xCF, 0x83,
  0x3E, 0x0C, 0xF8, 0x1B, 0xE0, 0x6F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1C, 0x0F, 0xC0, 0xFF, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0x60, 0x0D, 0x80, 0x77, 0x03, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0xE1, 0xFF,
  0xF3, 0x80, 0xF7, 0x00, 0x6E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xEF, 0xFF, 0x9F, 0xFE, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xE1,
  0xE0, 0xE3, 0x00, 0xC6, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x37, 0x00, 0x6E, 0x00, 0xCC,
  0x03, 0x9C, 0x0E, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0x81,
  0xE7, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x77, 0x01, 0xEF, 0xFF, 0x9F, 0xFC, 0x38, 0x30, 0x70,
  0x60, 0xE0, 0xE1, 0xC0, 0xC3, 0x81, 0xC7, 0x01, 0x8E, 0x03, 0x9C, 0x03,
  0x38, 0x07, 0x70, 0x06, 0xE0, 0x0E, 0x0F, 0xE0, 0x7F, 0xE1, 0xE0, 0xE3,
  0x00, 0xE6, 0x00, 0xDC, 0x01, 0xB8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xDC, 0x01, 0x9C,
  0x07, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0x80, 0x67, 0x03, 0x8F,
  0xFC, 0x0F, 0xE0, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x70,
  0x06, 0x70, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x38, 0x0C, 0x18, 0x0C, 0x18,
  0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0E,
  0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xC0, 0xE0, 0xF0, 0x38, 0x3E, 0x0E, 0x0D,
  0x83, 0x83, 0x61, 0xA0, 0xD8, 0x68, 0x36, 0x1A, 0x1D, 0x86, 0xC6, 0x61,
  0x31, 0x98, 0x4C, 0x66, 0x13, 0x18, 0xCC, 0xC6, 0x33, 0x11, 0x8C, 0xC4,
  0x63, 0x31, 0x18, 0xC8, 0x6C, 0x32, 0x1B, 0x0C, 0x86, 0xC3, 0x21, 0xB0,
  0xD8, 0x2C, 0x1E, 0x0B, 0x07, 0x82, 0xC1, 0xC0, 0xB0, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0xE0, 0x03, 0x30, 0x03, 0x9C, 0x01, 0x86, 0x01, 0x81, 0x81,
  0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x1C, 0x60, 0x06, 0x70, 0x03, 0xB0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x0C, 0xC0,
  0x0E, 0x30, 0x06, 0x1C, 0x07, 0x06, 0x03, 0x03, 0x83, 0x80, 0xC1, 0x80,
  0x71, 0xC0, 0x19, 0xC0, 0x0E, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xD8, 0x00,
  0x63, 0x00, 0x38, 0xC0, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x80, 0xC0, 0xE0,
  0x30, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x01,
  0xB0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF,
  0xFF, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x81,
  0xC6, 0x06, 0x1C, 0x38, 0x30, 0xC0, 0xE7, 0x01, 0x98, 0x06, 0xE0, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x87, 0x0E, 0x1C, 0x0F, 0xC0, 0x7F, 0xC3,
  0x83, 0x98, 0x06, 0x60, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0F, 0xFC,
  0xFF, 0xF7, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xE0, 0x3D, 0xFF, 0xB3, 0xFC, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xF8, 0x3B, 0xC0, 0x6E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xBB, 0xFC,
  0xE7, 0xE0, 0x0F, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x07, 0x60, 0x0F, 0x80,
  0x3E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x36, 0x00, 0xD8, 0x07, 0x70, 0x38, 0xFF, 0xC0, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xF8,
  0xCF, 0xFB, 0x78, 0x2D, 0xC0, 0x76, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1D, 0x80, 0x77, 0x02, 0xCF, 0xFB, 0x1F, 0xCC, 0x0F, 0xC0, 0x7F, 0xC3,
  0x83, 0x98, 0x06, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0xD8, 0x07,
  0x70, 0x38, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0F, 0x8C, 0xFF, 0xB7,
  0x82, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0xCF, 0x1B,
  0x1F, 0xCC, 0x1C, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x03,
  0x87, 0xFE, 0x1F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xF8, 0x3B, 0xC0, 0x6E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0C,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0xFF, 0xCF,
  0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xF0, 0x06, 0xC0, 0x3B, 0x01, 0xCC, 0x06, 0x30, 0x38, 0xC1, 0xC3,
  0x06, 0x0F, 0xF0, 0x3F, 0xC0, 0xC3, 0x83, 0x07, 0x0C, 0x1C, 0x30, 0x38,
  0xC0, 0x63, 0x01, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x1C, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x9E, 0x79, 0x7E, 0xFB, 0x0E, 0x3E,
  0x18, 0x3C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1, 0x83, 0xC3, 0x07, 0x86,
  0x0F, 0x0C, 0x1E, 0x18, 0x3C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1, 0x83,
  0xC3, 0x07, 0x86, 0x0F, 0x0C, 0x18, 0xE7, 0xE3, 0xBF, 0xCF, 0x83, 0xBC,
  0x06, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x36, 0x00, 0xD8, 0x07, 0x70, 0x38, 0xFF, 0xC0,
  0xFE, 0x00, 0xE7, 0xE3, 0xBF, 0xCF, 0x83, 0xBC, 0x06, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x3B, 0xBF, 0xCE, 0x7E, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F, 0x8C,
  0xFF, 0xB7, 0x82, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x36, 0x01,
  0xD8, 0x07, 0x70, 0x2C, 0xFF, 0xB1, 0xFC, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC7, 0xC3, 0x7F, 0xCD, 0x07, 0xB8,
  0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0x03, 0x98, 0x07, 0x60,
  0x0D, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x70, 0x1C, 0xFF, 0xE1,
  0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x1F,
  0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x36,
  0x01, 0xD8, 0x06, 0x70, 0x38, 0xFF, 0xC0, 0xFE, 0x00, 0xE0, 0x03, 0x60,
  0x07, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x38, 0x0C, 0x18,
  0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x30, 0x06,
  0x70, 0x06, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0xE0,
  0xC0, 0xD8, 0x38, 0x36, 0x0E, 0x0D, 0x83, 0x86, 0x61, 0xA1, 0x98, 0x68,
  0x63, 0x12, 0x18, 0xC4, 0xC6, 0x31, 0x31, 0x8C, 0xCC, 0xC3, 0x31, 0x30,
  0xCC, 0x4C, 0x12, 0x13, 0x06, 0x86, 0xC1, 0xA1, 0xB0, 0x78, 0x78, 0x1E,
  0x0E, 0x07, 0x83, 0x80, 0xC0, 0xE0, 0x60, 0x07, 0x70, 0x0E, 0x38, 0x0C,
  0x18, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x03, 0x60, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x1C, 0x18,
  0x18, 0x1C, 0x30, 0x0C, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0x60, 0x07,
  0x70, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x18,
  0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x30, 0x06, 0x70, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7F, 0xFD,
  0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xF0,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x3F, 0xC0,
  0xFF, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x7F, 0x03, 0xFC, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x78, 0x0F, 0xC0, 0x3C, 0x00, 0x7C, 0x07, 0xFC, 0x0F,
  0x1C, 0x1E, 0x1C, 0x7C, 0x1F, 0xD8, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 25, 20, 8, -25 },
  { 14, 10, 10, 20, 5, -25 },
  { 27, 18, 25, 20, 1, -25 },
  { 84, 15, 35, 20, 3, -30 },
  { 150, 19, 25, 20, 1, -25 },
  { 210, 17, 25, 20, 2, -25 },
  { 264, 2, 10, 20, 9, -25 },
  { 267, 9, 33, 20, 7, -29 },
  { 305, 10, 33, 20, 4, -29 },
  { 347, 18, 18, 20, 1, -21 },
  { 388, 16, 16, 20, 2, -19 },
  { 420, 6, 10, 20, 6, -5 },
  { 428, 11, 2, 20, 5, -12 },
  { 431, 5, 5, 20, 8, -5 },
  { 435, 14, 32, 20, 3, -28 },
  { 491, 14, 25, 20, 3, -25 },
  { 535, 15, 25, 20, 3, -25 },
  { 582, 15, 25, 20, 3, -25 },
  { 629, 14, 25, 20, 3, -25 },
  { 673, 14, 25, 20, 3, -25 },
  { 717, 14, 25, 20, 3, -25 },
  { 761, 15, 25, 20, 3, -25 },
  { 808, 15, 25, 20, 3, -25 },
  { 855, 14, 25, 20, 3, -25 },
  { 899, 15, 25, 20, 3, -25 },
  { 946, 5, 19, 20, 8, -19 },
  { 958, 7, 24, 20, 6, -19 },
  { 979, 14, 17, 20, 3, -20 },
  { 1009, 14, 10, 20, 3, -16 },
  { 1027, 14, 17, 20, 3, -20 },
  { 1057, 12, 25, 20, 5, -25 },
  { 1095, 17, 31, 20, 2, -25 },
  { 1161, 16, 25, 20, 2, -25 },
  { 1211, 15, 25, 20, 3, -25 },
  { 1258, 14, 25, 20, 3, -25 },
  { 1302, 14, 25, 20, 3, -25 },
  { 1346, 13, 25, 20, 4, -25 },
  { 1387, 14, 25, 20, 4, -25 },
  { 1431, 14, 25, 20, 3, -25 },
  { 1475, 14, 25, 20, 3, -25 },
  { 1519, 13, 25, 20, 4, -25 },
  { 1560, 15, 25, 20, 2, -25 },
  { 1607, 16, 25, 20, 3, -25 },
  { 1657, 14, 25, 20, 4, -25 },
  { 1701, 14, 25, 20, 3, -25 },
  { 1745, 14, 25, 20, 3, -25 },
  { 1789, 14, 25, 20, 3, -25 },
  { 1833, 15, 25, 20, 3, -25 },
  { 1880, 15, 31, 20, 3, -25 },
  { 1939, 15, 25, 20, 3, -25 },
  { 1986, 15, 25, 20, 3, -25 },
  { 2033, 16, 25, 20, 2, -25 },
  { 2083, 14, 25, 20, 3, -25 },
  { 2127, 16, 25, 20, 2, -25 },
  { 2177, 18, 25, 20, 1, -25 },
  { 2234, 17, 25, 20, 2, -25 },
  { 2288, 18, 25, 20, 1, -25 },
  { 2345, 14, 25, 20, 3, -25 },
  { 2389, 8, 32, 20, 7, -28 },
  { 2421, 14, 32, 20, 3, -28 },
  { 2477, 8, 32, 20, 5, -28 },
  { 2509, 14, 13, 20, 3, -25 },
  { 2532, 16, 2, 20, 2, 1 },
  { 2536, 6, 5, 20, 7, -27 },
  { 2540, 14, 19, 20, 3, -19 },
  { 2574, 14, 25, 20, 3, -25 },
  { 2618, 14, 19, 20, 3, -19 },
  { 2652, 14, 25, 20, 3, -25 },
  { 2696, 14, 19, 20, 3, -19 },
  { 2730, 16, 25, 20, 2, -25 },
  { 2780, 14, 25, 20, 3, -19 },
  { 2824, 14, 25, 20, 3, -25 },
  { 2868, 15, 26, 20, 3, -26 },
  { 2917, 12, 32, 20, 3, -26 },
  { 2965, 14, 25, 20, 4, -25 },
  { 3009, 18, 25, 20, 1, -25 },
  { 3066, 15, 19, 20, 3, -19 },
  { 3102, 14, 19, 20, 3, -19 },
  { 3136, 14, 19, 20, 3, -19 },
  { 3170, 14, 25, 20, 3, -19 },
  { 3214, 14, 25, 20, 3, -19 },
  { 3258, 14, 19, 20, 4, -19 },
  { 3292, 14, 19, 20, 3, -19 },
  { 3326, 15, 24, 20, 2, -24 },
  { 3371, 14, 19, 20, 3, -19 },
  { 3405, 16, 19, 20, 2, -19 },
  { 3443, 18, 19, 20, 1, -19 },
  { 3486, 16, 19, 20, 2, -19 },
  { 3524, 16, 25, 20, 2, -19 },
  { 3574, 14, 19, 20, 3, -19 },
  { 3608, 14, 32, 20, 3, -28 },
  { 3664, 2, 32, 20, 9, -28 },
  { 3672, 14, 32, 20, 3, -28 },
  { 3728, 15, 6, 20, 3, -15 },
};

const GFXfont JetBrainsMono_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_EXTRALIGHT34PT7B_H_
