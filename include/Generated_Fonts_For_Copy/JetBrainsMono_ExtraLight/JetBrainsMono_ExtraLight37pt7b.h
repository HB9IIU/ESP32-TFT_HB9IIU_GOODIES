#ifndef _JETBRAINSMONO_EXTRALIGHT37PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0x00, 0x00, 0x1E, 0xFF, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x0C, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x81, 0x80, 0x30, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x38, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0, 0x1C, 0x0C,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x81, 0xC0, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x39, 0x9E, 0x71, 0x8E, 0x61, 0x87,
  0x61, 0x87, 0x61, 0x87, 0x61, 0x80, 0x71, 0x80, 0x71, 0x80, 0x39, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0x9E, 0x01, 0x8E,
  0x01, 0x87, 0x01, 0x83, 0x01, 0x83, 0xC1, 0x83, 0xE1, 0x83, 0xE1, 0x87,
  0x71, 0x87, 0x79, 0x9E, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00, 0x3B, 0xFC, 0x03, 0x38,
  0x60, 0x19, 0x83, 0x81, 0x8C, 0x0C, 0x18, 0x60, 0x60, 0xC3, 0x03, 0x0C,
  0x18, 0x18, 0xC0, 0xC1, 0xC6, 0x07, 0x0C, 0x60, 0x1F, 0xE6, 0x00, 0x7E,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0xF8,
  0x01, 0x9F, 0xE0, 0x18, 0xC3, 0x80, 0xC6, 0x0C, 0x0C, 0x70, 0x60, 0xC3,
  0x83, 0x0E, 0x1C, 0x18, 0x60, 0xE0, 0xC6, 0x03, 0x06, 0x60, 0x18, 0x73,
  0x00, 0xFF, 0x30, 0x01, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x70, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0xE7, 0x00, 0x18, 0x70, 0x77, 0x06, 0x0C, 0xE0, 0xE3, 0x9C, 0x0E, 0x63,
  0x80, 0xFC, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0xC3,
  0x01, 0xD8, 0x70, 0x73, 0x87, 0xFC, 0x38, 0x7F, 0x03, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x60, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x7C,
  0x03, 0x80, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x1F,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x60, 0x67, 0xC6, 0x3F, 0xFF,
  0x6F, 0xE0, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xD8, 0x00,
  0x39, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0x78,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0xF3, 0xCE, 0x79, 0xC7, 0x1C, 0xE3, 0x8C,
  0x30, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x38, 0x1C,
  0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xFC, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x79, 0xC0, 0xF1, 0xC0, 0xC1, 0xC0,
  0x81, 0xC0, 0x81, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFE, 0x1E, 0x07,
  0x8E, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xB8,
  0x07, 0x78, 0x1C, 0x7F, 0xF0, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x31, 0xC0, 0x67, 0x00, 0xCE, 0x01, 0xB8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x7F, 0xFE,
  0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x71, 0xE0, 0x77, 0xF8, 0x7F, 0x7C, 0x78, 0x1E,
  0x70, 0x0E, 0x70, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x60, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C,
  0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x60, 0x07, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x6E, 0x00, 0x77, 0x00, 0x33, 0x80,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xFC,
  0x38, 0x1C, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x07, 0x60, 0x06,
  0x70, 0x06, 0x30, 0x0E, 0x38, 0x1C, 0x0E, 0x78, 0x07, 0xE0, 0x07, 0xE0,
  0x1E, 0x78, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0x70, 0x0F, 0x78, 0x1E, 0x3F, 0xFE, 0x1F, 0xEC, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x31, 0xFF, 0xFF, 0x7C,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78,
  0x1C, 0x7D, 0xFB, 0xF3, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x3C, 0x78, 0xE1, 0xC7, 0x0E, 0x1C, 0x30, 0xE1, 0x83, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xE3, 0xFC, 0x3F,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x81,
  0xC0, 0x70, 0xE0, 0x0E, 0x70, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x3C, 0x0F, 0xFF, 0x03, 0x87, 0xC1, 0xC0,
  0xF0, 0x60, 0x3C, 0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x60, 0x3C,
  0x18, 0x0F, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x70, 0x3C, 0x0E, 0x1F, 0x03,
  0xFB, 0xE0, 0x3C, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x1C, 0xE0, 0x07, 0x18, 0x01, 0x86, 0x00, 0x61,
  0xC0, 0x38, 0x70, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x06, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xE0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC7, 0x00, 0x39, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x7E, 0x00,
  0x1C, 0xFF, 0xC1, 0xFF, 0xE3, 0x01, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x76, 0x01, 0xCF,
  0xFF, 0x1F, 0xFE, 0x30, 0x0E, 0x60, 0x0E, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x0E, 0xC0, 0x7D,
  0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xF1, 0xC0, 0xF7, 0x00, 0xEE,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x0E, 0x70, 0x3C, 0x7F, 0xF0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0xC3, 0x03,
  0xE6, 0x01, 0xCC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x01,
  0xB0, 0x07, 0x60, 0x1C, 0xC0, 0xF9, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF,
  0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xF1, 0xC0, 0xF7, 0x00, 0xEE,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x0E, 0x70, 0x3C, 0x7F, 0xF0, 0x7F, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0E, 0x38, 0x1E, 0x1F, 0xFC, 0x0F,
  0xF0, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0,
  0x38, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0xE0, 0xC0, 0xE0, 0xC1,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0,
  0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0,
  0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xD8, 0x1B, 0xD8, 0x1B, 0xD8,
  0x1B, 0xCC, 0x33, 0xCC, 0x33, 0xC6, 0x33, 0xC6, 0x63, 0xC6, 0x63, 0xE3,
  0x63, 0xE3, 0xC3, 0xE3, 0xC3, 0xE1, 0xC3, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xD8, 0x0F, 0x60, 0x3D, 0xC0, 0xF3, 0x03, 0xCC, 0x0F, 0x38,
  0x3C, 0x60, 0xF1, 0x83, 0xC3, 0x0F, 0x0C, 0x3C, 0x38, 0xF0, 0x63, 0xC1,
  0x8F, 0x03, 0x3C, 0x0C, 0xF0, 0x3B, 0xC0, 0x6F, 0x01, 0xBC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xC0,
  0xE7, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xB8, 0x03, 0x70, 0x0E, 0x70, 0x38, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xE0,
  0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1E,
  0xFF, 0xFC, 0xFF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xC0, 0xE7, 0x00, 0xEC,
  0x00, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0x70,
  0x0E, 0x70, 0x38, 0x7F, 0xE0, 0x7F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0xFF, 0xE0, 0xFF, 0xF8,
  0xC0, 0x7C, 0xC0, 0x1E, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xE0, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x70,
  0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x07, 0x0F, 0xF0, 0x1F, 0xFC, 0x38, 0x1E, 0x70, 0x0E, 0x60, 0x07,
  0x60, 0x07, 0x60, 0x07, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0x70, 0x07, 0x78, 0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x07, 0x70, 0x38, 0xFF, 0xC1, 0xFE, 0x00, 0xE0, 0x01, 0xD8,
  0x00, 0x76, 0x00, 0x19, 0xC0, 0x06, 0x70, 0x03, 0x8C, 0x00, 0xC3, 0x80,
  0x30, 0xE0, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x70, 0x38,
  0x0C, 0x0E, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x38, 0x70, 0x06, 0x1C, 0x01,
  0x86, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x3B,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x70,
  0x3E, 0x07, 0x07, 0x60, 0xF0, 0x76, 0x0F, 0x07, 0x60, 0xD0, 0x66, 0x0D,
  0x06, 0x60, 0xD0, 0x66, 0x09, 0x86, 0x70, 0x98, 0x67, 0x09, 0x86, 0x31,
  0x98, 0xE3, 0x19, 0x8E, 0x31, 0x88, 0xC3, 0x18, 0x8C, 0x31, 0x08, 0xC3,
  0x10, 0xCC, 0x31, 0x0C, 0xC3, 0xB0, 0xCC, 0x3B, 0x0C, 0xC1, 0xB0, 0xCC,
  0x1B, 0x05, 0x81, 0xB0, 0x58, 0x1A, 0x05, 0x81, 0xA0, 0x78, 0x1A, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x01, 0xDC, 0x00, 0xE3, 0x00,
  0x38, 0xE0, 0x1C, 0x18, 0x06, 0x07, 0x03, 0x80, 0xE0, 0xC0, 0x18, 0x70,
  0x07, 0x18, 0x00, 0xCC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0x38, 0x01, 0xC6, 0x00, 0x61,
  0xC0, 0x38, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0C,
  0x70, 0x03, 0x98, 0x00, 0x7E, 0x00, 0x1C, 0xC0, 0x00, 0xFC, 0x00, 0x39,
  0x80, 0x06, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x06, 0x01, 0x80,
  0xE0, 0x70, 0x0C, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x00,
  0x33, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xE0, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x38, 0x1C,
  0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x01, 0xC0, 0x1F,
  0xF0, 0xFF, 0xF1, 0xC0, 0x77, 0x00, 0xEC, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x0F, 0xFC, 0xFF, 0xFB, 0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0xFF, 0xB1, 0xFE,
  0x60, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0xF0, 0x67, 0xF8, 0xDE, 0xF9, 0xE0, 0x7B, 0x80, 0x77, 0x00, 0x6C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0x70, 0x0E, 0xD0, 0x39,
  0xBF, 0xF3, 0x3F, 0x80, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0xE3, 0x80, 0xEE,
  0x00, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x03, 0xE0, 0x07, 0xE0, 0x0D,
  0xC0, 0x39, 0xC0, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x70, 0xCF, 0xF3, 0x7C, 0xED,
  0xC0, 0xFE, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF8, 0x07, 0x70, 0x3C, 0xFF, 0xB1, 0xFC, 0xC0, 0x07, 0x80, 0x3F, 0xE1,
  0xF3, 0xE3, 0x80, 0xCE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0xF1, 0xFF, 0xC1, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0xFF, 0x37, 0xCE, 0xDC, 0x0F, 0xE0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x07, 0x70, 0x3D, 0xFF, 0xB3, 0xFC, 0xC1, 0x83,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0xFF, 0xE3, 0xFF,
  0x0F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x38, 0x33, 0xFC, 0xDC, 0xFB, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0xFF, 0xE3,
  0xFF, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x1C,
  0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x70,
  0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x0E,
  0x1C, 0xDF, 0x3E, 0xE3, 0xE7, 0xC1, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0x03, 0x83, 0x3F, 0xCD, 0xEF, 0xBC, 0x0F,
  0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0xE3,
  0x81, 0xCE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06,
  0xE0, 0x0D, 0xC0, 0x39, 0xC0, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xC1,
  0x9F, 0xE3, 0x7B, 0xE7, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x06, 0xE0, 0x0D, 0xC0, 0x3B, 0x40, 0xE6, 0xFF, 0xCC,
  0xFE, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x37, 0xCE, 0xDC, 0x0F, 0xE0, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x77, 0x03,
  0xCF, 0xFB, 0x1F, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x01, 0xC1, 0xCF, 0xF3, 0xB9, 0xF7, 0xC0, 0xEF,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0xE0, 0x07, 0x70, 0x07, 0x78, 0x0E, 0x3F, 0xFC,
  0x0F, 0xF8, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0xC0, 0x03, 0xF0,
  0x01, 0xB8, 0x01, 0xCC, 0x00, 0xC7, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30,
  0x70, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x07, 0x06, 0x01, 0x87, 0x00, 0xC3,
  0x00, 0x71, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xC0, 0xC0, 0xF8, 0x1C, 0x1B, 0x07, 0x83, 0x60,
  0xF0, 0x6E, 0x1A, 0x0C, 0xC2, 0x43, 0x98, 0x4C, 0x63, 0x19, 0x8C, 0x63,
  0x31, 0x8C, 0x66, 0x31, 0xCC, 0x46, 0x19, 0x08, 0xC3, 0x21, 0xB0, 0x6C,
  0x36, 0x0D, 0x86, 0xC1, 0xB0, 0xD8, 0x36, 0x0B, 0x03, 0x81, 0x60, 0x70,
  0x38, 0x0E, 0x07, 0x00, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0x60, 0x70,
  0x38, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0x38, 0x01, 0xC6, 0x00,
  0xE1, 0xC0, 0x30, 0x38, 0x1C, 0x06, 0x0E, 0x01, 0xC7, 0x00, 0x3B, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0x98, 0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE1,
  0x80, 0x70, 0xE0, 0x30, 0x30, 0x38, 0x1C, 0x18, 0x0E, 0x1C, 0x03, 0x0E,
  0x01, 0xC6, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFD, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0xC0, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x18, 0x03, 0x7E, 0x03, 0xF7, 0x03,
  0xC3, 0x83, 0xC1, 0xC3, 0xC0, 0xFF, 0xC0, 0x7E, 0x00, 0x18,
};

const GFXglyph JetBrainsMono_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 27, 22, 9, -27 },
  { 18, 10, 11, 22, 6, -27 },
  { 32, 20, 27, 22, 1, -27 },
  { 100, 16, 37, 22, 3, -32 },
  { 174, 21, 27, 22, 1, -27 },
  { 245, 19, 27, 22, 2, -27 },
  { 310, 2, 11, 22, 10, -27 },
  { 313, 11, 35, 22, 7, -31 },
  { 362, 11, 35, 22, 4, -31 },
  { 411, 20, 19, 22, 1, -23 },
  { 459, 17, 17, 22, 3, -21 },
  { 496, 6, 12, 22, 7, -6 },
  { 505, 12, 2, 22, 5, -13 },
  { 508, 6, 5, 22, 8, -5 },
  { 512, 16, 35, 22, 3, -31 },
  { 582, 16, 27, 22, 3, -27 },
  { 636, 16, 27, 22, 4, -27 },
  { 690, 17, 27, 22, 3, -27 },
  { 748, 15, 27, 22, 3, -27 },
  { 799, 15, 27, 22, 3, -27 },
  { 850, 16, 27, 22, 3, -27 },
  { 904, 16, 27, 22, 3, -27 },
  { 958, 17, 27, 22, 3, -27 },
  { 1016, 16, 27, 22, 3, -27 },
  { 1070, 16, 27, 22, 3, -27 },
  { 1124, 6, 21, 22, 8, -21 },
  { 1140, 7, 27, 22, 7, -21 },
  { 1164, 16, 19, 22, 3, -22 },
  { 1202, 16, 11, 22, 3, -18 },
  { 1224, 16, 19, 22, 3, -22 },
  { 1262, 12, 27, 22, 6, -27 },
  { 1303, 18, 34, 22, 2, -27 },
  { 1380, 18, 27, 22, 2, -27 },
  { 1441, 15, 27, 22, 4, -27 },
  { 1492, 15, 27, 22, 4, -27 },
  { 1543, 15, 27, 22, 4, -27 },
  { 1594, 15, 27, 22, 4, -27 },
  { 1645, 15, 27, 22, 4, -27 },
  { 1696, 15, 27, 22, 4, -27 },
  { 1747, 14, 27, 22, 4, -27 },
  { 1795, 14, 27, 22, 4, -27 },
  { 1843, 16, 27, 22, 2, -27 },
  { 1897, 16, 27, 22, 4, -27 },
  { 1951, 16, 27, 22, 4, -27 },
  { 2005, 16, 27, 22, 3, -27 },
  { 2059, 14, 27, 22, 4, -27 },
  { 2107, 15, 27, 22, 4, -27 },
  { 2158, 16, 27, 22, 4, -27 },
  { 2212, 15, 34, 22, 4, -27 },
  { 2276, 16, 27, 22, 4, -27 },
  { 2330, 16, 27, 22, 3, -27 },
  { 2384, 18, 27, 22, 2, -27 },
  { 2445, 14, 27, 22, 4, -27 },
  { 2493, 18, 27, 22, 2, -27 },
  { 2554, 20, 27, 22, 1, -27 },
  { 2622, 18, 27, 22, 2, -27 },
  { 2683, 19, 27, 22, 2, -27 },
  { 2748, 16, 27, 22, 3, -27 },
  { 2802, 9, 35, 22, 8, -31 },
  { 2842, 16, 35, 22, 3, -31 },
  { 2912, 8, 35, 22, 6, -31 },
  { 2947, 16, 14, 22, 3, -27 },
  { 2975, 18, 2, 22, 2, 1 },
  { 2980, 7, 5, 22, 7, -29 },
  { 2985, 15, 21, 22, 3, -21 },
  { 3025, 15, 27, 22, 4, -27 },
  { 3076, 15, 21, 22, 4, -21 },
  { 3116, 14, 27, 22, 4, -27 },
  { 3164, 15, 21, 22, 4, -21 },
  { 3204, 18, 27, 22, 2, -27 },
  { 3265, 14, 28, 22, 4, -21 },
  { 3314, 14, 27, 22, 4, -27 },
  { 3362, 17, 28, 22, 3, -28 },
  { 3422, 14, 35, 22, 3, -28 },
  { 3484, 16, 27, 22, 4, -27 },
  { 3538, 18, 27, 22, 2, -27 },
  { 3599, 16, 21, 22, 3, -21 },
  { 3641, 14, 21, 22, 4, -21 },
  { 3678, 15, 21, 22, 4, -21 },
  { 3718, 15, 28, 22, 4, -21 },
  { 3771, 14, 28, 22, 4, -21 },
  { 3820, 15, 21, 22, 4, -21 },
  { 3860, 16, 21, 22, 3, -21 },
  { 3902, 17, 26, 22, 2, -26 },
  { 3958, 14, 20, 22, 4, -20 },
  { 3993, 17, 20, 22, 3, -20 },
  { 4036, 19, 20, 22, 2, -20 },
  { 4084, 18, 20, 22, 2, -20 },
  { 4129, 17, 27, 22, 3, -20 },
  { 4187, 15, 20, 22, 4, -20 },
  { 4225, 16, 35, 22, 3, -31 },
  { 4295, 2, 35, 22, 10, -31 },
  { 4304, 16, 35, 22, 3, -31 },
  { 4374, 16, 8, 22, 3, -17 },
};

const GFXfont JetBrainsMono_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_EXTRALIGHT37PT7B_H_
