#ifndef _JETBRAINSMONO_EXTRALIGHT66PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0x3B, 0xFC, 0x07, 0xC1, 0xC3, 0xF0, 0x7C, 0x0E, 0x0F, 0x87, 0xC0,
  0x70, 0x3E, 0x3E, 0x03, 0x81, 0xF1, 0xE0, 0x1C, 0x07, 0x8F, 0x00, 0xE0,
  0x3E, 0x78, 0x07, 0x01, 0xF3, 0xC0, 0x38, 0x0F, 0x9E, 0x01, 0xC0, 0x00,
  0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x01, 0xF8,
  0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3F, 0x07, 0x00, 0x00, 0xFE, 0x38,
  0x00, 0x03, 0xFD, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0x7F, 0x80, 0x00, 0x38, 0xFE, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x70, 0x3E, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x1C, 0x07,
  0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x07, 0xFC,
  0x01, 0xC0, 0x3F, 0xE0, 0x0E, 0x01, 0xEF, 0x00, 0x70, 0x0F, 0x78, 0x03,
  0x80, 0xFB, 0xE0, 0x1C, 0x07, 0xCF, 0x80, 0xE0, 0x7C, 0x7E, 0x07, 0x07,
  0xE1, 0xF8, 0x38, 0x7E, 0x07, 0xF9, 0xDF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xC7, 0xFF, 0x80, 0x00, 0x1C, 0x3F, 0xFE, 0x00, 0x01, 0xE3, 0xE0,
  0xF8, 0x00, 0x1E, 0x3E, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x3C, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0xC0,
  0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xE1, 0xE0, 0x00, 0x7F, 0xFE, 0x0E, 0x00,
  0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x3C, 0x1F, 0xF8, 0x00, 0x01, 0xC1, 0xFF, 0xE0, 0x00,
  0x1E, 0x1F, 0xFF, 0x80, 0x01, 0xE1, 0xF0, 0x3E, 0x00, 0x0E, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x00, 0x3C,
  0x07, 0x80, 0x38, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x3C, 0x00, 0x70, 0x03, 0xC1, 0xC0, 0x03, 0x80, 0x1E, 0x1E,
  0x00, 0x1E, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x0F, 0x0E, 0x00, 0x03, 0xE1,
  0xF8, 0xF0, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x00, 0x7F, 0xF8, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xDF, 0x03, 0xE0, 0x07, 0xDF, 0x01, 0xF0, 0x03, 0xCF, 0x80,
  0x7C, 0x03, 0xE7, 0x80, 0x1F, 0x01, 0xE3, 0xC0, 0x07, 0xC1, 0xF1, 0xE0,
  0x03, 0xE0, 0xF0, 0xF0, 0x00, 0xF8, 0xF8, 0x78, 0x00, 0x3E, 0xF8, 0x3C,
  0x00, 0x0F, 0x78, 0x1E, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x01, 0xFC, 0x07,
  0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x0F, 0xBC,
  0x0F, 0x80, 0x0F, 0x9F, 0x07, 0xE0, 0x1F, 0x87, 0xC1, 0xFE, 0x3F, 0x81,
  0xF0, 0x7F, 0xFF, 0x80, 0x78, 0x1F, 0xFF, 0x80, 0x3E, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x3B, 0xF8, 0x07, 0x80, 0x7E, 0xFF, 0x81,
  0xE0, 0xFF, 0xFF, 0xFC, 0x70, 0xFF, 0xF3, 0xFF, 0x8C, 0xFF, 0xF0, 0x1F,
  0xFB, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x1F, 0xC7, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0x03, 0xF8, 0x1F, 0xF0,
  0x3F, 0x81, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0x01, 0xF0,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x81, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xBC, 0x00,
  0x03, 0xF1, 0xE0, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x7E,
  0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xC0, 0x07,
  0x80, 0x04, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC1, 0xF8,
  0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3D,
  0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x87, 0xFF, 0x01, 0xF3, 0xFF, 0xF8,
  0x3E, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x1F, 0xF0, 0x00, 0xFB, 0xFF, 0xE0, 0x0F, 0xBF,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0xFF, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF0, 0x01,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x3F,
  0xF8, 0x0F, 0xFF, 0xF7, 0x80, 0x3F, 0xFE, 0x7C, 0x00, 0x3F, 0xC7, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x1F, 0xEF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0x00, 0x07, 0xC0, 0x7F,
  0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x0F, 0xF0, 0x01, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xE7, 0xF0, 0x03,
  0xFD, 0xF7, 0xF0, 0x07, 0xC0, 0x37, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0x0F,
  0x80, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x0F,
  0x80, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x3F, 0xF0, 0x07,
  0xF0, 0x77, 0xF0, 0x03, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xC7, 0xF0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0x00, 0x07, 0xF1, 0xE0,
  0x00, 0x3F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E,
  0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x1F, 0xE3, 0xC0, 0x00,
  0x7E, 0x78, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x3F, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0x70, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFE, 0x3C,
  0x00, 0x1F, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xCF,
  0x00, 0x07, 0xE3, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8,
  0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07,
  0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x77, 0xEE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0xEF, 0xEF, 0x00, 0x0E,
  0xFE, 0x70, 0x01, 0xEF, 0xE7, 0x80, 0x1C, 0xFE, 0x38, 0x01, 0xCF, 0xE3,
  0x80, 0x3C, 0xFF, 0x3C, 0x03, 0x8F, 0xF1, 0xC0, 0x38, 0xFF, 0x1E, 0x07,
  0x8F, 0xF1, 0xE0, 0x70, 0xFF, 0x0E, 0x07, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0E, 0x0F, 0xF0, 0x70, 0xE0, 0xFF, 0x07, 0x9E, 0x0F, 0xF0, 0x79,
  0xC0, 0xFF, 0x03, 0x9C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xDE,
  0x00, 0x0F, 0xF7, 0x80, 0x03, 0xFD, 0xE0, 0x00, 0xFF, 0x3C, 0x00, 0x3F,
  0xCF, 0x00, 0x0F, 0xF1, 0xC0, 0x03, 0xFC, 0x78, 0x00, 0xFF, 0x1E, 0x00,
  0x3F, 0xC3, 0xC0, 0x0F, 0xF0, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0xFF, 0x07,
  0x80, 0x3F, 0xC1, 0xE0, 0x0F, 0xF0, 0x3C, 0x03, 0xFC, 0x0F, 0x00, 0xFF,
  0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80,
  0xFF, 0x00, 0xF0, 0x3F, 0xC0, 0x3C, 0x0F, 0xF0, 0x07, 0x83, 0xFC, 0x01,
  0xE0, 0xFF, 0x00, 0x78, 0x3F, 0xC0, 0x0F, 0x0F, 0xF0, 0x03, 0xC3, 0xFC,
  0x00, 0xF0, 0xFF, 0x00, 0x1E, 0x3F, 0xC0, 0x07, 0x8F, 0xF0, 0x00, 0xF3,
  0xFC, 0x00, 0x3C, 0xFF, 0x00, 0x0F, 0x3F, 0xC0, 0x01, 0xEF, 0xF0, 0x00,
  0x7B, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x78, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0xC1, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7F,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F,
  0x01, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFE, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x8F, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x7E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF8, 0xF0, 0x00,
  0x7F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF0,
  0x01, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3D, 0xE0, 0x07, 0xE0, 0x07,
  0xBC, 0x00, 0xFC, 0x00, 0xF7, 0x80, 0x1F, 0x80, 0x1E, 0xF0, 0x03, 0xF0,
  0x03, 0xDE, 0x00, 0x7E, 0x00, 0x7B, 0xC0, 0x1C, 0xC0, 0x1E, 0x78, 0x03,
  0x9C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x78, 0xF0, 0x0E, 0x70, 0x0F, 0x1E,
  0x01, 0xCE, 0x01, 0xE3, 0xC0, 0x39, 0xC0, 0x3C, 0x78, 0x07, 0x38, 0x07,
  0x8F, 0x01, 0xC7, 0x00, 0xF1, 0xE0, 0x38, 0x70, 0x1C, 0x3C, 0x07, 0x0E,
  0x07, 0x87, 0x80, 0xE1, 0xC0, 0xF0, 0xF8, 0x1C, 0x38, 0x1E, 0x0F, 0x03,
  0x87, 0x03, 0xC1, 0xE0, 0x70, 0xE0, 0x78, 0x3C, 0x0E, 0x1C, 0x0F, 0x07,
  0x83, 0x83, 0x81, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x07,
  0x03, 0xC1, 0xC0, 0xE1, 0xE0, 0x78, 0x38, 0x1C, 0x3C, 0x07, 0x87, 0x03,
  0x87, 0x80, 0xF0, 0xE0, 0x70, 0xF0, 0x1E, 0x38, 0x0E, 0x1E, 0x03, 0xC7,
  0x01, 0xC3, 0xC0, 0x78, 0xE0, 0x1C, 0x78, 0x0F, 0x1C, 0x03, 0x8E, 0x01,
  0xE3, 0x80, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x78, 0x03, 0xCE, 0x01, 0xCF,
  0x00, 0x7B, 0x80, 0x39, 0xE0, 0x0F, 0x70, 0x07, 0x3C, 0x01, 0xEE, 0x00,
  0xE7, 0x80, 0x3D, 0xC0, 0x0E, 0xF0, 0x07, 0xB8, 0x01, 0xDC, 0x00, 0xF7,
  0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0xF0, 0x01, 0xD8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x6F, 0x7E, 0x00, 0x0E, 0xF3, 0xFC, 0x07, 0xCF, 0x1F, 0xFF, 0xFC,
  0xF0, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0xC0, 0xF0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x7F, 0x00, 0xF0, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x0F, 0x3F, 0xFF, 0xE3,
  0xDE, 0x01, 0xFC, 0xF6, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xBF, 0x00, 0x03, 0xEF, 0xE0, 0x01, 0xFB, 0xDC, 0x00, 0xFC, 0xF7, 0xC0,
  0xFE, 0x3C, 0xFF, 0xFF, 0x0F, 0x1F, 0xFF, 0x83, 0xC1, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF, 0xE7, 0xC3,
  0xFF, 0xFE, 0xF8, 0xFE, 0x03, 0xFF, 0x3F, 0x00, 0x1F, 0xE7, 0xC0, 0x01,
  0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x3F, 0x9F, 0x80, 0x0F, 0xF1, 0xFE, 0x0F, 0xBE, 0x1F, 0xFF, 0xF7, 0xC1,
  0xFF, 0xFC, 0xF8, 0x0F, 0xFE, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x1F, 0xFF, 0xCF, 0x87,
  0xFF, 0xFD, 0xF1, 0xFC, 0x07, 0xBE, 0x7E, 0x00, 0x3F, 0xCF, 0x80, 0x03,
  0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x78, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x02, 0xF3,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xF8, 0x3E, 0xF8, 0x7F, 0xFF,
  0x9F, 0x03, 0xFF, 0xE3, 0xE0, 0x3F, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x7F, 0x00, 0xF0, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x0F, 0x3F, 0xFF, 0xE3,
  0xDE, 0x01, 0xFC, 0xF6, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x1F, 0x9E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x7E, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x7C, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xF8, 0x0F, 0x83,
  0xCF, 0xF0, 0x7F, 0x8F, 0x7F, 0xE3, 0xFF, 0x3F, 0xFF, 0xDF, 0xFE, 0xFC,
  0x1F, 0x40, 0xFB, 0xE0, 0x3F, 0x01, 0xEF, 0x80, 0xF8, 0x07, 0xFC, 0x01,
  0xE0, 0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x1F, 0xC0, 0x3C, 0x3F, 0xFC, 0x0F, 0x1F, 0xFF,
  0xC3, 0xCF, 0xFF, 0xF8, 0xF7, 0x80, 0x7F, 0x3D, 0x80, 0x0F, 0xCF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x3C, 0x3F, 0xFC, 0x0F, 0x1F, 0xFF, 0xC3, 0xCF,
  0xFF, 0xF8, 0xF7, 0x80, 0x7F, 0x3D, 0xC0, 0x07, 0xCF, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xEF, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x7E, 0xF7, 0x00, 0x3F,
  0x3D, 0xF0, 0x3F, 0x8F, 0x3F, 0xFF, 0xC3, 0xC7, 0xFF, 0xE0, 0xF0, 0x7F,
  0xF0, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x7C,
  0x1F, 0xFF, 0xCF, 0x87, 0xFF, 0xFD, 0xF1, 0xFC, 0x07, 0xFE, 0x7E, 0x00,
  0x3F, 0xCF, 0x80, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F,
  0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xCF, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0xE3, 0xFC, 0x1F, 0x7C,
  0x3F, 0xFF, 0xEF, 0x83, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC, 0x3E, 0x00, 0x38,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x1E, 0x1F, 0xFE, 0x03, 0xC7, 0xFF,
  0xF0, 0x79, 0xFF, 0xFF, 0x0F, 0x78, 0x07, 0xF1, 0xEE, 0x00, 0x3F, 0x3F,
  0x80, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x1F, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x07, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xEF,
  0x00, 0x3E, 0x00, 0x79, 0xE0, 0x0F, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07,
  0x9E, 0x00, 0xDC, 0x01, 0xE7, 0x80, 0x77, 0x00, 0x79, 0xE0, 0x1C, 0xC0,
  0x1C, 0x78, 0x07, 0x38, 0x0F, 0x0E, 0x01, 0xCE, 0x03, 0xC3, 0xC0, 0x73,
  0x80, 0xF0, 0xF0, 0x18, 0xE0, 0x3C, 0x3C, 0x0E, 0x38, 0x0F, 0x0F, 0x03,
  0x86, 0x03, 0x83, 0xC0, 0xE1, 0xC1, 0xE0, 0x70, 0x38, 0x70, 0x78, 0x1E,
  0x0E, 0x1C, 0x1E, 0x07, 0x87, 0x07, 0x07, 0x81, 0xE1, 0xC1, 0xC1, 0xE0,
  0x78, 0x70, 0x38, 0x70, 0x1E, 0x1C, 0x0E, 0x1C, 0x03, 0x87, 0x03, 0x8F,
  0x00, 0xF1, 0xC0, 0xE3, 0xC0, 0x3C, 0xE0, 0x38, 0xF0, 0x0F, 0x38, 0x0E,
  0x3C, 0x03, 0xCE, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x73, 0x80, 0x3C, 0xE0,
  0x1D, 0xE0, 0x07, 0x30, 0x07, 0x78, 0x01, 0xFC, 0x01, 0xDE, 0x00, 0x7F,
  0x00, 0x77, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x7F, 0xC0, 0x01, 0xF3, 0xFF, 0x80, 0x07, 0xDF, 0xFF,
  0x80, 0x1F, 0x7C, 0x3E, 0x00, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x00, 0xF8,
  0x07, 0xBC, 0x01, 0xF0, 0x1E, 0xF0, 0x03, 0xE0, 0xFB, 0xC0, 0x07, 0xFF,
  0xEF, 0x00, 0x0F, 0xFF, 0x3C, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x1F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 8, 48, 40, 16, -48 },
  { 49, 18, 20, 40, 11, -48 },
  { 94, 35, 48, 40, 2, -48 },
  { 304, 29, 66, 40, 5, -57 },
  { 544, 37, 49, 40, 1, -49 },
  { 771, 33, 50, 40, 4, -49 },
  { 978, 5, 20, 40, 17, -48 },
  { 991, 19, 63, 40, 13, -55 },
  { 1141, 19, 63, 40, 8, -55 },
  { 1291, 34, 33, 40, 3, -40 },
  { 1432, 30, 31, 40, 5, -37 },
  { 1549, 12, 21, 40, 12, -10 },
  { 1581, 21, 4, 40, 9, -24 },
  { 1592, 10, 11, 40, 15, -10 },
  { 1606, 28, 62, 40, 6, -55 },
  { 1823, 28, 50, 40, 6, -49 },
  { 1998, 29, 48, 40, 6, -48 },
  { 2172, 30, 49, 40, 5, -49 },
  { 2356, 28, 49, 40, 5, -48 },
  { 2528, 26, 48, 40, 6, -48 },
  { 2684, 27, 49, 40, 6, -48 },
  { 2850, 29, 49, 40, 5, -48 },
  { 3028, 30, 48, 40, 5, -48 },
  { 3208, 28, 50, 40, 6, -49 },
  { 3383, 29, 49, 40, 5, -49 },
  { 3561, 10, 38, 40, 15, -37 },
  { 3609, 13, 48, 40, 12, -37 },
  { 3687, 28, 34, 40, 6, -39 },
  { 3806, 28, 19, 40, 6, -31 },
  { 3873, 28, 34, 40, 6, -39 },
  { 3992, 23, 48, 40, 10, -48 },
  { 4130, 32, 61, 40, 4, -49 },
  { 4374, 32, 48, 40, 4, -48 },
  { 4566, 27, 48, 40, 7, -48 },
  { 4728, 28, 50, 40, 6, -49 },
  { 4903, 26, 48, 40, 7, -48 },
  { 5059, 27, 48, 40, 7, -48 },
  { 5221, 28, 48, 40, 7, -48 },
  { 5389, 28, 50, 40, 6, -49 },
  { 5564, 26, 48, 40, 7, -48 },
  { 5720, 24, 48, 40, 8, -48 },
  { 5864, 28, 49, 40, 4, -48 },
  { 6036, 29, 48, 40, 7, -48 },
  { 6210, 27, 48, 40, 8, -48 },
  { 6372, 28, 48, 40, 6, -48 },
  { 6540, 26, 48, 40, 7, -48 },
  { 6696, 27, 50, 40, 6, -49 },
  { 6865, 29, 48, 40, 7, -48 },
  { 7039, 28, 61, 40, 6, -49 },
  { 7253, 28, 48, 40, 7, -48 },
  { 7421, 29, 50, 40, 5, -49 },
  { 7603, 32, 48, 40, 4, -48 },
  { 7795, 26, 49, 40, 7, -48 },
  { 7955, 32, 48, 40, 4, -48 },
  { 8147, 35, 48, 40, 2, -48 },
  { 8357, 33, 48, 40, 3, -48 },
  { 8555, 34, 48, 40, 3, -48 },
  { 8759, 28, 48, 40, 6, -48 },
  { 8927, 16, 62, 40, 14, -55 },
  { 9051, 28, 62, 40, 6, -55 },
  { 9268, 15, 62, 40, 10, -55 },
  { 9385, 28, 26, 40, 6, -48 },
  { 9476, 32, 3, 40, 4, 2 },
  { 9488, 12, 9, 40, 13, -52 },
  { 9502, 28, 38, 40, 5, -37 },
  { 9635, 26, 49, 40, 7, -48 },
  { 9795, 27, 38, 40, 6, -37 },
  { 9924, 27, 49, 40, 6, -48 },
  { 10090, 27, 38, 40, 6, -37 },
  { 10219, 31, 48, 40, 4, -48 },
  { 10405, 27, 49, 40, 6, -37 },
  { 10571, 26, 48, 40, 7, -48 },
  { 10727, 30, 51, 40, 6, -51 },
  { 10919, 24, 63, 40, 6, -51 },
  { 11108, 29, 48, 40, 7, -48 },
  { 11282, 33, 48, 40, 3, -48 },
  { 11480, 30, 37, 40, 5, -37 },
  { 11619, 26, 37, 40, 7, -37 },
  { 11740, 27, 38, 40, 6, -37 },
  { 11869, 26, 49, 40, 7, -37 },
  { 12029, 27, 49, 40, 6, -37 },
  { 12195, 27, 37, 40, 8, -37 },
  { 12320, 28, 38, 40, 6, -37 },
  { 12453, 30, 47, 40, 4, -47 },
  { 12630, 26, 37, 40, 7, -36 },
  { 12751, 31, 36, 40, 4, -36 },
  { 12891, 34, 36, 40, 3, -36 },
  { 13044, 31, 36, 40, 4, -36 },
  { 13184, 31, 48, 40, 4, -36 },
  { 13370, 27, 36, 40, 6, -36 },
  { 13492, 27, 62, 40, 6, -55 },
  { 13702, 4, 62, 40, 18, -55 },
  { 13733, 27, 62, 40, 6, -55 },
  { 13943, 30, 13, 40, 5, -30 },
};

const GFXfont JetBrainsMono_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight66pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _JETBRAINSMONO_EXTRALIGHT66PT7B_H_
